# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA9: length 64.3
  TOP w0.081: UC1.AT4 122.52,87 v6(122.35,87)
  TOP w0.122: UD4.R7 127.88,59.83 125.89,59.83 125.78,59.72 v6(125.73,59.72) ; v6(136.13,59.72) 136.18,59.72 136.29,59.83 138.28,59.83 UD3.R7
  IN4 w0.058: v6(122.35,87) 122.07,87.28 121.01,87.28 120.24,86.51 120.24,85.68
  IN4 w0.086: 120.24,85.68 120.24,61.7 122.61,59.34 124.94,59.34 125.32,59.72 v6(125.73,59.72) 125.78,59.72 125.79,59.73 126.08,59.73 126.17,59.64 126.17,59.5 126.25,59.41 126.43,59.41 126.51,59.5 126.51,59.64 126.6,59.73 127.37,59.73 127.64,59.46 v7(127.81,59.46) 127.86,59.41 128.88,59.41 129.01,59.54 135.95,59.54 v6(136.13,59.72) 136.18,59.72 136.19,59.73 136.48,59.73 136.57,59.64 136.57,59.5 136.65,59.41 136.83,59.41 136.91,59.5 136.91,59.64 137,59.73 137.77,59.73 138.04,59.46 v7(138.21,59.46) 138.35,59.46 138.61,59.21 138.89,59.21 139.16,59.48 141.2,59.48 141.8,58.89 v7(142.84,58.89)
  BOTTOM w0.122: v7(138.21,59.46) 137.83,59.85 UD1.R7 ; v7(127.81,59.46) 127.43,59.85 UD2.R7
DDR_A_MA10: length 57.5
  TOP w0.081: v8(122.05,82.65) 121.99,82.71 v10(121.56,82.71) 120.14,82.71 120.14,82.7 119.53,82.7 118.44,83.79 116.71,83.79 116.25,84.24 116.25,84.9 115.97,85.18 UC1.AH2
  IN1 w0.086: v8(141.95,62.45) 141.25,61.75 138.9,61.75 138.4,62.25 v4(138.3,62.25) 138.26,62.21 136.37,62.21 136.07,62.51 135.49,62.51 135.23,62.25 v8(135.1,62.25) 134.84,62.51 134.11,62.51 133.79,62.19 132.98,62.19 132.49,61.7 132.18,61.7 132,61.88 128.37,61.88 v4(128.22,62.03) 128.19,62.03 128.02,62.21 125.97,62.21 125.67,62.51 125.15,62.51 124.88,62.25 v8(124.7,62.25) 124.44,62.51 123.07,62.51 122.76,62.82 122.76,63.3 122.82,63.36 122.82,63.51 121.7,64.64 121.7,72.78 122.16,73.25 122.16,74.82 122.08,74.91 121.92,74.91 121.82,74.81 121.82,73.73 121.73,73.65 121.56,73.65 121.47,73.73 121.47,80.84 121.77,81.13 121.77,83.02 121.85,83.11 122.17,83.11 122.4,83.34 123.62,83.34 123.74,83.22 123.74,83.03 123.66,82.95 122.59,82.95 122.4,82.76 122.16,82.76 v8(122.05,82.65)
  BOTTOM w0.122: v4(128.22,62.03) 128.17,62.03 127.95,62.25 UD2.M3
DDR_A_MA11: length 57
  TOP w0.081: UC1.AN2 119.87,85.82 v6(119.77,85.82)
  IN4 w0.058: v6(119.77,85.82) 119.86,85.73
  IN4 w0.086: 119.86,85.73 119.95,85.64 119.95,61.58 120.63,60.91 120.63,60.78 120.36,60.51 120.36,60.39 120.48,60.27 120.6,60.27 120.87,60.54 120.99,60.54 121.08,60.45 121.08,60.18 120.25,59.35 120.25,59.23 120.37,59.11 120.49,59.11 121.45,60.06 121.57,60.06 121.7,59.94 121.7,59.82 121.2,59.32 121.2,59.2 121.32,59.08 121.44,59.08 121.9,59.54 122.02,59.54 122.15,59.42 122.15,59.29 121.91,59.06 121.91,58.94 122.07,58.78 122.2,58.78 122.3,58.88 123.73,58.88 v6(123.9,59.05) 124.02,58.93 127.57,58.93 127.74,58.77 128.21,58.77 128.37,58.93 128.58,58.93 v7(128.7,59.05) 129.17,58.57 132.58,58.57 132.67,58.66 132.67,58.97 132.75,59.06 132.93,59.06 133.01,58.97 133.01,58.66 133.1,58.57 133.83,58.57 v6(134.3,59.05) 134.39,58.96 137.92,58.96 138.13,58.75 138.8,58.75 v7(139.1,59.05) 139.36,59.31 140.94,59.31 141.92,58.32 v7(142.84,58.32)
DDR_A_MA12: length 65.3
  TOP w0.081: v6(122.35,85.68) 122.45,85.78 122.94,85.78 123.14,85.98 123.14,86.36 UC1.AU4
  TOP w0.122: UD3.M7 v6(135.7,62.25) ; UD4.M7 v6(125.3,62.25)
  IN4 w0.086: v7(142.84,62.32) 142.82,62.34 139.68,62.34 139.29,61.94 138.93,61.94 138.71,61.72 138.21,61.72 v7(138.14,61.8) 138.11,61.82 138.11,62.07 138.04,62.15 137.31,62.15 137.2,62.03 137.2,61.97 137.26,61.9 137.26,61.82 137.19,61.75 136.9,61.75 136.81,61.83 136.81,62.07 136.72,62.16 136.55,62.16 136.46,62.07 136.46,61.84 136.38,61.75 136.2,61.75 136.12,61.84 136.12,62.19 136.03,62.28 135.73,62.28 v6(135.7,62.25) 135.58,62.25 135.27,61.94 133.31,61.94 133.07,61.7 128.68,61.7 128.63,61.75 127.79,61.75 v7(127.74,61.8) 127.6,61.94 127.6,62.04 127.48,62.16 126.84,62.16 126.75,62.07 126.75,61.84 126.67,61.75 126.5,61.75 126.41,61.84 126.41,62.07 126.32,62.16 126.15,62.16 126.06,62.07 126.06,61.84 125.98,61.75 125.8,61.75 125.72,61.84 125.72,62.19 125.63,62.28 125.33,62.28 v6(125.3,62.25) 125.1,62.05 124.64,62.05 124.54,61.95 123.75,61.95 122.51,63.2 122.51,64.03 122.48,64.06 122.48,65.82 122.04,66.26 122.04,74.84 122.24,75.04 122.24,80.87 122.67,81.29 123.37,81.29 123.52,81.44 123.52,83.37 123.42,83.46 122.15,83.46 122.04,83.57 122.04,84.18 122.03,84.19 122.03,84.74 122.35,85.07 122.66,85.07 122.73,85.14 122.73,86.12 122.65,86.21 122.44,86.21 122.35,86.12 v6(122.35,85.68)
  BOTTOM w0.122: v7(138.14,61.8) 138.14,61.88 137.76,62.25 UD1.M7 ; UD2.M7 127.36,62.25 127.74,61.88 v7(127.74,61.8)
DDR_A_MA13: length 68.1
  TOP w0.081: UC1.AE3 113.46,86.09 113.74,85.81 113.74,84.67 113.73,84.66 113.73,83.64 115.3,82.07 v10(115.72,82.07) 116.54,81.26 118.11,81.26 v8(118.14,81.23)
  TOP w0.122: RD179.1 141.71,57.3 140.52,58.49 139.66,58.49 UD3.T8 138.67,58.61 136.76,58.61 v1(136.75,58.63) ; UD4.T8 128.27,58.61 v1(124.54,58.61)
  IN1 w0.086: v1(136.75,58.63) v4(136.3,58.63) 136.29,58.61 134.94,58.61 134.77,58.78 131.46,58.78 131.02,58.34 129.87,58.34 129.86,58.35 127.83,58.35 127.53,58.65 v4(127.28,58.65) 127.24,58.61 125.79,58.61 125.71,58.53 125.71,58.48 125.62,58.4 125.45,58.4 125.36,58.48 125.36,58.53 125.27,58.61 v1(124.54,58.61) 124.47,58.55 123.47,58.55 122.65,59.37 121.68,59.37 118.14,62.91 v8(118.14,81.23)
  BOTTOM w0.122: UD2.T8 124.35,58.6 127.23,58.6 v4(127.28,58.65) ; UD1.T8 134.3,58.39 134.42,58.27 135.05,58.27 135.86,59.08 137.54,59.08 137.66,58.96 137.66,58.42 137.51,58.27 136.44,58.27 136.3,58.42 v4(136.3,58.63)
DDR_A_MA14: length 58.4
  TOP w0.081: v8(122.05,81.94) 121.93,81.81 120.78,81.81 120.6,81.99 119.57,81.99 118.12,83.45 116.42,83.45 115.69,84.17 115.69,86.28 UC1.AG4
  TOP w0.122: v8(134.7,63.07) 134.67,63.1 134.33,63.08 UD3.L2 ; v8(124.28,63.15) 124.2,63.06 UD4.L2
  IN1 w0.058: v8(122.05,81.94) 122.3,81.68 122.3,80.24 122.27,80.21 122.27,80.09
  IN1 w0.086: 122.27,80.09 122.27,79.08 122.4,78.95 122.77,78.95 122.86,78.86 122.86,78.69 122.77,78.61 122.16,78.61 122.07,78.52 122.07,78.35 122.16,78.26 123.17,78.26 123.26,78.17 123.26,78 123.17,77.92 122.16,77.92 122.07,77.83 122.07,77.66 122.16,77.57 123.05,77.57 123.14,77.48 123.14,77.31 123.05,77.22 122.16,77.22 122.07,77.14 122.07,76.97 122.16,76.88 123.02,76.88 123.26,76.64 123.26,75.51 122.74,75 122.74,73.01 122.27,72.54 122.27,64.66 123.07,63.86 123.22,63.86 123.76,63.32 124.1,63.32 v8(124.28,63.15) 124.46,63.32 124.87,63.32 124.88,63.31 125.43,63.31 125.78,62.96 128.18,62.96 v4(128.32,62.82) 128.55,62.59 128.78,62.59 128.86,62.67 128.86,62.89 128.95,62.97 129.12,62.97 129.21,62.89 129.21,62.75 129.29,62.66 133.63,62.66 134.06,63.1 134.67,63.1 v8(134.7,63.07) 134.7,63.12 134.88,63.31 135.22,63.31 135.31,63.22 135.52,63.22 135.6,63.31 136.22,63.31 136.57,62.96 138.58,62.96 v4(138.72,62.82) 138.79,62.82 139.22,62.38 140.74,62.38 v8(141.95,63.59)
  BOTTOM w0.122: v4(138.72,62.82) 138.77,62.82 139,63.05 UD1.L2 ; UD2.L2 128.6,63.05 128.37,62.82 v4(128.32,62.82)
DDR_A_MA15: length 70.2
  TOP w0.081: v8(121.79,80.65) 121.77,80.67 v10(116.97,80.67) 116.01,80.67 112.72,83.96 UC1.AD1
  TOP w0.122: UD4.M8 128.3,62.65 v8(124.87,62.65) ; UD3.M8 138.7,62.65 v8(135.27,62.65)
  IN1 w0.086: v8(141.95,63.02) 141.01,62.08 139.04,62.08 138.48,62.64 v4(137.68,62.64) 137.67,62.65 136.26,62.65 136.12,62.79 135.41,62.79 v8(135.27,62.65) 135.13,62.79 134,62.79 133.67,62.46 131.65,62.46 131.57,62.37 131.57,62.19 131.48,62.11 131.31,62.11 131.22,62.19 131.22,62.37 131.13,62.46 130.96,62.46 130.91,62.41 127.46,62.41 127.28,62.59 v4(127.28,62.64) 127.18,62.74 127.06,62.74 126.97,62.65 126.97,62.47 126.88,62.38 126.71,62.38 126.62,62.47 126.62,62.69 126.53,62.78 126.41,62.78 126.32,62.69 126.32,62.47 126.24,62.38 126.06,62.38 125.98,62.47 125.98,62.6 125.89,62.68 125.7,62.68 125.59,62.79 125.21,62.79 125.16,62.84 124.95,62.84 124.87,62.76 v8(124.87,62.65) 124.81,62.7 123.81,62.7 123.32,63.2 123.32,63.52 123.14,63.69 122.89,63.69 121.98,64.6 121.98,72.66 122.45,73.13 122.45,75.11 122.37,75.2 121.85,75.2 121.77,75.28 121.77,75.46 121.85,75.54 122.65,75.54 122.73,75.63 122.73,75.8 122.65,75.89 121.85,75.89 121.77,75.97 121.77,76.15 121.85,76.23 122.49,76.23 122.58,76.32 122.58,76.5 122.49,76.59 121.86,76.59 121.76,76.69 121.76,80.62 v8(121.79,80.65)
  BOTTOM w0.122: UD1.M8 134.69,62.64 v4(137.68,62.64) ; UD2.M8 124.29,62.64 v4(127.28,62.64)
DDR_A_MA16: length 69.7
  TOP w0.076: v1(122.81,82.64) 122.24,83.21 119.53,83.21 118.62,84.12 117.49,84.12 117.14,84.47 117.14,84.93 117,85.07 116.69,85.07 116.42,85.34 116.42,85.62 116.25,85.79 116.25,86.2 115.97,86.48 UC1.AH4
  TOP w0.122: UD3.L8 138.72,63.43 135.48,63.43 v8(135.41,63.5) ; UD4.L8 128.3,63.45 125.15,63.45 125.04,63.55 125.02,63.55 v8(124.99,63.58)
  IN1 w0.058: 122.56,80.09 122.56,82.06 122.43,82.2 122.43,82.32 122.75,82.64 v1(122.81,82.64)
  IN1 w0.086: 122.56,80.09 122.56,79.33 122.65,79.24 123.95,79.24 124.06,79.12 124.06,78.88 123.95,78.76 123.64,78.76 123.55,78.67 123.55,74.93 123.46,74.84 123.12,74.84 123.04,74.76 123.04,74.59 123.12,74.5 123.46,74.5 123.55,74.41 123.55,74.24 123.46,74.15 123.12,74.15 123.04,74.07 123.04,73.89 123.12,73.81 123.46,73.81 123.55,73.72 123.55,73.54 123.47,73.46 123.12,73.46 123.03,73.37 123.03,73.26 123.16,73.13 123.16,73.02 122.56,72.42 122.56,64.62 123.15,64.04 123.29,64.04 123.74,63.59 124.07,63.59 124.19,63.71 124.47,63.71 124.59,63.59 124.96,63.59 124.97,63.58 v8(124.99,63.58) 125.09,63.48 125.28,63.48 125.35,63.55 125.35,63.61 125.43,63.69 125.7,63.69 125.78,63.6 125.78,63.23 125.89,63.13 126.07,63.13 126.15,63.22 126.15,63.6 126.24,63.69 126.39,63.69 126.47,63.6 126.47,63.22 126.56,63.13 126.73,63.13 126.82,63.22 126.82,63.45 126.91,63.54 127.19,63.54 v4(127.28,63.45) 127.58,63.15 129.29,63.15 129.55,62.88 133.52,62.88 133.95,63.31 134.59,63.31 134.8,63.53 135.38,63.53 v8(135.41,63.5) 135.43,63.48 136.42,63.48 136.47,63.43 137.66,63.43 v4(137.68,63.45) 137.98,63.15 138.8,63.15 139.07,62.88 140.66,62.88 v8(141.95,64.16)
  BOTTOM w0.122: v4(127.28,63.45) 124.3,63.45 UD2.L8 ; v4(137.68,63.45) 134.7,63.45 UD1.L8
DDR_A_ODT0: length 59.7
  TOP w0.081: UC1.AD3 113.09,85.71 113.09,84.04 116.08,81.05 117.51,81.05 117.66,80.9 121.92,80.9 122.38,80.44
  TOP w0.122: 122.38,80.44 122.73,80.09 v8(122.89,80.09)
  IN1 w0.086: v8(122.89,80.09) 122.89,79.63 122.99,79.53 124.54,79.53 124.73,79.34 124.73,78.56 124.65,78.47 123.94,78.47 123.84,78.37 123.84,78.22 123.92,78.13 124.58,78.13 124.66,78.04 124.66,77.87 124.58,77.78 123.92,77.78 123.84,77.7 123.84,77.53 123.92,77.44 124.63,77.44 124.71,77.35 124.71,77.18 124.63,77.09 123.92,77.09 123.84,77.01 123.84,73.28 122.85,72.3 122.85,64.65 123.26,64.25 123.92,64.25 124.26,63.91 124.64,63.91 v8(124.7,63.85) 124.78,63.93 125,63.93 125.08,63.86 126.7,63.86 126.79,63.95 126.79,64.15 126.87,64.24 127.02,64.24 127.13,64.13 127.13,63.8 127.22,63.71 127.34,63.71 127.51,63.87 127.62,63.87 127.77,63.71 127.77,63.41 127.86,63.32 128.1,63.32 128.18,63.41 v4(128.18,63.57) 129.27,63.57 129.7,63.14 130.29,63.14 130.38,63.23 130.38,63.64 130.46,63.73 130.64,63.73 130.72,63.64 130.72,63.23 130.81,63.14 130.98,63.14 131.07,63.23 131.07,63.44 131.15,63.53 131.33,63.53 131.41,63.44 131.41,63.23 131.5,63.14 133.42,63.14 133.81,63.53 134.37,63.53 134.69,63.85 v8(135.1,63.85) 135.47,63.8 136.15,63.73 136.4,63.72 137.69,63.72 138.03,63.66 v4(138.71,63.51) 138.88,63.51 139.25,63.14 140.36,63.14 v8(141.95,64.73)
  BOTTOM w0.122: UD2.K3 v4(128.18,63.57) ; v4(138.71,63.51) 138.71,63.73 138.59,63.85 UD1.K3
DDR_A_PARITY: length 54.8
  TOP w0.081: v8(118.05,82.71) 117.92,82.71 117.92,82.7 v10(117.47,82.7) 116.9,82.7 115.52,84.09 115.52,85.55 115.23,85.83 UC1.AG3
  IN1 w0.086: v8(118.05,82.71) 118.56,82.2 118.56,80.99 118.49,80.92 118.49,62.8 119.65,61.64 119.77,61.64 119.94,61.8 120.06,61.8 120.19,61.68 120.19,61.56 120.02,61.39 120.02,61.27 120.14,61.15 120.26,61.15 120.42,61.3 120.54,61.3 120.66,61.18 120.66,61.06 120.51,60.9 120.51,60.78 120.66,60.63 120.78,60.63 120.92,60.78 121.04,60.78 121.16,60.65 121.16,60.53 121.02,60.39 121.02,60.27 121.14,60.14 121.27,60.14 121.42,60.3 121.54,60.3 121.66,60.18 121.66,60.05 121.51,59.9 121.51,59.78 121.7,59.59 122.91,59.59 123.72,58.78 124.16,58.78 124.43,59.05 v8(124.7,59.05) 125.03,59.05 125.12,58.96 125.12,58.89 125.2,58.8 125.38,58.8 125.46,58.89 125.46,58.96 125.55,59.05 125.72,59.05 125.81,58.96 125.81,58.89 125.9,58.8 126.07,58.8 126.15,58.89 126.15,59.01 126.24,59.1 126.41,59.1 126.5,59.01 126.5,58.89 126.59,58.8 126.76,58.8 126.85,58.89 126.85,58.96 126.93,59.05 v4(127.9,59.05) 128.21,58.74 129.96,58.74 130.01,58.69 130.88,58.69 131.33,59.15 132.37,59.15 132.58,59.35 134,59.35 134.04,59.31 134.41,59.31 134.67,59.05 v8(135.1,59.05) 135.19,58.96 138.21,58.96 v4(138.3,59.05) 138.39,58.96 138.71,58.96 139.28,58.38 141.88,58.38 v8(141.95,58.45)
DDR_B_ACT#: length 59.9
  IN1 w0.058: v8(122.62,90) 122.62,90.97 121.89,91.7 114.36,91.7 114.26,91.59
  IN1 w0.086: 114.26,91.59 113.14,90.48 113.14,85.7 113.92,84.93 113.92,74.21 114.24,73.89 114.24,72.76 114.55,72.45 114.55,66.85 114.27,66.58 114.27,64.54 113.73,64 113.73,63.92 113.23,63.43 112.78,63.43 v4(112.4,63.05) 111.95,63.5 109.56,63.5 109.42,63.37 109.42,63.27 v7(109.2,63.05) 109.13,63.12 104.3,63.12 104.18,62.99 103.96,62.99 103.83,63.12 103.61,63.12 103.48,62.99 103.27,62.99 103.14,63.12 102.92,63.12 102.79,62.99 102.58,62.99 102.45,63.12 102.07,63.12 v4(102,63.05) 101.55,63.5 99.25,63.5 v7(98.8,63.05) 98.73,63.12 98.04,63.12 97.74,62.82 96.06,62.82 95.66,63.22 v8(94.4,63.22)
DDR_B_ALERT#: length 70.6
  TOP w0.081: UC1.AR8 121.42,89.07 119.61,89.07 v6(119.43,88.88)
  TOP w0.122: RD202.2 116.77,60.59 v5(116.77,61.15) ; UD8.P9 103.2,60.25 99.45,60.25 v6(99.43,60.23) ; v6(109.83,60.23) 109.85,60.25 113.6,60.25 UD7.P9
  IN4 w0.058: v6(119.43,88.88) 118.93,89.38 118.3,89.38 118.05,89.12 118.05,88.84 117.96,88.75
  IN4 w0.086: v6(99.43,60.23) 99.53,60.12 v8(101.69,60.12) 103.2,60.12 103.86,59.46 107.82,59.46 108.36,60 109.6,60 v6(109.83,60.23) 109.91,60.15 112.06,60.15 v8(112.09,60.12) 113.87,60.12 114.53,60.78 115.69,60.78 116.06,61.15 v5(116.77,61.15) 116.46,61.46 116.46,61.77 118.3,63.61 118.3,71.78 118.05,72.04 118.05,86.17 117.69,86.53 117.69,86.77 117.69,87.09 118.06,87.47 118.06,88.07 117.96,88.17 117.96,88.75
  BOTTOM w0.122: v8(112.09,60.12) 112.01,60.2 108.05,60.2 UD5.P9 ; v8(101.69,60.12) 101.61,60.2 97.65,60.2 UD6.P9
DDR_B_BA0: length 62
  TOP w0.122: UD7.N2 108.4,61.33 108.66,61.06 v6(108.69,61.06) ; v6(98.29,61.06) 98.26,61.06 98,61.33 UD8.N2
  IN1 w0.086: v6(98.29,61.06) 97.97,61.06 97.8,60.9 94.47,60.9 v8(94.41,60.96)
  IN4 w0.086: v6(116.22,89.35) 116.04,89.35 115.95,89.43 115.95,89.82 116.14,90.01 116.27,90.01 116.44,89.84 116.44,89.72 116.43,89.72 116.43,89.55 116.58,89.41 116.58,89.17 116.43,89.03 116.43,88.88 116.58,88.73 116.58,87.03 116.82,86.79 116.82,86.17 117.1,85.88 117.1,85.8 117.02,85.71 116.5,85.71 116.41,85.62 116.41,85.45 116.5,85.36 117.02,85.36 117.1,85.28 117.1,85.11 117.02,85.02 116.5,85.02 116.41,84.93 116.41,84.76 116.5,84.67 117.02,84.67 117.1,84.59 117.1,84.41 117.02,84.33 116.5,84.33 116.41,84.24 116.41,84.07 116.5,83.98 117.02,83.98 117.1,83.9 117.1,83.72 117.02,83.64 116.5,83.64 116.41,83.55 116.41,83.38 116.5,83.29 117.02,83.29 117.1,83.21 117.1,83.03 117.02,82.95 116.5,82.95 116.41,82.86 116.41,82.69 116.5,82.6 117.02,82.6 117.1,82.51 117.1,82.34 117.02,82.26 116.5,82.26 116.41,82.17 116.41,82 116.5,81.91 117.02,81.91 117.1,81.82 117.1,71.4 117.47,71.03 117.47,65.82 116.83,65.17 116.83,63.19 115.29,61.65 v8(112.8,61.65) 112.73,61.57 111.99,61.57 111.91,61.65 111.53,61.65 111.25,61.37 108.99,61.37 v6(108.69,61.06) 108.39,60.77 103.97,60.77 103.29,61.45 102.6,61.45 v8(102.4,61.65) 102.33,61.57 101.55,61.57 101.47,61.65 101.02,61.65 100.79,61.42 98.64,61.42 v6(98.29,61.06)
  BOTTOM w0.122: UD6.N2 v8(102.4,61.65) ; UD5.N2 v8(112.8,61.65)
DDR_B_BA1: length 77.2
  TOP w0.081: v6(115.67,89.66) 115.78,89.52 115.92,89.5 116.29,89.77 116.31,89.88 UC1.AH9
  TOP w0.122: UD8.N8 102.4,61.85 v6(99.43,61.85) ; UD7.N8 112.8,61.85 v6(109.83,61.85)
  IN4 w0.086: v7(93.26,61.43) 93.44,61.24 97.82,61.24 98.42,61.85 v6(99.43,61.85) v8(101.69,61.85) 101.79,61.95 102.47,61.95 102.7,61.72 103.37,61.72 103.81,61.28 108.39,61.28 108.71,61.6 109.5,61.6 109.75,61.85 v6(109.83,61.85) 109.85,61.83 112.07,61.83 v8(112.09,61.85) 112.22,61.98 112.98,61.98 113.13,61.82 113.36,61.82 113.46,61.93 113.46,62.09 113.53,62.16 113.79,62.16 113.88,62.07 113.88,61.94 113.96,61.85 114.14,61.85 114.22,61.94 114.22,62.07 114.31,62.16 114.48,62.16 114.57,62.07 114.57,61.99 114.65,61.9 114.83,61.9 114.91,61.99 114.91,62.06 115.3,62.45 115.43,62.45 115.56,62.32 115.68,62.32 115.8,62.44 115.8,62.56 115.67,62.69 115.67,62.82 116.02,63.16 116.14,63.16 116.24,63.05 116.37,63.05 116.49,63.18 116.49,63.3 116.38,63.41 116.38,63.53 116.54,63.69 116.54,65.29 117.16,65.91 117.16,70.66 116.79,71.02 116.79,78.09 116.71,78.18 116.22,78.18 116.13,78.26 116.13,78.44 116.22,78.52 116.71,78.52 116.79,78.61 116.79,78.78 116.71,78.87 116.22,78.87 116.13,78.95 116.13,79.13 116.22,79.21 116.71,79.21 116.79,79.3 116.79,79.47 116.71,79.56 116.22,79.56 116.13,79.65 116.13,79.82 116.22,79.9 116.71,79.9 116.79,79.99 116.79,80.16 116.71,80.25 116.22,80.25 116.13,80.34 116.13,80.51 116.22,80.6 116.71,80.6 116.79,80.68 116.79,80.85 116.71,80.94 116.22,80.94 116.13,81.03 116.13,81.2 116.22,81.29 116.71,81.29 116.79,81.37 116.79,81.52 116.69,81.62 116.21,81.62 116.11,81.71 116.11,85.94 116.21,86.03 116.39,86.03 116.53,86.17 116.53,86.35 116.44,86.44 116.22,86.44 116.11,86.54 116.11,86.62 116.29,86.79 116.29,88.65 116.15,88.79 116.15,89 116.1,89.06 115.88,89.06 115.67,89.27 115.49,89.27 115.22,89.54 115.22,89.72 115.33,89.83 115.5,89.83 v6(115.67,89.66)
  BOTTOM w0.122: v8(101.69,61.85) 98.4,61.85 UD6.N8 ; UD5.N8 108.8,61.85 v8(112.09,61.85)
DDR_B_BG0: length 58.8
  IN1 w0.058: v8(121.71,90) 122.05,90.34 122.05,91.32 121.81,91.55 119.36,91.55 119.18,91.37
  IN1 w0.086: 119.18,91.37 116.29,91.37 114.94,90.01 114.85,90.01 114.38,89.54 114.38,85.86 114.64,85.6 114.64,76.23 115.13,75.74 115.13,66.61 114.87,66.35 114.87,63.51 114.25,62.89 113.84,62.89 113.44,62.49 v4(113.2,62.25) 113.01,62.44 111.46,62.44 111.35,62.33 109.58,62.33 109.37,62.54 109.07,62.54 108.86,62.33 108.69,62.33 108.6,62.25 v7(108.4,62.25) 108.07,62.58 106.17,62.58 105.79,62.19 105.41,62.19 105.28,62.32 102.87,62.32 v4(102.8,62.25) 102.47,62.58 101.65,62.58 101.52,62.44 101.16,62.44 101.04,62.32 99.15,62.32 98.96,62.51 98.69,62.51 98.5,62.32 98.07,62.32 v7(98,62.25) 96.32,62.25 96.02,61.95 94.54,61.95 v8(94.41,62.07)
DDR_B_BG1: length 59.3
  TOP w0.122: 116.73,61.94 RD250.2 ; 116.73,61.94 117.09,61.94 117.28,62.13 117.28,62.77 117.16,62.89 114.81,62.89 114.62,62.7 113.79,62.7 113.6,62.89 113.6,64.04 113.35,64.29 113.11,64.29 112.84,64.56 112.84,64.66 112.53,64.97 109.07,64.97 108.84,64.74 108.84,64.63 108.43,64.23 107.38,64.23 106.81,63.66 105.35,63.66 105.11,63.9 v5(105.11,64.1) ; 116.73,61.94 v8(117.34,61.33) ; RD255.1 94.83,64.99 RD252.2 95.34,64.48 95.62,64.48 v5(95.68,64.42)
  IN1 w0.086: v5(105.11,64.1) 105.04,64.16 99.58,64.16 99.31,63.89 98.57,63.89 98.17,64.29 96.82,64.29 96.33,64.29 96.2,64.42 v5(95.68,64.42) ; v8(121.71,88.7) 121.71,88.33 117.73,84.36 117.73,61.73 v8(117.34,61.33)
  BOTTOM w0.122: RD246.2 105.11,63.99 v5(105.11,64.1) ; v5(95.68,64.42) 95.68,64.33 95.19,63.84 RD248.2
DDR_B_CKE0: length 65.2
  IN1 w0.058: 114.1,91.85 122.14,91.85 122.91,91.08 122.91,89.64 v8(122.62,89.35)
  IN1 w0.086: v8(94.42,64.37) 94.8,63.99 96.9,63.99 97.03,64.11 97.73,64.11 v8(98,63.85) 98.29,63.85 98.43,63.72 102.02,63.72 102.11,63.8 102.11,63.92 102.17,63.99 102.66,63.99 v4(102.8,63.85) 103.19,63.46 104.23,63.46 104.31,63.55 104.31,63.64 104.4,63.73 104.57,63.73 104.66,63.64 104.66,63.55 104.74,63.46 104.92,63.46 105,63.55 105,63.64 105.09,63.73 105.26,63.73 105.35,63.64 105.35,63.55 105.43,63.46 105.61,63.46 105.69,63.55 105.69,63.64 105.78,63.73 105.95,63.73 106.04,63.64 106.04,63.55 106.13,63.46 108.01,63.46 v8(108.4,63.85) 109.15,63.85 109.16,63.86 113.09,63.86 113.1,63.85 v4(113.2,63.85) 113.46,64.11 113.46,64.82 113.74,65.1 113.74,66.3 113.69,66.35 113.69,66.92 113.78,67 114.17,67 114.26,67.09 114.26,67.26 114.17,67.35 113.55,67.35 113.46,67.44 113.46,67.61 113.55,67.69 114.17,67.69 114.26,67.78 114.26,67.95 114.17,68.04 113.55,68.04 113.46,68.13 113.46,68.3 113.55,68.39 114.17,68.39 114.26,68.47 114.26,72.33 113.46,73.13 113.46,78.28 113.38,78.37 113.27,78.37 113.18,78.45 113.18,78.63 113.27,78.71 113.38,78.71 113.46,78.8 113.46,78.97 113.38,79.06 113.27,79.06 113.18,79.15 113.18,79.32 113.27,79.4 113.38,79.4 113.46,79.49 113.46,84.56 112.65,85.37 112.65,88.36 112.85,88.56 112.85,90.6 114.1,91.85
DDR_B_CLK0: length 73
  TOP w0.081: UC1.AM9 119.09,89.87 119.58,89.87 119.76,89.69 120.22,89.69 v6(120.36,89.82)
  TOP w0.125: UD7.K7 112.25,64 109.59,64 109.41,64.17 109.08,64.17 v6(109.02,64.24) ; UD8.K7 101.83,64.02 99.1,64.02 98.88,64.24 v6(98.62,64.24)
  IN4 w0.058: v6(120.36,89.82) 120.53,89.99 120.53,89.99 120.55,90.01 120.77,90.01 120.9,90.15 120.9,90.63 119.94,91.59 115.29,91.59 113.41,89.72 113.41,87.53
  IN4 w0.086: v7(94.41,63.75) 94.62,63.55 95.78,63.55 96.34,64.11 98.49,64.11 v6(98.62,64.24) 98.81,64.24 99.14,64.57 101.66,64.57 101.92,64.32 102.21,64.32 v7(102.31,64.41) 102.43,64.29 103.3,64.29 103.85,63.74 105.51,63.74 106.89,63.74 106.98,63.83 106.98,64 107.06,64.09 107.23,64.09 107.31,64 107.31,63.83 107.41,63.74 107.63,63.74 107.69,63.8 107.69,63.94 107.66,63.97 107.66,64.2 107.75,64.29 107.86,64.29 107.95,64.2 107.95,64.18 108.01,64.11 108.28,64.11 108.33,64.16 108.33,64.35 108.39,64.42 108.58,64.42 108.65,64.35 108.65,64.18 108.71,64.11 108.89,64.11 v6(109.02,64.24) 109.06,64.28 109.26,64.28 109.55,64.57 112.06,64.57 112.12,64.52 112.14,64.52 112.34,64.32 112.61,64.32 v7(112.71,64.41) 112.71,64.41 112.82,64.52 112.97,64.52 113.67,65.22 113.67,74.55 113.51,74.7 113.51,75.97 113.41,76.08 113.41,76.46 113.37,76.5 113.37,87.49 113.41,87.53
  BOTTOM w0.125: UD6.K7 98.91,63.96 101.64,63.96 101.92,64.24 102.18,64.24 102.31,64.36 v7(102.31,64.41) ; UD5.K7 109.34,63.99 112.06,63.99 112.27,64.19 112.48,64.19 v7(112.71,64.41)
DDR_B_CLK#0: length 74
  TOP w0.081: v6(120.33,90.39) 120.29,90.35 119.86,90.35 119.77,90.27 119.77,90.1 UC1.AN9
  TOP w0.125: v4(99.33,64.32) 99.39,64.25 102.14,64.25 UD8.K8 ; UD7.K8 112.56,64.24 109.91,64.24 109.83,64.32 v4(109.73,64.32)
  IN4 w0.058: 113.52,87.42 113.53,87.43 113.53,87.45 113.55,87.47 113.55,87.59 113.54,87.6 113.54,89.66 115.34,91.47 119.89,91.47 120.78,90.58 120.78,90.2 120.72,90.13 120.59,90.13 v6(120.33,90.39)
  IN4 w0.086: v7(94.41,63.19) 94.62,63.4 95.2,63.4 95.2,63.4 95.84,63.4 96.41,63.96 98.62,63.96 98.76,63.96 99.14,64.34 99.3,64.34 v4(99.33,64.32) 99.63,64.32 99.69,64.25 99.69,63.97 99.77,63.89 99.93,63.89 100,63.96 100,64.32 100.09,64.41 100.26,64.41 100.35,64.32 100.35,63.97 100.43,63.88 100.61,63.88 100.69,63.97 100.69,64.32 100.78,64.41 101.46,64.41 v7(101.57,64.3) 101.73,64.14 102.43,64.14 102.43,64.14 103.23,64.14 103.79,63.59 107.69,63.59 108.07,63.96 109.15,63.96 109.5,64.32 v4(109.73,64.32) 109.8,64.39 109.97,64.39 110.06,64.31 110.06,64 110.14,63.91 110.34,63.91 110.45,64.02 110.45,64.32 110.54,64.41 110.69,64.41 110.77,64.32 110.77,63.97 110.86,63.88 111.01,63.88 111.09,63.97 111.09,64.28 111.18,64.37 111.9,64.37 v7(111.97,64.3) 112.16,64.11 112.77,64.11 113.82,65.16 113.82,74.62 113.67,74.77 113.67,76.04 113.56,76.14 113.56,76.57 113.52,76.61 113.52,87.42
  BOTTOM w0.125: v7(101.57,64.3) 101.46,64.19 98.45,64.19 98.11,63.85 UD6.K8 ; UD5.K8 108.6,63.85 108.94,64.19 109.24,64.19 109.25,64.2 111.98,64.2 111.98,64.29 v7(111.97,64.3)
DDR_B_CS#0: length 76.9
  TOP w0.122: v8(99.09,62.78) 99.11,62.78 99.28,62.94 101.89,62.94 UD8.L7 ; UD7.L7 112.29,62.94 109.68,62.94 109.51,62.78 v8(109.49,62.78)
  IN1 w0.086: v8(94.4,62.66) 94.55,62.51 95.58,62.51 95.67,62.6 97.8,62.6 98.12,62.92 98.53,62.92 98.67,62.78 v8(99.09,62.78) 99.11,62.78 99.25,62.92 99.75,62.92 99.92,63.09 100.09,63.09 100.18,63.01 100.18,62.75 100.27,62.66 100.44,62.66 100.53,62.75 100.53,63.16 100.61,63.25 100.79,63.25 100.87,63.16 100.87,62.72 100.95,62.64 101.31,62.64 101.36,62.69 v4(101.36,63.1) 101.69,62.77 105.89,62.77 106.02,62.89 108.68,62.89 108.69,62.91 108.91,62.91 109.08,62.74 109.45,62.74 v8(109.49,62.78) 109.65,62.94 110.13,62.94 110.24,63.05 110.24,63.21 110.32,63.3 110.49,63.3 110.58,63.21 110.58,62.65 110.67,62.56 110.84,62.56 110.93,62.65 110.93,63.19 111.01,63.27 111.19,63.27 111.27,63.19 111.27,62.77 111.35,62.69 111.71,62.69 111.76,62.74 v4(111.76,63.1) 111.89,63.1 112.29,62.69 112.61,62.69 112.75,62.83 112.75,63.07 112.85,63.17 112.99,63.17 113.07,63.09 113.07,63 113.16,62.92 113.33,62.92 113.42,63 113.42,63.09 113.51,63.17 114.07,63.17 114.58,63.68 114.58,66.47 114.84,66.73 114.84,72.96 114.75,73.05 114.61,73.05 114.53,73.13 114.53,73.31 114.61,73.39 114.75,73.39 114.84,73.48 114.84,73.65 114.75,73.74 114.61,73.74 114.53,73.82 114.53,74 114.61,74.08 114.75,74.08 114.84,74.17 114.84,74.33 114.75,74.41 114.44,74.41 114.35,74.5 114.35,74.67 114.44,74.76 114.75,74.76 114.84,74.84 114.84,75.02 114.75,75.1 114.44,75.1 114.35,75.19 114.35,75.36 114.44,75.45 114.75,75.45 114.84,75.54 114.84,75.62 114.69,75.77 114.45,75.77 114.35,75.88 114.35,85.48 114.09,85.74 114.09,86.31 113.96,86.44 113.52,86.44 113.43,86.53 113.43,86.7 113.52,86.79 113.99,86.79 114.07,86.88 114.07,87.05 113.99,87.14 113.52,87.14 113.43,87.22 113.43,87.4 113.52,87.48 113.99,87.48 114.07,87.57 114.07,87.74 113.99,87.83 113.52,87.83 113.43,87.91 113.43,88.09 113.52,88.17 113.99,88.17 114.07,88.26 114.07,88.43 113.99,88.52 113.52,88.52 113.43,88.6 113.43,89.1 113.59,89.26 113.59,89.38 113.43,89.54 113.43,89.74 113.52,89.83 113.65,89.83 113.87,89.61 114.02,89.61 114.12,89.72 114.12,89.84 113.59,90.37 113.59,90.5 113.69,90.59 113.81,90.59 114.33,90.07 114.45,90.07 114.58,90.19 114.58,90.32 114.17,90.72 114.17,90.86 114.3,90.99 114.45,90.99 114.94,90.5 115.06,90.5 115.2,90.65 115.2,90.77 115.11,90.86 115.11,91.19 114.94,91.37 114.46,91.37 v8(114.39,91.3)
  BOTTOM w0.122: v4(101.36,63.1) 101.31,63.05 UD6.L7 ; v4(111.76,63.1) 111.71,63.05 UD5.L7
DDR_B_D0: length 18.8
  IN1 w0.058: v8(110.94,84.79) 112.17,83.56 112.17,81.56 112.11,81.5 111.91,81.5 111.85,81.44 111.85,81.32 111.91,81.26 112.11,81.26 112.17,81.21 112.17,81.09 112.11,81.03 111.91,81.03 111.85,80.97 111.85,80.86 111.91,80.8 112.11,80.8 112.17,80.74 112.17,80.62 112.11,80.56 111.91,80.56 111.85,80.51 111.85,80.39 111.91,80.33 112.11,80.33 112.17,80.27 112.17,80.15 112.11,80.1 111.91,80.1 111.85,80.04 111.85,79.92 111.91,79.86 112.11,79.86 112.17,79.8 112.17,79.69 112.11,79.63 111.91,79.63 111.85,79.57 111.85,79.45 111.91,79.4 112.11,79.4 112.17,79.34 112.17,79.22 112.11,79.16 111.91,79.16 111.85,79.1 111.85,78.99 111.91,78.93 112.11,78.93 112.17,78.87 112.17,78.75 112.11,78.69 111.91,78.69 111.85,78.64 111.85,72.86 113.2,71.52 v8(113.2,70.25)
DDR_B_D1: length 19.1
  IN1 w0.058: v8(110.94,85.44) 110.94,85.24 112.43,83.75 112.43,78.41 112.37,78.35 112.17,78.35 112.11,78.29 112.11,78.18 112.17,78.12 112.37,78.12 112.43,78.06 112.43,77.94 112.37,77.88 112.17,77.88 112.11,77.82 112.11,77.71 112.17,77.65 112.37,77.65 112.43,77.59 112.43,77.47 112.37,77.42 112.17,77.42 112.11,77.36 112.11,72.97 113.47,71.61 113.47,70 113.35,69.88 112.83,69.88 v8(112.4,69.45)
DDR_B_D2: length 20
  IN1 w0.058: v8(110.2,86.74) 109.81,86.34 109.81,84.02 110.18,83.65 110.18,70.42 110.12,70.36 109.96,70.36 109.91,70.42 109.91,71.77 109.85,71.83 109.73,71.83 109.67,71.77 109.67,70.95 109.61,70.89 109.26,70.89 109.2,70.95 v8(109.2,71.05)
DDR_B_D3: length 20.4
  IN1 w0.058: v8(108.4,69.45) 108.78,69.83 108.78,71.29 109.26,71.77 109.26,71.85 108.74,72.37 108.74,72.45 108.83,72.53 108.91,72.53 109.42,72.02 109.51,72.02 109.92,72.43 109.92,83.56 109.67,83.81 109.67,86.85 v8(110.2,87.39)
DDR_B_D4: length 20.6
  IN1 w0.058: v8(112.4,68.65) 113.34,69.25 113.92,69.82 113.92,71.91 112.95,72.88 112.95,84.29 112.6,85.01 111.97,85.64 111.76,85.81 111.63,85.94 111.47,86.22 111.47,86.39 v8(110.94,87.39)
DDR_B_D5: length 20.3
  IN1 w0.058: v8(110.94,86.74) 111.25,86.43 111.25,85.37 111.51,85.12 111.89,85.12 112.69,84.32 112.69,77.11 112.63,77.05 112.43,77.05 112.38,76.99 112.38,76.87 112.43,76.82 112.63,76.82 112.69,76.76 112.69,76.64 112.63,76.58 112.43,76.58 112.38,76.52 112.38,76.41 112.43,76.35 112.63,76.35 112.69,76.29 112.69,76.17 112.63,76.11 112.43,76.11 112.38,76.06 112.38,75.94 112.47,75.84 112.47,75.68 112.38,75.59 112.38,73.08 113.67,71.79 113.67,69.92 v8(113.2,69.45)
DDR_B_D6: length 18.6
  IN1 w0.058: v8(110.2,85.44) 109.96,85.19 109.96,84.28 110.44,83.8 110.44,69.57 110.32,69.45 110.17,69.45 110.11,69.51 110.11,70.05 110.05,70.11 109.94,70.11 109.88,70.05 109.88,69.51 109.82,69.45 v8(109.2,69.45)
DDR_B_D7: length 17.7
  IN1 w0.058: v8(110.2,84.79) 110.2,84.41 110.7,83.92 110.7,68.85 110.51,68.65 v8(109.2,68.65)
DDR_B_D8: length 25.5
  IN1 w0.058: v8(108.43,87.39) 108.97,86.85 108.97,84.15 109.45,83.67 109.45,73.56 108.21,72.32 108.21,69.61 108.15,69.55 108.15,69.17 108.97,68.35 111.32,68.35 111.5,68.17 111.58,68.17 111.92,68.51 112.01,68.51 112.09,68.43 112.09,68.35 111.75,68.01 111.75,67.92 112.4,67.27 v8(112.4,67.05)
DDR_B_D9: length 23.5
  IN1 w0.058: v8(112.4,65.45) 109.88,67.97 108.93,67.97 107.35,69.55 107.35,70.35 107.58,70.58 107.58,72.43 108.93,73.78 108.93,83.61 108.67,83.86 108.67,85.19 v8(108.43,85.44)
DDR_B_D10: length 22.7
  IN1 w0.058: v8(109.2,65.45) 109.2,65.8 106.2,68.8 106.2,73.05 106.48,73.33 106.48,73.41 106.33,73.56 106.33,73.64 106.41,73.73 106.5,73.73 106.64,73.58 106.73,73.58 106.81,73.66 106.81,73.74 106.66,73.89 106.66,73.97 106.74,74.06 106.83,74.06 106.97,73.91 107.06,73.91 107.14,73.99 107.14,74.07 106.99,74.22 106.99,74.3 107.07,74.39 107.16,74.39 107.31,74.24 107.39,74.24 107.5,74.35 107.5,82.41 107.69,82.6 v8(107.69,84.79)
DDR_B_D11: length 23.4
  IN1 w0.058: v8(107.69,85.44) 107.45,85.19 107.45,82.73 107.24,82.53 107.24,74.93 107.09,74.78 107,74.78 106.87,74.92 106.79,74.92 106.7,74.84 106.7,74.75 106.84,74.62 106.84,74.53 106.76,74.45 106.67,74.45 106.54,74.59 106.46,74.59 106.37,74.5 106.37,74.42 106.51,74.29 106.51,74.2 106.43,74.12 106.34,74.12 106.21,74.26 106.12,74.26 106.04,74.17 106.04,74.09 106.18,73.95 106.18,73.87 106.1,73.79 106.01,73.79 105.88,73.93 105.79,73.93 105.71,73.84 105.71,73.76 105.85,73.62 105.85,73.54 105.8,73.5 105.8,73.22 105.99,73.03 105.99,71.83 105.94,71.77 105.82,71.77 105.77,71.71 105.77,71.6 105.82,71.54 105.94,71.54 105.99,71.48 105.99,68.47 108.21,66.25 v8(108.4,66.25)
DDR_B_D12: length 23.4
  IN1 w0.058: v8(112.4,64.65) 112.4,65.05 109.66,67.78 108.9,67.78 107.21,69.48 107.21,70.41 107.29,70.5 107.29,72.51 108.66,73.89 108.66,83.51 108.43,83.75 v8(108.43,84.79)
DDR_B_D13: length 25.3
  IN1 w0.058: v8(108.43,86.74) 108.82,86.05 108.82,84.01 109.19,83.64 109.19,73.67 107.89,72.38 107.89,69.22 108.95,68.16 110.87,68.16 112.78,66.25 v8(113.2,65.45)
DDR_B_D14: length 25.1
  IN1 w0.058: v8(107.69,87.39) 107.15,86.85 107.15,83.1 106.72,82.67 106.72,75.59 105.05,73.93 105.05,72.85 104.99,72.79 104.81,72.79 104.75,72.73 104.75,72.62 104.81,72.56 104.99,72.56 105.05,72.5 105.05,68.71 106.92,66.84 106.92,66.57 108.04,65.45 v8(108.4,65.45)
DDR_B_D15: length 24.8
  IN1 w0.058: v8(107.69,86.74) 107.3,86.34 107.3,82.97 106.98,82.65 106.98,75.48 105.31,73.82 105.31,68.83 107.51,66.64 107.61,66.64 108.31,65.94 108.46,65.94 108.84,65.56 108.84,65.01 v8(109.2,64.65)
DDR_B_D16: length 25.3
  IN4 w0.058: v7(109.2,68.65) 108.67,68.65 108.39,68.93 108.33,68.93 107.49,69.76 107.49,72.85 107.92,73.27 107.92,73.29 109.88,75.25 109.88,77.5 110.3,77.92 110.3,87.69 110,87.99 110,89.25 110.16,89.41 110.16,90.72 v6(110.73,91.3)
DDR_B_D17: length 24.8
  IN4 w0.058: v6(110.73,90.65) 110.39,90.3 110.39,89.31 110.2,89.12 110.2,88.12 110.49,87.83 110.49,77.69 110.14,77.34 110.14,75.14 108.8,73.81 108.8,73.72 108.96,73.56 108.96,73.48 108.88,73.4 108.8,73.4 108.64,73.56 108.56,73.56 108.47,73.47 108.47,73.39 108.63,73.23 108.63,73.15 108.55,73.07 108.47,73.07 108.31,73.23 108.23,73.23 108.14,73.14 108.14,73.06 108.3,72.9 108.3,72.82 108.22,72.74 108.14,72.74 107.98,72.9 107.89,72.9 107.72,72.72 107.72,69.85 108.12,69.45 v7(108.4,69.45)
DDR_B_D18: length 23.4
  IN4 w0.058: v7(113.2,69.45) 113.18,69.47 113.18,71.16 113.24,71.22 113.35,71.22 113.41,71.28 113.41,71.39 113.35,71.45 113.24,71.45 113.18,71.51 113.18,71.63 113.24,71.69 113.35,71.69 113.41,71.74 113.41,71.86 113.35,71.92 113.24,71.92 113.18,71.98 113.18,72.09 113.24,72.15 113.35,72.15 113.41,72.21 113.41,72.33 113.35,72.39 113.24,72.39 113.18,72.44 113.18,74.03 112.93,74.28 112.93,88.38 112.57,88.75 112.57,90.38 v6(111.65,91.3)
DDR_B_D19: length 22.7
  IN4 w0.058: v7(112.4,68.65) 112.92,69.17 112.92,73.92 112.67,74.17 112.67,88.29 112.34,88.62 112.34,89.96 v6(111.65,90.65)
DDR_B_D20: length 22.5
  IN4 w0.058: v7(108.4,70.25) 108.15,70.5 108.15,71.86 109.45,73.16 109.53,73.16 109.82,72.87 109.9,72.87 109.98,72.95 109.98,73.04 109.7,73.32 109.7,73.4 109.78,73.49 109.86,73.49 110.15,73.2 110.23,73.2 110.31,73.28 110.31,73.37 110.03,73.65 110.03,73.73 110.11,73.82 110.19,73.82 110.48,73.53 110.56,73.53 110.65,73.61 110.65,73.7 110.36,73.98 110.36,74.07 110.66,74.37 110.66,76.59 110.93,76.86 110.93,88.05 110.73,88.24 v6(110.73,88.7)
DDR_B_D21: length 23.1
  IN4 w0.058: v6(110.73,89.35) 110.41,89.02 110.41,88.24 110.67,87.98 110.67,77.42 110.4,77.15 110.4,74.51 110.22,74.33 110.13,74.33 110.05,74.41 109.97,74.41 109.88,74.33 109.88,74.24 109.97,74.16 109.97,74.08 109.88,74 109.8,74 109.72,74.08 109.64,74.08 109.55,74 109.55,73.91 109.64,73.83 109.64,73.75 109.55,73.67 109.47,73.67 109.39,73.75 109.31,73.75 109.22,73.67 109.22,73.58 109.31,73.5 109.31,73.42 107.92,72.04 107.92,70.23 108.34,69.81 108.84,69.81 v7(109.2,69.45)
DDR_B_D22: length 21.4
  IN4 w0.058: v7(112.4,71.05) 112.4,71.09 112.46,71.15 112.67,71.15 112.73,71.21 112.73,71.33 112.67,71.39 112.46,71.39 112.4,71.45 112.4,71.59 112.46,71.65 112.69,71.65 112.75,71.71 112.75,71.83 112.69,71.88 112.46,71.88 112.4,71.94 112.4,72.06 112.46,72.12 112.69,72.12 112.75,72.18 112.75,72.29 112.69,72.35 112.46,72.35 112.4,72.41 112.4,72.53 112.46,72.59 112.62,72.59 112.66,72.63 112.66,72.78 112.62,72.82 112.46,72.82 112.4,72.88 112.4,72.99 112.46,73.05 112.59,73.05 112.65,73.11 112.65,73.23 112.59,73.29 112.46,73.29 112.4,73.35 112.4,73.46 112.46,73.52 112.62,73.52 112.66,73.56 112.66,73.7 112.6,73.75 112.39,73.75 112.15,74 112.15,76.41 112.08,76.48 112.08,88.92 v6(111.65,89.35)
DDR_B_D23: length 20.4
  IN4 w0.058: v6(111.65,88.7) 111.65,88.48 111.89,88.24 111.89,76.29 111.81,76.22 111.81,72.79 111.76,72.74 111.76,72.63 111.82,72.57 112.08,72.57 112.14,72.51 112.14,72.39 112.08,72.34 111.82,72.34 111.76,72.28 111.76,72.16 111.82,72.1 112.08,72.1 112.14,72.04 112.14,69.71 v7(112.4,69.45)
DDR_B_D24: length 32
  IN4 w0.058: v6(108.91,89.35) 109.16,89.09 109.16,78.96 108.66,78.46 108.66,75.93 106.87,74.14 106.87,74.06 107.03,73.9 107.03,73.81 106.95,73.73 106.87,73.73 106.7,73.89 106.62,73.89 106.56,73.84 106.56,73.77 106.73,73.6 106.73,73.52 106.56,73.34 106.56,69.41 108,67.97 112.39,67.97 112.9,67.46 112.9,65.15 v7(112.4,64.65)
DDR_B_D25: length 31.5
  IN4 w0.058: v7(112.4,65.45) 112.65,65.7 112.65,67.34 112.2,67.78 107.82,67.78 106.3,69.31 106.3,73.94 106.46,74.11 106.46,74.19 106.37,74.28 106.37,74.37 106.45,74.45 106.53,74.45 106.63,74.35 106.71,74.35 106.79,74.44 106.79,74.52 106.7,74.61 106.7,74.7 106.78,74.78 106.86,74.78 106.96,74.68 107.04,74.68 107.12,74.77 107.12,74.85 107.03,74.94 107.03,75.03 107.11,75.11 107.19,75.11 107.29,75.01 107.37,75.01 107.45,75.1 107.45,75.18 107.36,75.28 107.36,75.36 107.44,75.44 107.52,75.44 107.62,75.35 107.7,75.35 107.79,75.43 107.79,75.51 107.69,75.61 107.69,75.69 107.77,75.77 107.86,75.77 107.95,75.68 108.03,75.68 108.39,76.04 108.39,78.89 108.9,79.4 108.9,88.69 v6(108.91,88.7)
DDR_B_D26: length 33.3
  IN4 w0.058: v6(107.99,90.65) 107.33,89.99 107.33,87.94 106.81,87.42 106.81,77.96 106.7,77.85 106.7,77.76 106.85,77.62 106.85,77.54 106.76,77.45 106.68,77.45 106.53,77.6 106.45,77.6 106.35,77.49 106.35,77.41 106.58,77.18 106.58,77.09 106.5,77.01 106.42,77.01 106.18,77.25 106.1,77.25 106.02,77.16 106.02,77.08 106.25,76.84 106.25,76.76 106.17,76.68 106.09,76.68 105.85,76.92 105.77,76.92 105.69,76.83 105.69,76.75 105.92,76.51 105.92,76.43 105.84,76.35 105.76,76.35 105.52,76.59 105.44,76.59 105.35,76.5 105.35,76.42 105.59,76.18 105.59,76.1 105.51,76.02 105.43,76.02 105.19,76.25 105.11,76.25 105.02,76.17 105.02,76.09 105.26,75.85 105.26,75.77 103.05,73.56 103.05,70.97 103.53,70.49 103.53,70.19 108.27,65.45 v7(108.4,65.45)
DDR_B_D27: length 34.2
  IN4 w0.058: v7(109.2,64.65) 109.05,64.8 108.39,64.8 103.16,70.03 103.16,70.37 102.74,70.79 102.74,73.62 103.54,74.42 103.54,75.07 103.74,75.27 103.82,75.27 104.06,75.03 104.15,75.03 104.23,75.11 104.23,75.19 103.99,75.43 103.99,75.52 104.07,75.6 104.15,75.6 104.39,75.36 104.48,75.36 104.56,75.44 104.56,75.52 104.32,75.76 104.32,75.85 104.4,75.93 104.48,75.93 104.72,75.69 104.81,75.69 104.89,75.77 104.89,75.85 104.65,76.09 104.65,76.18 106.62,78.15 106.62,87.56 107.15,88.09 107.15,90.46 v6(107.99,91.3)
DDR_B_D28: length 34.3
  IN4 w0.058: v6(108.91,91.3) 109.6,90.6 109.6,78.32 109.41,78.13 109.41,75.45 107.09,73.13 107.09,69.63 108.31,68.41 110.12,68.41 110.18,68.46 110.18,68.7 110.24,68.76 110.36,68.76 110.42,68.7 110.42,68.46 110.48,68.41 110.59,68.41 110.65,68.46 110.65,68.7 110.71,68.76 110.83,68.76 110.88,68.7 110.88,68.46 110.94,68.41 111.06,68.41 111.12,68.46 111.12,68.7 111.18,68.76 111.29,68.76 111.35,68.7 111.35,68.46 111.41,68.41 112.85,68.41 113.49,67.77 113.49,65.74 v7(113.2,65.45)
DDR_B_D29: length 33.8
  IN4 w0.058: v6(108.91,90.65) 109.42,90.13 109.42,78.78 109.09,78.45 109.09,75.51 108.97,75.38 108.89,75.38 108.73,75.55 108.64,75.55 108.56,75.46 108.56,75.38 108.72,75.22 108.72,75.14 108.64,75.05 108.56,75.05 108.4,75.21 108.31,75.21 108.23,75.13 108.23,75.05 108.39,74.89 108.39,74.8 108.31,74.72 108.23,74.72 108.06,74.88 107.98,74.88 107.9,74.8 107.9,74.72 108.06,74.56 108.06,74.47 107.98,74.39 107.9,74.39 107.73,74.55 107.65,74.55 107.57,74.47 107.57,74.39 107.73,74.23 107.73,74.14 107.65,74.06 107.56,74.06 107.4,74.22 107.32,74.22 107.24,74.14 107.24,74.06 107.4,73.9 107.4,73.81 106.82,73.24 106.82,69.52 108.18,68.16 112.71,68.16 113.22,67.66 113.22,66.27 v7(113.2,66.25)
DDR_B_D30: length 31.4
  IN4 w0.058: v6(107.99,88.7) 107.99,81.72 107.52,81.24 107.52,77.28 104.27,74.04 104.27,73.21 104.33,73.15 104.92,73.15 104.98,73.09 104.98,72.97 104.92,72.92 104.33,72.92 104.27,72.86 104.27,72.74 104.33,72.68 104.92,72.68 104.98,72.62 104.98,72.51 104.92,72.45 104.33,72.45 104.27,72.39 104.27,72.27 104.33,72.21 104.92,72.21 104.98,72.16 104.98,72.04 104.92,71.98 104.33,71.98 104.27,71.92 104.27,71.81 104.33,71.75 104.92,71.75 104.98,71.69 104.98,71.57 104.92,71.51 104.33,71.51 104.27,71.46 104.27,70.2 107.41,67.05 v7(109.2,67.05)
DDR_B_D31: length 31.9
  IN4 w0.058: v6(107.99,89.35) 107.7,89.05 107.7,81.69 107.37,81.36 107.37,77.51 103.42,73.56 103.42,73.31 103.47,73.26 103.9,73.26 103.96,73.2 103.96,73.05 103.91,73 103.39,73 103.33,72.94 103.33,72.19 103.39,72.13 103.9,72.13 103.96,72.08 103.96,71.96 103.9,71.9 103.39,71.9 103.33,71.84 103.33,71.73 103.39,71.67 103.9,71.67 103.96,71.61 103.96,71.49 103.9,71.43 103.39,71.43 103.33,71.38 103.33,71.22 103.89,70.67 103.89,70.21 107.77,66.32 108.33,66.32 v7(109.2,65.45)
DDR_B_D32: length 19.6
  IN1 w0.058: v8(102.8,70.25) 103,70.45 103,73.4 103.74,74.14 103.74,75.12 103.97,75.34 104.05,75.34 104.27,75.12 104.35,75.12 104.44,75.2 104.44,75.29 104.21,75.51 104.21,75.59 104.3,75.67 104.38,75.67 104.6,75.45 104.68,75.45 104.77,75.53 104.77,75.62 104.54,75.84 104.54,75.92 104.63,76 104.71,76 104.93,75.78 105.02,75.78 105.1,75.86 105.1,75.95 104.88,76.17 104.88,76.25 104.96,76.33 105.04,76.33 105.26,76.11 105.35,76.11 105.43,76.2 105.43,76.28 105.21,76.5 105.21,76.58 105.63,77 105.63,82.69 106.17,83.24 106.17,85.18 v8(105.91,85.44)
DDR_B_D33: length 20.9
  IN1 w0.058: v8(98,69.45) 98.36,69.81 98.36,71.15 99.32,72.1 99.32,73.3 100.82,74.8 100.82,78.32 103.36,80.86 103.36,82.87 104.64,84.14 104.64,86.85 v8(105.18,87.39)
DDR_B_D34: length 21
  IN1 w0.058: v8(102.8,69.45) 103.08,69.45 103.31,69.69 103.31,73.35 104.19,74.23 104.19,74.31 104.09,74.41 104.09,74.49 104.18,74.57 104.26,74.57 104.36,74.47 104.44,74.47 104.53,74.56 104.53,74.64 104.42,74.74 104.42,74.82 104.51,74.9 104.59,74.9 104.69,74.8 104.77,74.8 104.86,74.89 104.86,74.97 104.76,75.07 104.76,75.15 104.84,75.24 104.92,75.24 105.02,75.13 105.1,75.13 105.19,75.22 105.19,75.3 105.09,75.4 105.09,75.48 105.17,75.57 105.25,75.57 105.35,75.47 105.43,75.47 105.52,75.55 105.52,75.63 105.42,75.73 105.42,75.81 105.5,75.9 105.58,75.9 105.68,75.8 105.77,75.8 105.89,75.92 105.89,82.57 106.32,83 106.32,86.33 v8(105.91,86.74)
DDR_B_D35: length 20.2
  IN1 w0.058: v8(105.18,86.74) 104.78,86.34 104.78,83.94 103.63,82.78 103.63,80.76 102.92,80.05 102.92,79.97 103.11,79.77 103.11,79.69 103.02,79.61 102.94,79.61 102.75,79.8 102.67,79.8 102.59,79.72 102.59,79.63 102.78,79.44 102.78,79.36 102.69,79.28 102.61,79.28 102.42,79.47 102.34,79.47 102.26,79.39 102.26,79.3 102.45,79.11 102.45,79.03 102.36,78.95 102.28,78.95 102.09,79.14 102.01,79.14 101.08,78.21 101.08,74.69 99.58,73.19 99.58,71.83 v8(98.8,71.05)
DDR_B_D36: length 21.6
  IN1 w0.058: v8(105.91,87.39) 106.47,86.83 106.47,82.86 106.15,82.54 106.15,75.75 104.04,73.64 104.04,71.81 104.01,71.78 104.01,69.24 103.42,68.65 v8(102,68.65)
DDR_B_D37: length 18.7
  IN1 w0.058: v8(98.8,69.45) 98.95,69.45 100.63,71.13 100.63,73.87 101.34,74.58 101.34,77.25 103.89,79.8 103.89,82.67 104.93,83.71 104.93,85.19 v8(105.18,85.44)
DDR_B_D38: length 19.4
  IN1 w0.058: v8(105.91,84.79) 105.91,83.28 105.37,82.74 105.37,77.73 105.09,77.45 105.09,77.37 105.27,77.19 105.27,77.1 105.19,77.02 105.11,77.02 104.92,77.21 104.84,77.21 104.76,77.12 104.76,77.04 104.94,76.86 104.94,76.77 104.86,76.69 104.77,76.69 104.59,76.88 104.51,76.88 104.43,76.79 104.43,76.71 104.61,76.53 104.61,76.44 104.53,76.36 104.44,76.36 104.26,76.54 104.18,76.54 104.09,76.46 104.09,76.38 104.28,76.2 104.28,76.11 104.2,76.03 104.11,76.03 103.93,76.21 103.85,76.21 103.48,75.85 103.48,74.25 102.68,73.45 102.68,72.98 102.68,72.98 102.68,70.7 102.36,70.39 102.36,69.81 v8(102,69.45)
DDR_B_D39: length 18.9
  IN1 w0.058: v8(98.8,68.65) 98.98,68.65 100.93,70.6 100.93,73.8 101.6,74.48 101.6,77.14 104.15,79.69 104.15,82.58 105.18,83.61 v8(105.18,84.79)
DDR_B_D40: length 29.2
  IN1 w0.058: v8(103.4,86.74) 103.6,86.74 103.89,86.45 103.89,84.18 102.64,82.93 102.64,81.55 98.51,77.42 98.51,72.82 97.51,71.82 97.51,68.54 97.85,68.2 101.25,68.2 102.36,67.08 102.36,65.01 v8(102,64.65)
DDR_B_D41: length 25.6
  IN1 w0.058: v8(102,65.45) 99.6,67.85 97.35,67.85 96.71,68.48 96.71,71.59 97.9,72.78 97.9,77.55 102.11,81.76 102.11,83.07 103.4,84.35 v8(103.4,84.79)
DDR_B_D42: length 31.2
  IN1 w0.058: v8(98,65.45) 97.38,66.07 96.77,66.07 94.78,68.06 94.78,78.37 99.65,83.24 99.65,83.32 99.36,83.62 99.36,83.7 99.43,83.77 99.51,83.77 99.81,83.48 99.89,83.48 99.97,83.56 99.97,83.64 99.72,83.89 99.72,83.97 99.8,84.06 99.89,84.06 100.14,83.81 100.22,83.81 100.3,83.89 100.3,83.97 100.04,84.24 100.04,84.32 100.12,84.4 100.2,84.4 100.47,84.14 100.55,84.14 100.63,84.22 100.63,84.3 100.36,84.58 100.36,84.66 100.44,84.74 100.52,84.74 100.8,84.47 100.88,84.47 100.96,84.55 100.96,84.63 100.67,84.92 100.67,85.01 100.76,85.09 100.84,85.09 101.13,84.8 101.21,84.8 101.29,84.88 101.29,84.96 101.02,85.24 101.02,85.32 101.1,85.41 101.18,85.41 101.22,85.37 101.3,85.37 101.46,85.54 101.46,85.54 101.64,85.71 101.94,85.71 102.11,85.88 102.11,86.18 v8(102.66,86.74)
DDR_B_D43: length 27.5
  IN1 w0.058: v8(98.8,65.45) 98.8,65.57 98.49,65.88 97.92,65.88 97.41,66.39 96.9,66.39 95.14,68.15 95.14,78.36 100.33,83.55 100.86,83.55 100.95,83.46 101.03,83.46 101.11,83.54 101.11,83.62 101.02,83.71 101.02,83.8 101.11,83.88 101.19,83.88 101.28,83.79 101.36,83.79 101.44,83.87 101.44,83.95 101.35,84.04 101.35,84.13 101.44,84.21 101.52,84.21 101.61,84.12 101.69,84.12 101.77,84.2 101.77,84.29 101.68,84.37 101.68,84.46 101.77,84.54 101.85,84.54 101.94,84.45 102.02,84.45 102.11,84.53 102.11,84.62 102.06,84.67 102.06,84.75 102.14,84.83 102.22,84.83 102.23,84.82 102.32,84.82 102.4,84.9 102.4,84.98 102.29,85.1 102.29,85.56 102.34,85.62 102.48,85.62 v8(102.66,85.44)
DDR_B_D44: length 32
  IN1 w0.058: v8(103.4,87.39) 103.78,87.39 104.03,87.13 104.03,83.92 102.9,82.78 102.9,81.44 98.81,77.35 98.81,76.79 98.87,76.73 99.13,76.73 99.19,76.67 99.19,76.56 99.13,76.5 98.87,76.5 98.81,76.44 98.81,76.32 98.87,76.26 99.13,76.26 99.19,76.21 99.19,76.09 99.13,76.03 98.87,76.03 98.81,75.97 98.81,75.86 98.87,75.8 99.13,75.8 99.19,75.74 99.19,75.62 99.13,75.56 98.87,75.56 98.81,75.5 98.81,75.39 98.87,75.33 99.13,75.33 99.19,75.27 99.19,75.15 99.13,75.1 98.87,75.1 98.81,75.04 98.81,72.91 97.66,71.76 97.66,68.61 97.92,68.35 101.85,68.35 102.55,67.66 102.55,65.7 v8(102.8,65.45)
DDR_B_D45: length 27.7
  IN1 w0.058: v8(103.4,85.44) 103.64,85.44 103.7,85.38 103.7,84.34 102.38,83.02 102.38,81.66 98.21,77.48 98.21,72.83 96.95,71.58 96.95,68.49 97.41,68.04 99.73,68.04 100.66,67.11 100.74,67.11 101.3,67.67 101.38,67.67 101.47,67.58 101.47,67.5 100.95,66.98 100.95,66.9 101.03,66.82 101.11,66.82 101.63,67.34 101.72,67.34 v8(102,67.05)
DDR_B_D46: length 31.8
  IN1 w0.058: v8(102.66,87.39) 102.35,87.07 101.52,87.07 101.31,86.86 101.31,86.58 101.54,86.35 101.54,86.27 101.46,86.19 101.38,86.19 101.15,86.41 101.07,86.41 100.98,86.33 100.98,86.25 101.21,86.02 101.21,85.94 101.13,85.85 101.05,85.85 100.82,86.08 100.74,86.08 100.65,86 100.65,85.92 100.88,85.69 100.88,85.61 99.15,83.87 99.15,83.1 94.36,78.31 94.36,68.12 96.62,65.85 97.22,65.85 97.47,65.6 97.47,64.73 97.56,64.65 97.72,64.65 97.77,64.71 97.77,64.93 97.83,64.99 97.95,64.99 98.01,64.93 98.01,64.71 98.07,64.65 v8(98.8,64.65)
DDR_B_D47: length 28.4
  IN1 w0.058: v8(98,66.25) 97.55,66.7 97.03,66.7 95.4,68.33 95.4,77.9 95.84,78.34 95.84,78.43 95.75,78.51 95.75,78.6 95.83,78.68 95.92,78.68 96.01,78.59 96.09,78.59 96.17,78.67 96.17,78.76 96.08,78.85 96.08,78.93 96.16,79.01 96.25,79.01 96.34,78.92 96.42,78.92 96.5,79 96.5,79.09 96.41,79.18 96.41,79.26 96.49,79.34 96.58,79.34 96.67,79.25 96.75,79.25 96.83,79.33 96.83,79.42 96.74,79.51 96.74,79.59 96.83,79.67 96.91,79.67 97,79.58 97.08,79.58 97.16,79.67 97.16,79.75 97.07,79.84 97.07,79.92 97.16,80 97.24,80 97.33,79.91 97.41,79.91 97.49,80 97.49,80.08 97.4,80.17 97.4,80.25 97.49,80.33 97.57,80.33 97.66,80.24 97.74,80.24 97.82,80.33 97.82,80.41 97.74,80.5 97.74,80.58 97.82,80.66 97.9,80.66 97.99,80.57 98.07,80.57 98.16,80.66 98.16,80.74 98.07,80.83 98.07,80.91 98.15,81 98.23,81 98.32,80.91 98.4,80.91 98.49,80.99 98.49,81.07 98.4,81.16 98.4,81.24 98.48,81.33 98.56,81.33 98.65,81.24 98.73,81.24 98.82,81.32 98.82,81.4 98.73,81.49 98.73,81.57 98.81,81.66 98.89,81.66 98.98,81.57 99.07,81.57 99.15,81.65 99.15,81.73 99.06,81.82 99.06,81.9 99.14,81.99 99.22,81.99 99.31,81.9 99.4,81.9 99.48,81.98 99.48,82.06 99.39,82.15 99.39,82.24 99.47,82.32 99.55,82.32 99.64,82.23 99.73,82.23 99.81,82.31 99.81,82.39 99.72,82.48 99.72,82.57 99.8,82.65 99.88,82.65 99.97,82.56 100.06,82.56 100.14,82.64 100.14,82.72 100.05,82.81 100.05,82.9 100.13,82.98 100.22,82.98 100.31,82.89 100.39,82.89 100.47,82.97 100.47,83.05 100.38,83.14 100.38,83.23 100.46,83.31 100.55,83.31 100.64,83.22 101.04,83.22 102.6,84.79 v8(102.66,84.79)
DDR_B_D48: length 28.3
  IN4 w0.058: v6(106.16,91.3) 106.81,90.65 106.81,88.29 106.46,87.94 106.46,78.64 106.26,78.45 106.18,78.45 105.7,78.93 105.62,78.93 105.54,78.84 105.54,78.76 106.01,78.28 106.01,78.2 105.93,78.12 105.85,78.12 105.37,78.6 105.29,78.6 105.21,78.51 105.21,78.43 105.68,77.95 105.68,77.87 105.6,77.79 105.52,77.79 105.04,78.27 104.96,78.27 104.88,78.18 104.88,78.1 105.35,77.62 105.35,77.54 105.27,77.46 105.19,77.46 104.71,77.93 104.63,77.93 104.55,77.85 104.55,77.77 105.02,77.29 105.02,77.21 102.97,75.16 102.97,74.51 102.09,73.63 102.09,71.14 v7(102,71.05)
DDR_B_D49: length 28.3
  IN4 w0.058: v7(98,69.45) 97.17,70.28 97.17,72.01 97.68,72.52 97.68,74.93 97.74,74.99 98.03,74.99 98.09,75.05 98.09,75.17 98.03,75.22 97.74,75.22 97.68,75.28 97.68,75.4 97.74,75.46 98.03,75.46 98.09,75.52 98.09,75.63 98.03,75.69 97.74,75.69 97.68,75.75 97.68,75.87 97.74,75.93 98.03,75.93 98.09,75.98 98.09,76.1 98.03,76.16 97.74,76.16 97.68,76.22 97.68,76.33 97.74,76.39 98.03,76.39 98.09,76.45 98.09,76.57 98.03,76.63 97.74,76.63 97.68,76.68 97.68,77.09 103.72,83.13 103.72,87.46 104.71,88.45 104.71,90.76 v6(105.25,91.3)
DDR_B_D50: length 24.3
  IN4 w0.058: v6(105.25,88.7) 105.25,88.23 104.5,87.49 104.5,82.81 99.48,77.78 99.48,77.28 99.42,77.22 99.04,77.22 98.98,77.16 98.98,77.04 99.04,76.98 99.42,76.98 99.48,76.93 99.48,76.81 99.42,76.75 99.04,76.75 98.98,76.69 98.98,76.58 99.04,76.52 99.42,76.52 99.48,76.46 99.48,73.84 98.49,72.85 98.49,72.22 97.96,71.69 97.96,70.64 98.8,69.8 v7(98.8,69.45)
DDR_B_D51: length 24.8
  IN4 w0.058: v6(106.16,89.35) 106.43,89.08 106.43,88.42 105.93,87.93 105.93,80.08 105.55,79.69 105.47,79.69 105.08,80.08 105,80.08 104.91,80 104.91,79.92 105.3,79.53 105.3,79.45 103.35,77.5 101.98,77.5 100.99,76.5 100.99,70.24 101.77,69.45 v7(102,69.45)
DDR_B_D52: length 26.7
  IN4 w0.058: v7(102.8,69.45) 102.25,70 101.66,70 101.25,70.42 101.25,74.92 103.14,76.81 103.22,76.81 103.44,76.6 103.52,76.6 103.6,76.68 103.6,76.76 103.39,76.98 103.39,77.06 103.47,77.15 103.55,77.15 103.77,76.93 103.85,76.93 103.93,77.01 103.93,77.09 103.72,77.31 103.72,77.39 103.8,77.48 103.88,77.48 104.1,77.26 104.18,77.26 104.26,77.34 104.26,77.42 104.05,77.64 104.05,77.72 106.19,79.87 106.19,87.98 106.62,88.4 106.62,90.19 v6(106.16,90.65)
DDR_B_D53: length 27
  IN4 w0.058: v6(105.25,90.65) 104.86,90.26 104.86,88.34 103.98,87.47 103.98,83.02 98.35,77.39 98.35,74.94 98.41,74.88 98.65,74.88 98.7,74.83 98.7,74.71 98.65,74.65 98.41,74.65 98.35,74.59 98.35,74.48 98.41,74.42 98.65,74.42 98.7,74.36 98.7,74.24 98.65,74.18 98.41,74.18 98.35,74.12 98.35,73.46 98.09,73.19 98.09,72.54 97.43,71.88 97.43,70.36 98.1,69.7 98.1,69.7 98.8,69 v7(98.8,68.65)
