# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D54: length 23.2
  IN4 w0.058: v7(102,68.65) 101.62,68.65 100.72,69.55 100.72,76.61 101.87,77.76 102.14,77.76 105.67,81.29 105.67,87.92 106.16,88.41 v6(106.16,88.7)
DDR_B_D55: length 25.2
  IN4 w0.058: v6(105.25,89.35) 105,89.1 105,88.24 104.24,87.48 104.24,82.92 98.63,77.3 98.63,76.2 98.69,76.14 99.16,76.14 99.21,76.08 99.21,75.96 99.16,75.91 98.69,75.91 98.63,75.85 98.63,75.73 98.69,75.67 99.16,75.67 99.21,75.61 99.21,75.5 99.16,75.44 98.69,75.44 98.63,75.38 98.63,75.26 98.69,75.2 99.16,75.2 99.21,75.15 99.21,73.95 98.23,72.97 98.23,72.35 97.69,71.81 97.69,70.56 v7(98,70.25)
DDR_B_D56: length 36.5
  IN4 w0.058: v6(102.5,91.3) 101.9,90.7 101.9,89.82 100.46,88.37 100.46,87.79 100.4,87.73 99.83,87.73 99.77,87.67 99.77,87.56 99.83,87.5 100.4,87.5 100.46,87.44 100.46,87.32 100.4,87.27 99.83,87.27 99.77,87.21 99.77,87.09 99.83,87.03 100.4,87.03 100.46,86.97 100.46,86.86 100.4,86.8 99.83,86.8 99.77,86.74 99.77,86.62 99.83,86.56 100.4,86.56 100.46,86.51 100.46,85.71 95.02,80.27 95.02,80.19 95.14,80.07 95.14,79.99 95.05,79.9 94.97,79.9 94.85,80.02 94.77,80.02 94.69,79.94 94.69,79.86 94.81,79.74 94.81,79.66 94.72,79.57 94.64,79.57 94.52,79.69 94.44,79.69 94.36,79.61 94.36,79.53 94.48,79.41 94.48,79.33 94.39,79.24 94.31,79.24 94.19,79.36 94.11,79.36 93.97,79.22 93.97,68.81 96.77,66 97.45,66 v7(98,65.45)
DDR_B_D57: length 37.3
  IN4 w0.058: v6(103.42,91.3) 103.89,90.83 103.89,87.97 103.38,87.46 103.38,83.45 96.86,76.93 96.86,76.63 96.92,76.57 97.15,76.57 97.21,76.51 97.21,76.4 97.15,76.34 96.92,76.34 96.86,76.28 96.86,76.16 96.92,76.1 97.15,76.1 97.21,76.05 97.21,75.93 97.15,75.87 96.92,75.87 96.86,75.81 96.86,75.69 96.92,75.64 97.15,75.64 97.21,75.58 97.21,75.46 97.15,75.4 96.92,75.4 96.86,75.34 96.86,75.23 96.92,75.17 97.15,75.17 97.21,75.11 97.21,74.99 97.15,74.94 96.92,74.94 96.86,74.88 96.86,74.76 96.92,74.7 97.15,74.7 97.21,74.64 97.21,74.53 97.15,74.47 96.92,74.47 96.86,74.41 96.86,74.29 96.92,74.23 97.15,74.23 97.21,74.18 97.21,74.06 97.15,74 96.92,74 96.86,73.94 96.86,70.05 98.53,68.38 102.36,68.38 103.06,67.68 103.06,65.71 v7(102.8,65.45)
DDR_B_D58: length 33.1
  IN4 w0.058: v6(102.58,88.7) 102.16,88.7 101.3,87.84 101.3,85.04 97.88,81.62 97.88,80.93 97.76,80.81 97.68,80.81 97.42,81.07 97.33,81.07 97.25,80.99 97.25,80.91 97.51,80.65 97.51,80.56 97.43,80.48 97.35,80.48 97.09,80.74 97,80.74 96.92,80.66 96.92,80.58 97.18,80.32 97.18,80.23 97.1,80.15 97.02,80.15 96.75,80.41 96.67,80.41 96.59,80.33 96.59,80.24 96.85,79.98 96.85,79.9 96.77,79.82 96.68,79.82 96.42,80.08 96.34,80.08 96.26,80 96.26,79.91 96.52,79.65 96.52,79.57 96.44,79.49 96.35,79.49 96.09,79.75 96.01,79.75 95.93,79.67 95.93,79.58 96.19,79.32 96.19,79.24 96.11,79.16 96.02,79.16 95.76,79.42 95.68,79.42 95.6,79.34 95.6,79.25 95.86,78.99 95.86,78.91 94.89,77.94 94.89,69 97.1,66.79 98.54,66.79 v7(98.8,67.05)
DDR_B_D59: length 33.2
  IN4 w0.058: v6(103.42,89.35) 103.17,89.1 103.17,88.15 102.81,87.78 102.81,83.99 100.37,81.56 100.13,81.56 99.82,81.24 99.74,81.24 99.52,81.46 99.44,81.46 99.36,81.38 99.36,81.29 99.57,81.08 99.57,81 99.49,80.91 99.41,80.91 99.19,81.13 99.11,81.13 99.03,81.05 99.03,80.96 99.24,80.75 99.24,80.67 96.07,77.5 96.07,69.84 97.99,67.92 101.5,67.92 102.3,67.12 102.3,65.75 v7(102,65.45)
DDR_B_D60: length 35.5
  IN4 w0.058: v6(102.5,90.65) 102.16,90.3 102.16,89.69 100.72,88.25 100.72,85.6 98.11,83 98.11,82.92 98.24,82.8 98.24,82.71 98.15,82.63 98.07,82.63 97.95,82.75 97.87,82.75 97.78,82.67 97.78,82.59 97.9,82.47 97.9,82.38 97.82,82.3 97.74,82.3 97.62,82.42 97.54,82.42 97.45,82.34 97.45,82.26 97.57,82.14 97.57,82.05 97.49,81.97 97.41,81.97 97.29,82.09 97.21,82.09 97.12,82.01 97.12,81.93 97.24,81.81 97.24,81.72 97.16,81.64 97.08,81.64 96.96,81.76 96.87,81.76 96.79,81.68 96.79,81.59 96.91,81.47 96.91,81.39 96.83,81.31 96.75,81.31 96.63,81.43 96.54,81.43 96.46,81.35 96.46,81.26 96.58,81.14 96.58,81.06 96.5,80.98 96.42,80.98 96.3,81.1 96.21,81.1 96.13,81.02 96.13,80.93 96.25,80.81 96.25,80.73 96.17,80.65 96.09,80.65 95.97,80.77 95.88,80.77 95.8,80.69 95.8,80.6 95.92,80.48 95.92,80.4 95.81,80.29 95.72,80.29 95.6,80.41 95.52,80.41 95.44,80.32 95.44,80.24 95.56,80.12 95.56,80.04 94.23,78.71 94.23,68.92 96.88,66.27 97.59,66.27 97.85,66 98.11,66 98.36,65.75 98.36,65.09 v7(98.8,64.65)
DDR_B_D61: length 35.4
  IN4 w0.058: v6(103.42,90.65) 103.7,90.37 103.7,88.15 103.19,87.64 103.19,83.63 100.47,80.91 100.38,80.91 100.34,80.95 100.26,80.95 100.18,80.86 100.18,80.78 100.22,80.74 100.22,80.66 100.14,80.58 100.05,80.58 100.01,80.62 99.93,80.62 99.85,80.53 99.85,80.45 99.89,80.41 99.89,80.33 99.8,80.25 99.72,80.25 99.68,80.28 99.6,80.28 99.52,80.2 99.52,80.12 99.56,80.08 99.56,80 99.47,79.92 99.39,79.92 99.35,79.95 99.27,79.95 99.19,79.87 99.19,79.79 99.23,79.75 99.23,79.67 99.14,79.58 99.06,79.58 99.02,79.62 98.94,79.62 98.86,79.54 98.86,79.46 98.9,79.42 98.9,79.34 98.81,79.25 98.73,79.25 98.69,79.29 98.61,79.29 98.53,79.21 98.53,79.13 98.56,79.09 98.56,79.01 98.48,78.92 98.4,78.92 98.36,78.96 98.28,78.96 98.2,78.88 98.2,78.8 98.23,78.76 98.23,78.67 98.15,78.59 98.07,78.59 98.03,78.63 97.95,78.63 97.86,78.55 97.86,78.47 97.9,78.43 97.9,78.34 97.82,78.26 97.74,78.26 97.7,78.3 97.62,78.3 97.53,78.22 97.53,78.13 97.57,78.1 97.57,78.01 97.49,77.93 97.41,77.93 97.37,77.97 97.29,77.97 97.2,77.89 97.2,77.8 97.24,77.77 97.24,77.68 97.16,77.6 97.08,77.6 97.04,77.64 96.96,77.64 96.87,77.56 96.87,77.47 96.91,77.43 96.91,77.35 96.6,77.04 96.6,69.94 98.3,68.23 101.72,68.23 101.98,67.98 102.06,67.98 102.23,68.15 102.31,68.15 102.4,68.07 102.4,67.98 102.22,67.81 102.22,67.73 102.31,67.65 102.39,67.65 102.56,67.82 102.64,67.82 102.73,67.74 102.73,67.65 102.56,67.48 102.56,67.4 102.74,67.21 102.74,66.31 v7(102.8,66.25)
DDR_B_D62: length 31.9
  IN4 w0.058: v7(102,64.65) 102.49,65.14 102.49,67.19 101.6,68.07 98.1,68.07 96.33,69.83 96.33,77.39 100.24,81.29 100.48,81.29 103,83.81 103,87.7 103.42,88.12 v6(103.42,88.7)
DDR_B_D63: length 33.9
  IN4 w0.058: v6(102.53,89.35) 102.32,89.35 101.04,88.07 101.04,85.15 100.91,85.02 100.82,85.02 100.7,85.14 100.62,85.14 100.54,85.05 100.54,84.97 100.66,84.85 100.66,84.77 100.58,84.69 100.49,84.69 100.37,84.81 100.29,84.81 100.21,84.72 100.21,84.64 100.33,84.52 100.33,84.44 100.25,84.35 100.16,84.35 100.04,84.48 99.96,84.48 99.88,84.39 99.88,84.31 100,84.19 100,84.11 99.92,84.02 99.83,84.02 99.71,84.14 99.63,84.14 99.55,84.06 99.55,83.98 99.67,83.86 99.67,83.78 99.58,83.69 99.5,83.69 99.38,83.81 99.3,83.81 99.22,83.73 99.22,83.65 99.34,83.53 99.34,83.45 99.25,83.36 99.17,83.36 99.05,83.48 98.97,83.48 98.89,83.4 98.89,83.32 99.01,83.2 99.01,83.11 98.92,83.03 98.84,83.03 98.72,83.15 98.64,83.15 98.55,83.07 98.55,82.99 98.67,82.87 98.67,82.78 95.18,79.29 95.18,79.21 95.41,78.99 95.41,78.9 95.33,78.82 95.25,78.82 95.02,79.05 94.94,79.05 94.63,78.74 94.63,78.57 94.69,78.51 94.84,78.51 94.89,78.45 94.89,78.34 94.84,78.28 94.69,78.28 94.63,78.22 94.63,68.89 96.99,66.53 98.16,66.53 98.8,65.88 v7(98.8,65.45)
DDR_B_DQS0: length 18.5
  IN1 w0.058: 111.38,83.34 111.38,83.35 111.37,83.36 111.37,83.88 110.68,84.58 110.68,85.82 v8(110.94,86.09)
  IN1 w0.076: v8(112.4,70.25) 112.92,70.77 112.92,71.19 112.25,71.87 111.97,71.87 111.65,71.55 111.54,71.55 111.23,71.85 111.23,71.96 111.56,72.29 111.56,72.56 111.38,72.74 111.38,81.88 111.46,81.96 111.5,81.96 111.69,82.15 111.69,82.75 111.5,82.95 111.46,82.95 111.38,83.02 111.38,83.34
DDR_B_DQS1: length 23
  IN1 w0.058: v8(108.43,86.09) 108.21,86.09 108.15,86.03 108.15,85.94 108.17,85.93 108.17,82.55 108.18,82.54 108.18,82.53
  IN1 w0.076: v8(109.2,66.25) 109.42,66.47 109.55,66.47 109.79,66.72 109.79,67.27 109.47,67.59 108.22,67.59 106.74,69.07 106.74,72.64 108.18,74.07 108.18,82.53
DDR_B_DQS2: length 22.4
  IN4 w0.058: v6(110.73,90) 111.04,90 111.1,89.94 111.1,88.32 111.41,88 111.41,87.48 111.4,87.47 111.4,87.45
  IN4 w0.076: v7(109.2,70.25) 109.2,70.39 109.09,70.5 108.75,70.5 108.43,70.82 108.43,71.4 108.84,71.81 109.58,71.81 111.13,73.37 111.13,76.46 111.24,76.57 111.24,87.29 111.4,87.45
DDR_B_DQS3: length 30.5
  IN4 w0.058: 108.18,87.45 108.18,87.47 108.19,87.48 108.19,87.77 108.36,87.94 108.36,89.94 108.3,90 v6(107.99,90)
  IN4 w0.076: v7(112.4,66.25) 112.26,66.39 111.73,66.39 110.69,67.42 107.45,67.42 105.27,69.6 105.27,74.37 107.81,76.91 107.81,80.88 108.18,81.25 108.18,87.45
DDR_B_DQS4: length 20.3
  IN1 w0.058: 104.83,82.1 104.83,82.11 104.82,82.12 104.82,82.58 105.66,83.43 105.66,86.02 105.73,86.09 v8(105.91,86.09)
  IN1 w0.076: v8(102,70.25) 102,70.47 102.05,70.52 102.24,70.52 102.46,70.74 102.46,71.84 102.21,72.1 102.21,72.28 102.01,72.48 101.63,72.48 101.55,72.56 101.55,72.99 101.63,73.06 102.01,73.06 102.21,73.26 102.21,73.69 102.92,74.4 102.92,77.26 103.37,77.71 103.48,77.71 103.9,77.28 104.18,77.28 104.61,77.71 104.61,77.99 104.18,78.41 104.18,78.52 104.83,79.17 104.83,82.1
DDR_B_DQS5: length 29
  IN1 w0.058: v8(103.4,86.09) 103.18,86.09 103.12,86.03 103.12,84.59 102.67,84.13 102.67,84.12 102.66,84.11
  IN1 w0.076: v8(98.8,66.25) 98.8,66.4 98.88,66.47 99.11,66.47 99.38,66.74 99.38,67.12 98.84,67.66 97.22,67.66 96.27,68.61 96.27,74.45 96.34,74.53 97.09,74.53 97.28,74.73 97.28,75.33 97.09,75.52 96.34,75.52 96.27,75.6 96.27,76.03 96.34,76.11 97.09,76.11 97.28,76.3 97.28,76.9 97.09,77.1 96.34,77.1 96.27,77.17 96.27,77.72 102.66,84.11
DDR_B_DQS6: length 25.5
  IN4 w0.058: v6(105.25,90) 105.55,90 105.61,89.94 105.61,88.38 105.22,87.98 105.22,86.98
  IN4 w0.076: 105.22,86.98 105.22,82.85 104.5,82.14 104.5,81.86 104.8,81.56 104.8,81.46 104.49,81.15 104.39,81.15 104.09,81.45 103.81,81.45 103.39,81.02 103.39,80.75 103.6,80.54 103.6,80.43 103.29,80.13 103.18,80.13 102.98,80.33 102.7,80.33 99.95,77.58 99.95,73.65 99.36,73.06 99.36,72.17 99.18,71.99 98.7,71.99 98.29,71.57 98.29,70.77 v7(98.8,70.25)
DDR_B_DQS7: length 34
  IN4 w0.058: v6(102.5,90) 102.77,90 102.83,89.94 102.83,88.45 102.35,87.97 102.2,87.97 101.79,87.56 101.79,87.25 101.78,87.24 101.78,87.23
  IN4 w0.076: 101.78,87.23 101.78,84.85 101.24,84.31 101.24,84.03 101.52,83.76 101.52,83.65 101.21,83.35 101.1,83.35 100.83,83.62 100.55,83.62 100.13,83.2 100.13,82.92 100.4,82.65 100.4,82.54 100.09,82.23 99.99,82.23 99.71,82.51 99.44,82.51 98.35,81.42 98.35,80.73 95.4,77.78 95.4,69.43 97.5,67.33 98.45,67.33 98.57,67.45 100.53,67.45 101.56,66.42 101.83,66.42 v7(102,66.25)
DDR_B_DQS#0: length 18.5
  IN1 w0.058: v8(110.2,86.09) 110.49,85.8 110.49,84.5 111.18,83.81 111.18,83.36 111.18,83.35 111.18,83.34
  IN1 w0.076: v8(112.4,71.05) 112.34,70.99 112.34,70.74 112.42,70.67 112.53,70.67 112.72,70.86 112.72,71.11 112.16,71.67 112.06,71.67 111.73,71.34 111.45,71.34 111.03,71.77 111.03,72.05 111.35,72.37 111.35,72.48 111.18,72.66 111.18,81.97 111.37,82.16 111.41,82.16 111.49,82.24 111.49,82.67 111.41,82.75 111.37,82.75 111.18,82.94 111.18,83.34
DDR_B_DQS#1: length 22.9
  IN1 w0.058: 107.98,82.53 107.98,82.54 107.98,82.55 107.98,85.85 107.97,85.87 107.97,86.03 107.91,86.09 v8(107.69,86.09)
  IN1 w0.076: 107.98,82.53 107.98,74.16 106.54,72.72 106.54,68.98 108.13,67.39 109.39,67.39 109.59,67.19 109.59,66.8 109.46,66.68 109.3,66.68 109.2,66.77 v8(109.2,67.05)
DDR_B_DQS#2: length 22.3
  IN4 w0.058: 111.61,87.32 111.61,87.47 111.6,87.48 111.6,88.08 111.28,88.39 111.28,89.94 111.34,90 v6(111.65,90)
  IN4 w0.076: v7(109.2,71.05) 109.31,70.94 109.31,70.78 109.24,70.7 108.84,70.7 108.64,70.91 108.64,71.32 108.92,71.61 109.66,71.61 111.34,73.28 111.34,76.38 111.44,76.48 111.44,87.15 111.61,87.32
DDR_B_DQS#3: length 30.5
  IN4 w0.058: 108.38,87.45 108.38,87.47 108.37,87.48 108.37,87.69 108.54,87.86 108.54,89.94 108.6,90 v6(108.91,90)
  IN4 w0.076: v7(112.4,67.05) 112.4,66.73 112.26,66.59 111.81,66.59 110.77,67.63 107.53,67.63 105.47,69.69 105.47,74.28 108.01,76.82 108.01,80.8 108.38,81.17 108.38,87.45
DDR_B_DQS#4: length 20.2
  IN1 w0.058: 104.62,82.1 104.62,82.11 104.63,82.12 104.63,82.65 105.48,83.5 105.48,86 105.39,86.09 v8(105.18,86.09)
  IN1 w0.076: 104.62,82.1 104.62,79.25 103.98,78.6 103.98,78.33 104.4,77.9 104.4,77.79 104.1,77.49 103.99,77.49 103.56,77.91 103.29,77.91 102.72,77.35 102.72,74.49 102.01,73.77 102.01,73.34 101.93,73.27 101.54,73.27 101.35,73.07 101.35,72.47 101.54,72.28 101.93,72.28 102.01,72.2 102.01,72.01 102.26,71.76 102.26,70.83 102.16,70.72 101.98,70.72 101.88,70.82 101.88,70.93 v8(102,71.05)
DDR_B_DQS#5: length 28.9
  IN1 w0.058: 102.51,84.25 102.52,84.26 102.54,84.26 102.74,84.47 102.74,84.46 102.94,84.67 102.94,86.03 102.88,86.09 v8(102.66,86.09)
  IN1 w0.076: v8(98.8,67.05) 98.73,66.98 98.73,66.75 98.81,66.68 99.02,66.68 99.17,66.83 99.17,67.04 98.76,67.45 97.13,67.45 96.06,68.52 96.06,74.54 96.26,74.73 97,74.73 97.08,74.81 97.08,75.24 97,75.32 96.26,75.32 96.06,75.51 96.06,76.11 96.26,76.31 97,76.31 97.08,76.38 97.08,76.82 97,76.89 96.26,76.89 96.06,77.09 96.06,77.8 102.51,84.25
DDR_B_DQS#6: length 25.4
  IN4 w0.058: v6(106.16,90) 105.86,90 105.8,89.94 105.8,88.3 105.47,87.98 105.47,86.93
  IN4 w0.076: 105.47,86.93 105.47,82.82 104.71,82.05 104.71,81.95 105,81.65 105,81.37 104.58,80.95 104.3,80.95 104.01,81.24 103.9,81.24 103.59,80.94 103.59,80.83 103.8,80.62 103.8,80.35 103.37,79.92 103.1,79.92 102.89,80.13 102.78,80.13 100.15,77.5 100.15,73.56 99.57,72.98 99.57,72.09 99.26,71.78 98.79,71.78 98.49,71.48 98.49,70.85 98.6,70.74 98.83,70.74 98.88,70.79 98.88,70.97 v7(98.8,71.05)
DDR_B_DQS#7: length 34.1
  IN4 w0.058: v6(103.42,90) 103.11,90 103.01,89.9 103.01,88.37 102.43,87.78 102.28,87.78 101.97,87.48 101.97,87.25 101.98,87.24 101.98,87.23
  IN4 w0.076: v7(102,67.05) 102,66.7 101.92,66.62 101.64,66.62 100.61,67.66 98.49,67.66 98.36,67.53 97.58,67.53 95.6,69.51 95.6,77.69 98.55,80.65 98.55,81.33 99.52,82.3 99.63,82.3 99.9,82.03 100.18,82.03 100.6,82.46 100.6,82.73 100.33,83 100.33,83.11 100.64,83.42 100.74,83.42 101.02,83.14 101.29,83.14 101.72,83.57 101.72,83.85 101.45,84.12 101.45,84.23 101.98,84.76 101.98,87.23
DDR_B_MA0: length 57.5
  IN4 w0.086: v6(117.13,90) 117.19,89.94 118.4,89.94 118.49,89.86 118.49,89.65 118.4,89.56 117.28,89.56 117.2,89.48 117.2,89.32 117.28,89.23 117.57,89.23 117.67,89.13 117.67,88.95 117.59,88.86 117.28,88.86 117.2,88.78 117.2,88.6 117.28,88.52 117.59,88.52 117.67,88.43 117.67,88.05 117.77,87.95 117.77,87.59 117.4,87.21 117.4,86.77 117.4,86.41 117.68,86.12 117.68,71.72 118.05,71.36 118.05,65.12 117.92,64.99 117.51,64.99 117.42,64.9 117.42,64.73 117.51,64.65 117.87,64.65 117.96,64.56 117.96,64.39 117.87,64.3 117.51,64.3 117.42,64.21 117.42,63.14 115.29,61 113.71,61 113.46,60.76 112.51,60.76 v8(112.4,60.65) 112.1,60.65 111.96,60.78 111.53,60.78 111.4,60.65 v6(109.2,60.65) 108.78,60.23 103.76,60.23 103.23,60.76 102.11,60.76 v8(102,60.65) 102,60.51 101.91,60.42 101.71,60.42 101.63,60.51 101.63,60.74 101.56,60.81 100.07,60.81 100.03,60.76 98.91,60.76 v6(98.8,60.65) 98.76,60.65 98.54,60.43 94.45,60.43 v7(94.41,60.4)
DDR_B_MA1: length 73.7
  TOP w0.081: UC1.AK6 117.7,87.78 117.51,87.59 v8(117.28,87.59)
  TOP w0.122: v7(98.85,60.25) 98.97,60.25 99.37,60.65 UD8.P7 ; v7(109.25,60.25) 109.37,60.25 109.77,60.65 UD7.P7
  IN1 w0.086: v8(117.28,87.59) 117.14,87.73 116.98,87.73 116.86,87.62 116.86,87.5 116.91,87.46 116.91,87.34 116.82,87.26 116.5,87.26 116.08,86.84 116.08,81.54 116.17,81.45 116.46,81.45 116.58,81.33 116.58,81.18 116.49,81.09 116.19,81.09 116.1,81 116.1,80.83 116.19,80.74 116.49,80.74 116.58,80.66 116.58,80.48 116.49,80.4 116.19,80.4 116.1,80.31 116.1,80.14 116.19,80.05 116.49,80.05 116.58,79.97 116.58,79.79 116.49,79.71 116.19,79.71 116.1,79.62 116.1,79.45 116.19,79.36 116.49,79.36 116.58,79.28 116.58,79.1 116.49,79.02 116.19,79.02 116.1,78.93 116.1,78.76 116.19,78.67 116.49,78.67 116.58,78.58 116.58,78.41 116.49,78.33 116.19,78.33 116.1,78.24 116.1,78.07 116.19,77.98 116.49,77.98 116.58,77.89 116.58,62.98 113.49,59.9 113.39,59.9 113.3,59.98 113.3,60.16 113.22,60.25 113.04,60.25 112.96,60.16 112.96,59.95 112.88,59.87 112.76,59.87 112.7,59.93 112.7,59.97 112.22,60.45 111.81,60.45 v4(111.76,60.51) 111.89,60.63 111.89,60.76 111.76,60.89 111.31,60.89 111.22,60.8 111.22,60.26 111.14,60.18 110.97,60.18 110.88,60.26 110.88,60.8 110.79,60.89 110.62,60.89 110.53,60.8 110.53,60.27 110.45,60.18 110.27,60.18 110.19,60.27 110.19,60.47 110.1,60.56 109.65,60.56 109.35,60.25 v7(109.25,60.25) 109.17,60.25 109.02,60.1 107.95,60.1 107.7,60.35 106.43,60.35 106.2,60.12 101.83,60.12 101.45,60.51 v4(101.36,60.51) 101.13,60.73 100.91,60.73 100.82,60.64 100.82,60.39 100.7,60.26 100.58,60.26 100.45,60.39 100.45,60.42 100.37,60.51 100.19,60.51 100.11,60.42 100.11,60.34 100.02,60.25 99.88,60.25 99.79,60.34 99.79,60.47 99.7,60.56 99.25,60.56 98.95,60.25 v7(98.85,60.25)
  IN4 w0.086: v7(94.41,59.84) 95.98,59.84 96.39,60.25 98.78,60.25 99.03,60.51 v4(101.36,60.51)
  BOTTOM w0.122: UD5.P7 109.34,60.51 v4(111.76,60.51) ; UD6.P7 98.94,60.51 v4(101.36,60.51)
DDR_B_MA2: length 64.8
  IN1 w0.086: v8(117.75,87.39) 117.75,87.33 118.26,86.82 118.52,86.82 118.65,86.68 118.65,86.51 118.46,86.31 118.3,86.31 117.43,87.19 117.31,87.19 117.19,87.06 117.19,86.94 118.06,86.07 118.06,85.95 117.97,85.85 117.84,85.85 116.75,86.94 116.63,86.94 116.42,86.73 116.42,86.56 116.54,86.44 116.77,86.44 117.6,85.61 117.6,85.49 117.47,85.36 117.35,85.36 116.64,86.07 116.52,86.07 116.4,85.94 116.4,85.54 116.51,85.42 116.8,85.42 117.11,85.11 117.11,84.99 116.96,84.85 116.84,84.85 116.64,85.05 116.52,85.05 116.39,84.92 116.39,84.62 116.48,84.53 116.76,84.53 116.87,84.43 116.87,84.24 116.78,84.16 116.47,84.16 116.38,84.07 116.38,83.9 116.47,83.81 116.78,83.81 116.87,83.72 116.87,83.55 116.78,83.47 116.47,83.47 116.38,83.38 116.38,83.21 116.47,83.12 116.78,83.12 116.87,83.03 116.87,82.86 116.78,82.77 116.47,82.77 116.38,82.69 116.38,82.52 116.47,82.43 116.78,82.43 116.87,82.34 116.87,82.17 116.78,82.08 116.47,82.08 116.38,82 116.38,81.82 116.47,81.74 116.78,81.74 116.87,81.65 116.87,62.87 113.64,59.64 112.5,59.64 112.4,59.74 v4(112.4,59.85) 112.3,59.75 112.17,59.75 112.04,59.88 112.04,60.15 111.96,60.23 111.58,60.23 111.46,60.1 111.46,59.83 111.37,59.74 111.12,59.74 111.05,59.82 111.05,59.9 110.97,59.97 110.74,59.97 110.66,59.89 110.66,59.83 110.57,59.74 110.4,59.74 110.31,59.83 110.31,59.91 110.23,60 110.05,60 109.97,59.91 109.97,59.83 109.88,59.74 109.71,59.74 109.62,59.83 109.62,59.98 109.55,60.05 109.42,60.05 109.22,59.85 v7(109.2,59.85) 109.13,59.92 108.16,59.92 107.75,59.51 107.43,59.51 107.38,59.46 106.17,59.46 105.92,59.72 102.23,59.72 102.16,59.79 102.06,59.79 v4(102,59.85) 101.86,59.85 101.53,60.18 101.22,60.18 100.86,59.82 98.83,59.82 v7(98.8,59.85) 98.63,60.02 96.82,60.02 96.52,59.72 v8(94.4,59.72)
DDR_B_MA3: length 73.6
  TOP w0.081: v8(118.33,87.69) 118.33,87.53 UC1.AL5
  TOP w0.122: UD7.N7 109.68,61.45 109.45,61.22 v7(109.45,61.14) ; v7(99.05,61.14) 99.05,61.22 99.28,61.45 UD8.N7
  IN1 w0.086: v8(93.22,60.9) 93.56,61.24 94.74,61.24 94.82,61.17 97.56,61.17 97.74,61.34 98.4,61.34 98.6,61.14 v7(99.05,61.14) 99.23,61.32 99.74,61.32 99.83,61.4 99.83,61.54 99.92,61.62 100.09,61.62 100.18,61.54 100.18,61.4 100.26,61.32 101.31,61.32 v4(101.36,61.37) 101.5,61.37 102.08,60.78 105.21,60.78 105.54,61.11 107.7,61.11 107.93,61.34 108.84,61.34 109.04,61.14 109.45,61.14 v7(109.45,61.14) 109.63,61.32 110.14,61.32 110.23,61.4 110.23,61.54 110.32,61.62 110.49,61.62 110.58,61.54 110.58,61.4 110.66,61.32 111.71,61.32 v4(111.76,61.37) 112.04,61.37 112.19,61.22 112.19,61.01 112.42,60.78 113,60.78 113.06,60.73 113.72,60.73 114.3,61.31 114.3,61.49 114.3,61.81 114.23,61.88 114.23,62 114.35,62.13 114.47,62.13 114.67,61.93 114.79,61.93 115.74,62.87 115.74,65.99 116,66.25 116,76.61 115.89,76.71 115.59,76.71 115.5,76.8 115.5,87.08 116.56,88.14 116.56,88.85 117.02,89.31 117.34,89.31 117.42,89.22 117.42,88.83 117.32,88.72 116.98,88.72 116.89,88.64 116.89,88.43 116.98,88.34 117.67,88.34 117.75,88.43 117.75,89.53 118.41,90.19 118.53,90.19 118.7,90.02 118.7,89.9 118.11,89.31 118.11,88.73 118.2,88.65 118.32,88.65 118.46,88.51 118.46,88.39 118.24,88.17 118.24,87.91 118.24,87.91 118.24,87.83 118.32,87.75 118.32,87.69 v8(118.33,87.69)
  BOTTOM w0.122: UD5.N7 111.68,61.45 v4(111.76,61.37) ; v4(101.36,61.37) 101.28,61.45 UD6.N7
DDR_B_MA4: length 66.1
  IN1 w0.086: v8(118.54,88.04) 118.92,88.42 118.92,89.16 119.02,89.26 119.02,89.79 119.13,89.89 119.33,89.89 119.41,89.82 119.41,89.39 119.51,89.28 119.72,89.28 119.89,89.45 119.89,90.6 119.79,90.71 119.1,90.71 119.01,90.62 119.01,90.49 118.92,90.4 118.75,90.4 118.66,90.49 118.66,90.62 118.58,90.71 118.16,90.71 118.03,90.58 118.03,90.22 117.7,89.89 117.5,89.89 117.22,89.61 116.97,89.61 116.78,89.81 116.65,89.81 116.49,89.64 116.49,89.49 116.48,89.49 116.56,89.41 116.56,89.26 116.33,89.03 116.1,89.03 116.03,88.95 116.03,88.8 116.24,88.59 116.24,88.23 115.87,87.86 115.75,87.86 115.47,88.14 115.35,88.14 115.22,88.02 115.22,87.9 115.51,87.62 115.51,87.49 115.21,87.2 115.21,76.51 115.3,76.42 115.59,76.42 115.71,76.3 115.71,66.37 115.45,66.11 115.45,62.96 114.8,62.31 114.02,62.31 113.86,62.15 113.86,62.03 113.95,61.93 113.95,61.81 113.83,61.69 113.71,61.69 113.64,61.76 113.51,61.76 113.41,61.66 113.41,61.54 113.74,61.21 113.74,61.03 113.61,60.91 113.21,60.91 113.13,60.99 113.13,61.29 113.08,61.34 113.08,61.61 113.01,61.67 112.84,61.67 112.7,61.53 v4(112.7,61.06) 112.65,61.11 112.55,61.11 111.81,61.85 111.3,61.85 111.21,61.77 111.21,61.61 111.12,61.52 110.95,61.52 110.86,61.61 110.86,61.77 110.78,61.85 110.26,61.85 109.98,61.57 109.32,61.57 v7(109.2,61.45) 109.13,61.52 108.45,61.52 108.21,61.77 107.45,61.77 107.14,61.45 104.37,61.45 103.99,61.06 v4(102.3,61.06) 102.25,61.11 102.15,61.11 101.41,61.85 100.9,61.85 100.81,61.77 100.81,61.61 100.72,61.52 100.55,61.52 100.46,61.61 100.46,61.77 100.38,61.85 99.86,61.85 99.58,61.57 98.92,61.57 v7(98.8,61.45) 98.73,61.52 98.32,61.52 98.12,61.72 96.6,61.72 96.39,61.51 v8(94.41,61.51)
  BOTTOM w0.122: UD5.N3 112.68,61.23 v4(112.7,61.06) ; UD6.N3 102.28,61.23 v4(102.3,61.06)
DDR_B_MA5: length 73.4
  TOP w0.122: UD8.P8 102.4,61.05 v6(99.43,61.05) ; v6(109.83,61.05) 112.8,61.05 UD7.P8
  IN4 w0.058: v6(119.37,88.04) 119.58,88.04 119.96,88.42 119.96,89.39 119.82,89.53 119.82,90.39 119.38,90.83 117.54,90.83 116.87,90.15 116.87,88.75
  IN4 w0.086: 116.87,88.75 116.87,87.16 117.11,86.91 117.11,86.77 117.11,86.29 117.39,86 117.39,71.61 117.73,71.27 117.73,65.66 117.12,65.05 117.12,63.2 115.1,61.18 113.09,61.18 112.9,61.37 112.42,61.37 v8(112.09,61.04) 112.06,61.01 109.87,61.01 v6(109.83,61.05) 109.1,61.05 108.53,60.48 103.81,60.48 103.32,60.98 102.75,60.98 102.39,61.34 102,61.34 v8(101.69,61.04) 101.63,60.98 99.5,60.98 v6(99.43,61.05) 98.66,61.05 98.3,60.68 94.7,60.68 v7(94.42,60.96)
  BOTTOM w0.122: UD5.P8 108.76,61.01 112.06,61.01 v8(112.09,61.04) ; UD6.P8 98.36,61.01 101.67,61.01 v8(101.69,61.04)
DDR_B_MA6: length 63.9
  IN1 w0.086: v8(94.4,60.35) 94.53,60.48 95.5,60.48 95.69,60.29 97.64,60.29 v7(98,60.65) 98.08,60.73 98.45,60.73 98.63,60.91 98.91,60.91 99.09,60.73 99.59,60.73 99.95,61.09 101.45,61.09 102.06,60.48 v4(102.4,60.48) 103.14,60.48 103.24,60.37 106.2,60.37 106.47,60.65 v7(108.4,60.65) 108.83,60.65 109.09,60.91 109.32,60.91 109.5,60.73 109.96,60.73 110.08,60.86 110.08,60.99 110.19,61.09 111.86,61.09 112.52,60.43 112.75,60.43 v4(112.8,60.48) 112.88,60.56 113.79,60.56 116.29,63.05 116.29,64.07 116.2,64.16 116.11,64.16 116.03,64.25 116.03,64.42 116.11,64.5 116.2,64.5 116.29,64.59 116.29,64.76 116.2,64.85 116.11,64.85 116.03,64.94 116.03,65.11 116.11,65.2 116.2,65.2 116.29,65.28 116.29,65.45 116.2,65.54 116.11,65.54 116.03,65.63 116.03,65.8 116.11,65.89 116.2,65.89 116.29,65.97 116.29,76.92 116.2,77 115.88,77 115.8,77.09 115.8,77.26 115.88,77.35 116.2,77.35 116.29,77.43 116.29,77.57 116.17,77.69 115.85,77.69 115.79,77.75 115.79,86.96 116.88,88.04 117.87,88.04 117.95,87.96 117.95,87.71 118.03,87.63 118.03,87.48 118.4,87.11 118.53,87.11 118.82,87.4 118.82,87.53 118.68,87.68 118.68,87.76 118.89,87.97 119.02,87.97 119.28,87.71 119.28,87.61 119.15,87.48 119.15,87.38 119.25,87.28 119.42,87.28 119.9,87.75 119.9,87.88 119.67,88.1 119.67,88.28 119.77,88.37 119.89,88.37 120.14,88.12 120.26,88.12 120.38,88.24 120.38,88.36 120.22,88.52 120.22,88.97 120.31,89.05 120.45,89.05 120.52,88.98 120.52,88.65 120.6,88.57 120.72,88.57 120.83,88.68 120.83,89.32 120.74,89.41 120.27,89.41 119.88,89.02 v8(119.88,88.7)
  BOTTOM w0.122: v4(102.4,60.48) 102.63,60.48 UD6.P2 ; v4(112.8,60.48) 113.03,60.48 UD5.P2
DDR_B_MA7: length 72.7
  TOP w0.076: UC1.AN10 119.8,90.65 119.46,90.3 v6(119.38,90.3)
  TOP w0.122: UD7.R8 112.76,59.41 109.96,59.41 v6(109.83,59.29) ; v6(99.43,59.29) 99.56,59.41 102.36,59.41 UD8.R8
  IN4 w0.058: 119.35,88.45 119.61,88.45 119.79,88.62 119.79,89.33 119.38,89.74 v6(119.38,90.3)
  IN4 w0.086: v7(93.26,58.73) 93.55,59.02 96.84,59.02 97.03,58.83 97.79,58.83 97.84,58.88 98.2,58.88 98.63,59.31 99.4,59.31 v6(99.43,59.29) 99.53,59.39 100.05,59.39 100.13,59.31 100.13,59.24 100.18,59.18 100.76,59.18 100.94,59.36 101.51,59.36 v8(101.59,59.29) 101.69,59.39 102.52,59.39 102.62,59.48 103.14,59.48 103.75,58.88 108.24,58.88 108.5,59.13 108.89,59.13 109.12,59.36 109.65,59.36 109.73,59.29 v6(109.83,59.29) v8(111.99,59.29) 112.09,59.29 112.14,59.34 112.78,59.34 113.03,59.59 116.2,59.59 117.58,60.97 117.58,61.21 118.94,62.57 118.94,72.3 118.69,72.54 118.69,86.35 118.54,86.49 118.54,87.12 118.64,87.23 118.64,87.78 119.3,88.45 119.35,88.45
  BOTTOM w0.122: v8(111.99,59.29) 111.83,59.45 108.8,59.45 UD5.R8 ; v8(101.59,59.29) 101.43,59.45 98.4,59.45 UD6.R8
DDR_B_MA8: length 63.2
  TOP w0.076: v6(118.52,89) 118.56,89.04 119.09,89.04 119.39,89.35 UC1.AN8
  TOP w0.122: v6(98.36,59.64) 98.16,59.85 UD8.R2 ; v6(108.76,59.64) 108.56,59.85 UD7.R2
  IN1 w0.086: v8(94.41,59.09) 94.54,59.21 95.81,59.21 96.27,58.75 97.45,58.75 97.66,58.96 97.66,59.15 97.96,59.44 98.16,59.44 v6(98.36,59.64)
  IN4 w0.058: v6(118.52,89) 118.57,89.05 118.85,89.05 118.92,88.98 118.92,88.75
  IN4 w0.086: v6(98.36,59.64) 98.44,59.56 102.11,59.56 v8(102.4,59.85) 103.05,59.85 103.72,59.18 107.87,59.18 108.34,59.64 v6(108.76,59.64) 108.84,59.57 112.52,59.57 v8(112.8,59.85) 113.97,59.85 114.19,60.07 114.48,60.07 114.7,59.85 114.94,59.85 115.02,59.94 115.02,60.44 115.11,60.53 115.28,60.53 115.37,60.44 115.37,59.94 115.45,59.85 115.63,59.85 115.71,59.94 115.71,60.27 115.8,60.35 115.97,60.35 116.06,60.27 116.06,60.07 116.15,59.97 116.33,59.97 116.52,60.16 116.52,60.28 116.16,60.64 116.16,60.76 116.28,60.88 116.4,60.88 116.76,60.52 116.88,60.52 117.25,60.89 117.25,61.29 116.89,61.65 116.89,61.79 116.98,61.88 117.13,61.88 117.32,61.69 117.44,61.69 117.57,61.81 117.57,61.94 117.38,62.13 117.38,62.27 117.52,62.42 117.65,62.42 117.81,62.26 117.93,62.26 118.05,62.38 118.05,62.5 117.89,62.66 117.89,62.79 118.03,62.93 118.16,62.93 118.27,62.82 118.39,62.82 118.68,63.11 118.68,72.1 118.4,72.38 118.4,86.23 118.25,86.37 118.25,86.86 118.25,87.24 118.35,87.35 118.35,88.19 118.25,88.29 118.25,88.41 118.38,88.53 118.5,88.53 118.68,88.35 118.8,88.35 118.92,88.47 118.92,88.75
  BOTTOM w0.122: UD5.R2 v8(112.8,59.85) ; UD6.R2 v8(102.4,59.85)
DDR_B_MA9: length 70.3
  TOP w0.081: UC1.AR11 121.6,91.04 v8(121.46,90.99)
  TOP w0.122: v8(98.77,59.44) 98.98,59.44 99.28,59.74 101.89,59.74 UD8.R7 ; v8(109.17,59.44) 109.38,59.44 109.68,59.74 112.29,59.74 UD7.R7
  IN1 w0.058: 121.16,90.07 121.46,90.38 v8(121.46,90.99)
  IN1 w0.086: 121.16,90.07 121.12,90.04 121.12,88.57 117.15,84.6 117.15,62.7 113.89,59.44 112.17,59.44 v4(111.76,59.85) 111.48,59.57 109.5,59.57 109.38,59.44 v8(109.17,59.44) 109.07,59.34 107.53,59.34 107.46,59.27 106.12,59.27 105.85,59.54 101.67,59.54 v4(101.36,59.85) 101.08,59.57 98.9,59.57 v8(98.77,59.44)
  IN4 w0.086: v4(101.36,59.85) 99.16,59.85 98.98,60.02 98.35,60.02 98.2,59.87 96.32,59.87 95.86,59.41 94.55,59.41 v7(94.41,59.28)
  BOTTOM w0.122: UD6.R7 v4(101.36,59.85) ; UD5.R7 v4(111.76,59.85)
DDR_B_MA10: length 58.4
  TOP w0.081: UC1.AH7 116.39,88.7 116.46,88.62 116.46,88.42 116.38,88.34 115.91,88.34 v6(115.77,88.48)
  TOP w0.122: v6(98.8,62.23) 98.8,62.24 UD8.M3
  IN4 w0.086: v7(94.41,61.51) 94.46,61.56 97.67,61.56 98.3,62.19 98.76,62.19 v6(98.8,62.23) 98.81,62.25 101.07,62.25 101.23,62.41 101.46,62.41 101.62,62.25 v8(102,62.25) 102.42,62.25 102.69,61.98 103.52,61.98 103.94,61.56 108.19,61.56 108.48,61.85 108.8,61.85 109.18,62.23 v6(109.19,62.23) 109.21,62.25 111.47,62.25 111.63,62.41 111.86,62.41 112.02,62.25 v8(112.39,62.25) 112.82,62.25 113.08,62.51 113.46,62.51 113.56,62.41 114.78,62.41 116.25,63.88 116.25,65.41 116.78,65.94 116.78,70.71 116.5,70.98 116.19,70.98 116.1,71.07 116.1,71.24 116.19,71.33 116.5,71.33 116.59,71.41 116.59,71.59 116.5,71.67 116.19,71.67 116.1,71.76 116.1,71.93 116.19,72.02 116.5,72.02 116.59,72.11 116.59,72.28 116.5,72.36 116.19,72.36 116.1,72.45 116.1,72.62 116.19,72.71 116.5,72.71 116.59,72.8 116.59,72.97 116.5,73.05 116.13,73.05 116.04,73.14 116.04,73.31 116.13,73.4 116.38,73.4 116.46,73.49 116.46,73.66 116.38,73.75 116.13,73.75 116.04,73.83 116.04,74 116.13,74.09 116.38,74.09 116.46,74.18 116.46,74.35 116.38,74.44 116.13,74.44 116.04,74.52 116.04,74.7 116.13,74.78 116.38,74.78 116.46,74.87 116.46,75.04 116.38,75.13 116.13,75.13 116.04,75.21 116.04,75.39 116.13,75.47 116.38,75.47 116.46,75.56 116.46,75.73 116.38,75.82 116.13,75.82 116.04,75.9 116.04,76.08 116.13,76.16 116.37,76.16 116.46,76.25 116.46,76.42 116.37,76.51 115.92,76.51 115.83,76.6 115.83,76.77 115.92,76.85 116.42,76.85 116.5,76.94 116.5,77.11 116.42,77.2 115.92,77.2 115.83,77.29 115.83,77.46 115.92,77.55 116.42,77.55 116.5,77.63 116.5,77.78 116.39,77.89 115.94,77.89 115.82,78.01 115.82,88.43 v6(115.77,88.48)
  BOTTOM w0.122: UD6.M3 v8(102,62.25)
DDR_B_MA11: length 63.6
  IN1 w0.058: v8(119.88,91.3) 119.98,91.4 121.73,91.4 121.79,91.35 121.79,90.45 121.41,90.07 121.41,89.89
  IN1 w0.086: v8(94.41,58.53) 94.46,58.57 97.53,58.57 v7(98,59.05) 98.27,58.78 98.96,58.78 99.19,59.01 102.58,59.01 102.62,59.05 v4(102.8,59.05) 103.07,58.78 104.15,58.78 104.24,58.86 104.24,58.92 104.32,59.01 104.5,59.01 104.58,58.92 104.58,58.86 104.67,58.78 104.84,58.78 104.93,58.86 104.93,58.92 105.01,59.01 105.19,59.01 105.27,58.92 105.27,58.86 105.36,58.78 107.11,58.78 107.25,58.64 107.99,58.64 v7(108.4,59.05) 108.44,59.01 108.79,59.01 109.02,58.78 109.47,58.78 109.7,59.01 113.16,59.01 v4(113.2,59.05) 113.94,59.05 114.73,59.84 114.85,59.84 115.37,59.33 115.49,59.33 115.61,59.45 115.61,59.58 115.1,60.09 115.1,60.21 115.22,60.33 115.34,60.33 115.89,59.78 116.02,59.78 116.14,59.9 116.14,60.03 115.59,60.58 115.59,60.7 115.71,60.82 115.83,60.82 116.41,60.24 116.53,60.24 116.65,60.37 116.65,60.49 116.07,61.07 116.07,61.19 117.44,62.56 117.44,84.48 121.41,88.45 121.41,89.89
DDR_B_MA12: length 69.7
  TOP w0.081: UC1.AR10 121.25,90.64 v8(121.21,90.68)
  TOP w0.122: v7(98.41,61.88) 98.97,61.88 99.35,62.25 UD8.M7 ; v7(108.81,61.88) 109.37,61.88 109.75,62.25 UD7.M7
  IN1 w0.058: v8(121.21,90.68) 121.21,90.72
  IN1 w0.086: 121.21,90.72 120.92,91.01 117.45,91.01 115.34,88.9 115.34,88.7 114.92,88.28 114.92,76.35 115.42,75.86 115.42,66.49 115.16,66.23 115.16,63.19 114.55,62.59 113.97,62.59 113.31,61.93 112.14,61.93 111.94,62.13 v4(111.76,62.13) 111.68,62.21 111.51,62.21 111.43,62.13 109.62,62.13 109.37,61.88 v7(108.81,61.88) 108.52,61.88 108.46,61.94 107.38,61.94 107.12,61.69 105.79,61.69 105.54,61.94 102.48,61.94 102.23,62.18 101.41,62.18 v4(101.36,62.13) 101.34,62.15 99.24,62.15 98.97,61.88 v7(98.41,61.88) 98.31,61.98 96.44,61.98 96.24,61.77 93.41,61.77 v8(93.22,61.58)
  BOTTOM w0.122: UD6.M7 101.24,62.25 v4(101.36,62.13) ; v4(111.76,62.13) 111.64,62.25 UD5.M7
DDR_B_MA13: length 77.4
  TOP w0.081: UC1.AF9 v6(114.83,89.56)
  TOP w0.122: v6(109.83,58.73) 112.88,58.73 UD7.T8 ; UD8.T8 102.48,58.73 v6(99.43,58.73)
  IN4 w0.058: v6(114.83,89.56) 115.34,90.07 115.85,90.07 116.15,90.38 116.84,90.38 117.44,90.98 119.44,90.98 119.96,90.45 119.96,89.64 120.15,89.46 120.15,88.24 120.08,88.17
  IN4 w0.086: v7(94.4,58.07) 94.6,58.27 98.5,58.27 98.96,58.73 v6(99.43,58.73) 99.49,58.73 99.58,58.64 99.58,58.5 99.67,58.41 99.89,58.41 99.94,58.46 99.94,58.59 100.04,58.69 101.58,58.69 v7(101.59,58.68) 101.95,58.32 109.09,58.32 109.5,58.73 v6(109.83,58.73) 111.88,58.73 111.93,58.68 v7(111.99,58.68) 115.86,58.68 119.63,62.45 119.63,85.05 119.41,85.28 119.41,86.23 120.08,86.9 120.08,88.17
  BOTTOM w0.122: v7(111.99,58.68) 111.96,58.65 108.8,58.65 UD5.T8 ; UD6.T8 98.4,58.65 101.56,58.65 v7(101.59,58.68)
DDR_B_MA14: length 61.6
  TOP w0.081: UC1.AH11 116.23,91.29 116.61,91.29 116.69,91.21 116.69,91.02 116.61,90.93 115.87,90.93 115.77,90.83 v6(115.77,90.35)
  TOP w0.122: UD8.L2 v6(98.4,62.65) ; UD7.L2 v6(108.8,62.65)
  IN4 w0.086: v6(115.77,90.35) 115.93,90.5 115.93,90.72 115.84,90.81 115.5,90.81 115.42,90.74 115.42,90.62 115.47,90.57 115.47,90.45 115.34,90.33 115.22,90.33 115.18,90.37 115.06,90.37 114.38,89.69 114.38,89.51 114.5,89.39 114.5,88.8 114.99,88.32 114.99,87.96 115.06,87.89 115.16,87.89 115.24,87.8 115.24,76.55 115.38,76.41 115.38,71.92 115.29,71.84 115.08,71.84 115,71.75 115,71.63 115.12,71.5 115.36,71.5 115.44,71.42 115.44,70.76 115.36,70.68 115.15,70.68 115.04,70.56 115.04,70.44 115.15,70.33 115.41,70.33 115.52,70.22 115.52,70.1 115.41,69.99 115.2,69.99 115.11,69.9 115.11,69.73 115.2,69.64 115.53,69.64 115.62,69.55 115.62,69.4 115.53,69.32 115.2,69.32 115.11,69.23 115.11,69.06 115.2,68.97 115.48,68.97 115.57,68.88 115.57,68.71 115.48,68.62 115.2,68.62 115.11,68.54 115.11,68.37 115.2,68.28 115.43,68.28 115.52,68.19 115.52,68.02 115.43,67.93 115.2,67.93 115.11,67.85 115.11,67.67 115.2,67.59 115.43,67.59 115.52,67.5 115.52,67.3 115.43,67.21 115.2,67.21 115.11,67.12 115.11,66.95 115.2,66.86 115.43,66.86 115.52,66.78 115.52,66.6 115.44,66.53 115.19,66.53 115.11,66.44 115.11,66.25 115.2,66.15 115.64,66.15 115.72,66.07 115.72,65.82 115.64,65.74 115.44,65.74 115.37,65.66 115.37,65.46 115.44,65.38 115.57,65.38 115.67,65.28 115.67,64.68 114.29,63.3 113.45,63.3 113.2,63.05 v8(112.8,63.05) 112.5,62.74 112.29,62.74 112.21,62.82 111.66,62.82 111.57,62.91 109.06,62.91 v6(108.8,62.65) 108.75,62.7 105.42,62.7 105.33,62.62 105.33,62.55 105.24,62.46 105.07,62.46 104.99,62.55 104.99,62.62 104.9,62.7 104.73,62.7 104.64,62.62 104.64,62.55 104.55,62.46 104.38,62.46 104.29,62.55 104.29,62.62 104.21,62.7 103.43,62.7 103.34,62.8 102.65,62.8 v8(102.4,63.05) 102.15,62.79 101.89,62.79 101.89,62.79 101.83,62.79 101.8,62.82 100.73,62.82 100.64,62.91 98.66,62.91 v6(98.4,62.65) 98,62.65 97.82,62.46 94.59,62.46 v7(94.41,62.63)
  BOTTOM w0.122: UD5.L2 v8(112.8,63.05) ; UD6.L2 v8(102.4,63.05)
DDR_B_MA15: length 76.1
  TOP w0.076: UC1.AF8 114.64,89.35 114.88,89.11 v6(114.88,88.95)
  TOP w0.122: v6(99.43,62.64) 102.41,62.64 UD8.M8 ; UD7.M8 112.81,62.64 v6(109.83,62.64)
  IN4 w0.086: 112.09,62.56 v8(112.09,62.56) ; 112.09,62.56 112.04,62.61 111.35,62.61 111.26,62.53 111.26,62.52 111.17,62.44 111,62.44 110.91,62.52 110.91,62.63 110.83,62.72 110.65,62.72 110.57,62.63 110.57,62.52 110.48,62.44 110.31,62.44 110.22,62.52 110.22,62.63 110.13,62.72 109.91,62.72 v6(109.83,62.64) 109.19,62.64 108.86,62.31 108.13,62.31 107.63,61.81 104.07,61.81 103.32,62.56 v8(101.69,62.56) 101.64,62.61 100.95,62.61 100.86,62.53 100.86,62.52 100.77,62.44 100.6,62.44 100.51,62.52 100.51,62.63 100.43,62.72 100.25,62.72 100.17,62.63 100.17,62.52 100.08,62.44 99.91,62.44 99.82,62.52 99.82,62.63 99.73,62.72 99.51,62.72 v6(99.43,62.64) 98.78,62.64 98.53,62.38 98.25,62.38 97.98,62.12 94.46,62.12 v7(94.41,62.07) ; 112.09,62.56 112.12,62.54 112.74,62.54 112.91,62.7 113.43,62.7 113.52,62.79 113.52,62.98 113.61,63.07 113.78,63.07 113.87,62.98 113.87,62.79 113.95,62.7 114.11,62.7 114.24,62.84 114.37,62.84 114.57,62.63 114.7,62.63 114.82,62.75 114.82,62.87 114.56,63.13 114.56,63.25 114.68,63.38 114.8,63.38 115,63.18 115.12,63.18 115.24,63.3 115.24,63.43 115.1,63.57 115.1,63.69 115.22,63.82 115.34,63.82 115.49,63.67 115.61,63.67 115.73,63.79 115.73,63.92 115.59,64.06 115.59,64.18 115.96,64.56 115.96,65.54 116.49,66.06 116.49,66.48 116.4,66.57 115.91,66.57 115.82,66.65 115.82,66.83 115.91,66.91 116.4,66.91 116.49,67 116.49,67.17 116.4,67.26 115.91,67.26 115.82,67.34 115.82,67.52 115.91,67.6 116.4,67.6 116.49,67.69 116.49,67.86 116.4,67.95 115.91,67.95 115.82,68.04 115.82,68.21 115.91,68.29 116.4,68.29 116.49,68.38 116.49,68.55 116.4,68.64 115.91,68.64 115.82,68.73 115.82,68.9 115.91,68.99 116.4,68.99 116.49,69.07 116.49,69.24 116.4,69.33 115.91,69.33 115.82,69.42 115.82,69.59 115.91,69.68 116.4,69.68 116.49,69.76 116.49,69.92 116.4,70 115.86,70 115.81,70.06 115.81,70.26 115.9,70.34 116.4,70.34 116.48,70.43 116.48,70.6 116.4,70.69 115.9,70.69 115.69,70.89 115.69,76.39 115.53,76.55 115.53,88.1 115.45,88.19 115.37,88.19 115.31,88.24 115.31,88.55 115.54,88.78 115.54,88.95 115.19,89.31 114.96,89.31 114.88,89.23 v6(114.88,88.95)
  BOTTOM w0.122: v8(112.09,62.56) 112.06,62.59 108.74,62.59 UD5.M8 ; v8(101.69,62.56) 101.67,62.59 98.34,62.59 UD6.M8
DDR_B_MA16: length 77.1
  TOP w0.122: UD7.L8 112.82,63.43 110.03,63.43 v6(109.83,63.22) ; v6(99.43,63.22) 99.63,63.43 102.42,63.43 UD8.L8
  IN4 w0.086: v6(116.22,90.65) 116.3,90.73 116.85,90.73 116.97,90.85 116.97,90.97 116.85,91.09 115.42,91.09 114.01,89.67 114.01,89.55 114.22,89.33 114.22,87.68 114.31,87.6 114.66,87.6 114.74,87.51 114.74,87.34 114.66,87.25 114.31,87.25 114.22,87.16 114.22,86.96 114.31,86.87 114.66,86.87 114.74,86.78 114.74,86.61 114.66,86.52 114.31,86.52 114.22,86.44 114.22,86.27 114.31,86.18 114.66,86.18 114.74,86.09 114.74,85.92 114.66,85.83 114.31,85.83 114.22,85.75 114.22,85.57 114.31,85.49 114.66,85.49 114.74,85.4 114.74,85.23 114.66,85.14 114.31,85.14 114.22,85.06 114.22,84.9 114.31,84.81 114.64,84.81 114.76,84.7 114.76,76.6 115.06,76.29 115.06,72.23 114.76,71.92 114.76,71.26 114.99,71.03 114.99,70.9 114.82,70.73 114.82,65.23 114.97,65.08 115.3,65.08 115.38,64.99 115.38,64.8 115.17,64.58 114.98,64.58 114.73,64.84 114.61,64.84 114.48,64.71 114.48,64.59 114.73,64.34 114.73,64.22 114.61,64.09 114.49,64.09 114.14,64.44 114.02,64.44 113.9,64.32 113.9,64.2 114.25,63.85 114.25,63.73 114.12,63.61 114,63.61 113.65,63.96 113.55,63.96 113.46,63.87 113.46,63.69 113.1,63.32 112.99,63.32 112.9,63.41 112.9,63.55 112.82,63.64 112.66,63.64 112.57,63.55 112.57,63.43 112.47,63.32 112.14,63.32 v7(112.12,63.35) 112.12,63.4 112.01,63.5 111.46,63.5 111.35,63.4 111.35,63.17 111.26,63.08 111.06,63.08 110.98,63.17 110.98,63.34 110.86,63.45 110.7,63.45 110.58,63.34 110.58,63.17 110.49,63.08 110.32,63.08 110.24,63.17 110.24,63.37 110.15,63.45 109.92,63.45 109.83,63.37 v6(109.83,63.22) 109.78,63.22 109.64,63.08 108.75,63.08 108.54,62.88 103.58,62.88 103.15,63.31 101.76,63.31 v7(101.72,63.35) 101.54,63.53 101.35,63.53 101.04,63.22 100.1,63.22 99.95,63.38 99.58,63.38 v6(99.43,63.22) 98.65,63.22 98.36,62.93 97.78,62.93 97.59,62.74 94.82,62.74 94.67,62.89 93.38,62.89 v7(93.22,62.73)
  BOTTOM w0.122: v7(112.12,63.35) 112.02,63.45 108.8,63.45 UD5.L8 ; v7(101.72,63.35) 101.62,63.45 98.4,63.45 UD6.L8
DDR_B_ODT0: length 63.4
  TOP w0.076: v6(113.93,89.05) UC1.AF7
  TOP w0.122: v6(98.39,63.4) 98.39,63.44 UD8.K3 ; UD7.K3 108.79,63.44 v6(108.79,63.4)
  IN1 w0.086: v6(98.39,63.4) 97.99,63.4 97.6,63 96.28,63 95.69,63.59 94.62,63.59 v8(94.41,63.8)
  IN4 w0.058: 113.93,87.45 v6(113.93,89.05)
  IN4 w0.086: 113.93,87.45 113.93,84.59 114.02,84.51 114.38,84.51 114.46,84.42 114.46,84.25 114.38,84.16 114.02,84.16 113.93,84.07 113.93,83.9 114.02,83.81 114.38,83.81 114.46,83.73 114.46,83.56 114.38,83.47 114.02,83.47 113.93,83.38 113.93,83.21 114.02,83.12 114.38,83.12 114.46,83.04 114.46,82.86 114.38,82.78 114.02,82.78 113.93,82.69 113.93,82.52 114.02,82.43 114.38,82.43 114.46,82.35 114.46,82.17 114.38,82.09 114.02,82.09 113.93,82 113.93,81.83 114.02,81.74 114.38,81.74 114.46,81.66 114.46,81.48 114.38,81.4 114.02,81.4 113.93,81.31 113.93,81.14 114.02,81.05 114.38,81.05 114.46,80.96 114.46,80.79 114.38,80.71 114.02,80.71 113.93,80.62 113.93,80.45 114.02,80.36 114.38,80.36 114.46,80.27 114.46,80.1 114.38,80.01 114.02,80.01 113.93,79.93 113.93,79.76 114.02,79.67 114.38,79.67 114.46,79.58 114.46,79.41 114.38,79.32 114.02,79.32 113.93,79.24 113.93,79.06 114.02,78.98 114.38,78.98 114.46,78.89 114.46,78.72 114.38,78.63 114.02,78.63 113.93,78.55 113.93,78.37 114.02,78.29 114.35,78.29 114.44,78.2 114.44,78.03 114.35,77.94 114.02,77.94 113.93,77.86 113.93,77.68 114.02,77.6 114.35,77.6 114.44,77.51 114.44,77.34 114.35,77.25 114.02,77.25 113.93,77.16 113.93,76.99 114.02,76.91 114.35,76.91 114.44,76.82 114.44,76.65 114.35,76.56 114.2,76.56 114.11,76.47 114.11,76.29 114.19,76.21 114.68,76.21 114.77,76.13 114.77,75.96 114.68,75.87 114.35,75.87 114.26,75.78 114.26,75.61 114.35,75.52 114.68,75.52 114.77,75.44 114.77,75.26 114.68,75.18 114.35,75.18 114.26,75.09 114.26,74.92 114.35,74.83 114.68,74.83 114.77,74.75 114.77,74.57 114.68,74.49 114.45,74.49 114.36,74.4 114.36,74.23 114.45,74.14 114.68,74.14 114.77,74.06 114.77,73.88 114.68,73.8 114.45,73.8 114.36,73.71 114.36,73.54 114.45,73.45 114.68,73.45 114.77,73.36 114.77,73.19 114.68,73.11 114.35,73.11 114.26,73.02 114.26,72.85 114.35,72.76 114.68,72.76 114.77,72.67 114.77,72.5 114.68,72.41 114.49,72.41 114.41,72.33 114.41,71.4 114.53,71.27 114.53,65.17 114.17,64.81 114.02,64.81 113.4,64.18 113.16,64.18 112.83,63.85 v7(112.4,63.85) 112.26,63.71 111.38,63.71 111.3,63.63 109.77,63.63 109.54,63.4 v6(108.79,63.4) 108.53,63.14 108.34,63.14 108.25,63.23 108.25,63.47 108.16,63.55 107.99,63.55 107.91,63.47 107.91,63.23 107.82,63.14 107.49,63.14 107.41,63.23 107.41,63.24 107.32,63.32 107.15,63.32 107.06,63.24 107.06,63.23 106.98,63.14 106.8,63.14 106.72,63.23 106.72,63.24 106.63,63.32 106.46,63.32 106.37,63.24 106.37,63.23 106.29,63.14 106.11,63.14 106.03,63.23 106.03,63.24 105.94,63.32 105.77,63.32 105.68,63.24 105.68,63.23 105.59,63.14 105.42,63.14 105.34,63.23 105.34,63.24 105.25,63.32 105.08,63.32 104.99,63.24 104.99,63.23 104.9,63.14 104.73,63.14 104.64,63.23 104.64,63.24 104.56,63.32 104.39,63.32 104.3,63.24 104.3,63.23 104.21,63.14 103.56,63.14 103.22,63.48 102.59,63.48 102.37,63.7 102.22,63.85 v7(102,63.85) 101.87,63.72 101.14,63.72 100.99,63.57 98.56,63.57 v6(98.39,63.4)
DDR_B_PARITY: length 57.2
  TOP w0.081: UC1.AJ7 117.58,88.7 117.93,88.34 118.69,88.34 118.92,88.12 118.92,87 v6(118.95,86.97)
  IN4 w0.086: v6(118.95,86.97) 118.95,87.65 119.04,87.73 119.73,87.73 119.81,87.65 119.81,87.05 119.19,86.43 119.19,62.33 116.26,59.4 113.14,59.4 112.79,59.05 v8(112.4,59.05) 112.36,59.01 109.24,59.01 v6(109.2,59.05) 108.85,58.7 102.35,58.7 v8(102,59.05) 101.96,59.01 98.84,59.01 v6(98.8,59.05) 98.26,58.51 94.62,58.51 v7(94.41,58.72)
DDR_DRAMRST#_R: length 96.5
  TOP w0.081: v5(103.31,57.88) 102.49,57.05 CD114.1 ; CD114.1 103.25,58.6 103.25,59.97 103.5,60.23 103.7,60.23 104.52,61.05 106.87,61.05 107.27,60.65 UD7.P1 ; CD114.1 100.62,58.13 97.98,58.13 97.6,58.51 97.6,60.42 97.37,60.65 UD8.P1 ; UD3.P1 130.09,60.65 129.73,60.29 129.35,60.29 129.16,60.1 129.16,58.57 129.67,58.07 v5(129.67,57.94) 123.89,57.94 123.51,58.32 123.51,60.29 123.15,60.65 UD4.P1 122.79,60.96 CD113.2
  BOTTOM w0.081: 118.43,58.07 118.43,59.27 117.73,59.97 117.14,59.97 116.07,61.04 114.39,61.04 UD5.P1 ; 118.43,58.07 118.61,58.07 CD112.2 119.05,57.62 129.35,57.62 v5(129.67,57.94) ; 118.43,58.07 118.11,57.75 103.44,57.75 v5(103.31,57.88) 103.19,58 103.19,60.12 103.42,60.35 103.42,60.37 103.6,60.55 UD6.P1 ; CD111.2 141.99,56.9 141.99,56.61 141.73,56.35 136.86,56.35 v2(136.28,56.93) 135.78,57.43 130.87,57.43 130.37,57.94 v5(129.67,57.94) ; CD111.2 CD69.1 ; CD111.2 141.85,57.53 RD31.1 ; CD111.2 142.43,57.72 142.43,58.89 141.61,59.71 140.84,59.71 UD1.P1 ; v5(129.67,57.94) 130.05,58.32 130.05,60.1 UD2.P1
DDR_RCOMP0: length 4.6
  TOP w0.254: 98.98,84.2 99.57,84.79 UC1.G1
  TOP w0.381: 98.98,84.2 98.54,84.2 97.2,82.86 RH148.2
DDR_RCOMP1: length 3.1
  TOP w0.381: RH149.2 v2(100.01,82.91) 100.01,83.13 100.63,83.75 UC1.H1
DDR_RCOMP2: length 3.8
  TOP w0.381: UC1.J2 101.27,85.1 101.27,82.96 v2(101.36,82.87) 101.36,82.42 RH150.2
DDR_VTT_PG_CTRL: length 49.5
  TOP w0.081: UC2.2 143.03,49.62 v5(143.3,49.35)
  TOP w0.089: UC1.BT13 137.29,92.81 v5(137.85,93.38)
  IN4 w0.058: v5(143.3,49.35) 143.53,49.58 143.53,64.84 143.32,65.05 143.32,65.69 144.12,66.49 144.12,74.92 140.65,78.39 v7(140.65,82.96)
  BOTTOM w0.102: v7(140.65,82.96) v2(139.93,83.68) 139.93,84.25 138.51,85.68 138.51,92.8 137.93,93.38 v5(137.85,93.38)
DDRID_0: length 14.1
  TOP w0.089: v5(98.46,29.93) 98.42,29.9 98.42,29.75 98.79,29.38 UH1.AW13
  IN1 w0.058: v5(98.81,19.98) 99.19,20.36 99.19,21.05 99.76,21.62 99.76,22.69
  IN1 w0.089: v5(98.46,29.93) 98.46,25.33 99.19,24.6 99.19,23.71 99.76,23.14 99.76,22.69
  BOTTOM w0.081: v2(98.11,20.13) 98.11,19.28 RH1023.2 98.21,19.18 RH1024.2 v5(98.81,19.98)
DDRID_1: length 13.7
  TOP w0.081: RH1025.2 RH1026.2 89.92,24.54 90.11,24.35 90.32,24.35
  TOP w0.089: 90.32,24.35 90.42,24.35 91,23.78 v8(91,23.01) ; UH1.BE9 97.02,26.54 97.23,26.33 97.23,25.95 96.99,25.72 96.99,25.28 97.13,25.14 97.13,25.07 v5(97.41,24.8)
  IN1 w0.089: v5(97.41,24.8) 97.22,24.8 96.74,25.28 96.43,25.28 95.14,23.98 95.14,23.41 94.93,23.21 94.74,23.21 94.68,23.14 94.23,23.14 94.11,23.01 v8(91,23.01)
  BOTTOM w0.089: v2(97.76,25.15) 97.41,24.8 v5(97.41,24.8)
DDRID_2: length 11.9
  TOP w0.081: v8(89.66,21.71) RH1027.2
  TOP w0.089: v5(96.59,24.19) 96.43,24.19 96.08,24.54 96.08,25.49 96.34,25.75 UH1.BF8
  IN1 w0.058: v8(89.66,21.71) 89.66,21.68 89.98,21.36 90.36,21.36 90.61,21.62 90.61,21.75 90.83,21.96 91.86,21.96 92.01,21.81 94.42,21.81 95.18,22.57
  IN1 w0.089: 95.18,22.57 95.49,22.88 95.49,23.7 95.98,24.19 v5(96.59,24.19)
DDRID_3: length 11.1
  TOP w0.081: v8(90.93,21.71) RH1029.2
  TOP w0.089: v5(97.22,24.28) 97.22,24.35 96.95,24.61 96.95,25.07 96.74,25.28 96.74,25.84 UH1.BF9
  IN1 w0.058: v8(90.93,21.71) 91.02,21.62 94.65,21.62 95.3,22.27 95.33,22.27 95.43,22.38
  IN1 w0.089: 95.43,22.38 95.67,22.61 95.67,23.54 95.76,23.63 97.07,23.63 97.16,23.72 97.16,24.22 v5(97.22,24.28)
DDRID_4: length 9.6
  TOP w0.081: v8(90.3,21.71) RH1032.2
  TOP w0.089: v5(96.59,24.92) 96.51,25 UH1.BG8
  IN1 w0.058: 95.05,22.69 94.95,22.59 94.95,22.56 94.76,22.38 90.61,22.38 90.3,22.06 v8(90.3,21.71)
  IN1 w0.089: v5(96.59,24.92) 96.57,24.89 96.43,24.89 95.31,23.78 95.31,22.95 95.05,22.69
DEBUG_CTL1: length 1.9
  TOP w0.081: v2(93.55,141.18) 93.57,141.15 v1(94.55,141.15)
  GND2 w0.254: v3(94.79,140.82) 94.55,141.06 v1(94.55,141.15)
  GND4 w0.254: v3(94.79,140.82) 94.91,140.82 95.11,140.62 v4(95.2,140.62)
DEBUG_CTL2: length 1.2
  GND4 w0.081: v4(95.7,140.12) 95.45,140.36 95.45,140.88 v3(95.19,141.15)
DEMB0: length 1.9
  TOP w0.081: UM8.53 69.35,133.87 RM75.2 RM79.2
DEMB1: length 2.5
  TOP w0.081: RM62.2 71.52,133.59 RM86.2 70.37,134.11 70,134.11 69.85,134.27 UM8.54
DEPOP#_EC: length 91
  TOP w0.076: UE5.E9 79.42,15.62 79.81,15.62 79.92,15.73 79.92,15.97 80.06,16.11 80.3,16.11 80.41,16.22 80.41,16.97 80.27,17.12 80.06,17.12 79.92,17.26 79.92,18.44
  TOP w0.081: v8(79.88,18.79) 79.91,18.79 79.92,18.78 79.92,18.44
  IN1 w0.058: v5(11.49,8.22) 12.71,9.43 66.83,9.43 70.08,12.68 70.08,14.85 71.16,15.93 71.16,16.23 73.62,18.69 78.85,18.69 79.01,18.53 79.6,18.53 79.67,18.6 79.7,18.6 v8(79.88,18.79)
  BOTTOM w0.081: v5(11.49,8.22) 11.47,8.22 11.2,8.49 11.2,13.97 10.48,14.7 6.13,14.7 5.86,14.97 JIO1.G9
DEVSLP1: length 45.3
  TOP w0.081: JSSD3.38 127.4,9.88 127.05,9.53 121.41,9.53 120.78,10.16 120.78,12.85 119.53,14.1 v2(117.61,14.1) 115.09,14.1 114.96,14.23 v1(114.96,17.37)
  TOP w0.089: v5(109.7,34.21) 109.59,34.32 UH1.AH35
  GND2 w0.081: v12(114.81,17.07) 114.81,17.22 v1(114.96,17.37)
  IN2 w0.058: 114,22.69 114,22.68 114,22.67 114,22.07 112.87,20.94 112.87,20.47 112.52,20.12 112.52,18.72 114.06,17.19 114.69,17.19 v12(114.81,17.07)
  IN2 w0.089: v5(109.7,34.21) 110.31,34.83 111.99,34.83 112.62,34.19 112.62,32.29 111.51,31.17 111.51,30.03 112.12,29.42 112.12,28.4 113.21,27.31 113.21,26.22 114,25.43 114,22.69
DEVSLP4: length 48.8
  TOP w0.081: v2(102.6,12.39) JSSD1.38 102.6,9.97 102.03,9.4 96.32,9.4 95.55,10.16 v1(95.55,12.04)
  TOP w0.089: v8(114.66,31.32) 115.38,31.32 UH1.AR47
  IN1 w0.089: v11(110.72,25.43) 110.72,25.89 111.39,26.56 111.39,27.83 112.27,28.71 112.27,28.98 112.5,29.21 112.93,29.21 113.51,29.8 113.51,29.97 114.66,31.12 v8(114.66,31.32)
  GND2 w0.081: v12(95.63,11.76) 95.63,11.77 95.55,11.84 v1(95.55,12.04)
  GND2 w0.089: v11(110.72,25.43) 110.76,25.39 v12(110.76,25.03)
  IN2 w0.058: 110.85,22.69 110.85,21.57 110.64,21.36 110.64,20.02 109.72,19.1 106.33,19.1 105.54,18.3 105.12,18.3 104.61,17.8 103.01,17.8 101.94,18.87 101.23,18.87 100.83,18.46 99.63,18.46 98.94,17.77 98.94,12.99 97.72,11.76 v12(95.63,11.76)
  IN2 w0.089: 110.85,22.69 110.85,23.57 110.36,24.06 110.36,24.64 v12(110.76,25.03)
DGPU_EN_EC: length 32.6
  TOP w0.076: UE5.D6 78.42,13.62 76.58,13.62
  TOP w0.081: 76.58,13.62 76,13.62 v1(75.61,14)
  GND2 w0.081: v1(75.61,14) 75.54,14.07 v3(75.54,14.37)
  IN3 w0.058: v9(74.43,17.52) 74.67,17.28 74.73,17.28 75.22,16.79 75.22,16.38 75.13,16.29 74.95,16.11 74.95,15.87 75.27,15.55 75.27,15.15 75.54,14.89 v3(75.54,14.37)
  GND4 w0.081: v9(74.43,17.52) v6(74.18,17.52)
  IN4 w0.058: v6(74.18,17.52) 74.09,17.52 73.69,17.11 67.94,17.11 65.7,19.36 65.7,25.14 62.14,28.7 62.14,29.53 v7(62.67,30.06)
  BOTTOM w0.081: PRV227.1 64.69,30.53 64.44,30.29 63.5,30.29 63.49,30.29 62.9,30.29 v7(62.67,30.06)
DGPU_HOLD_RST#: length 15
  TOP w0.089: v5(103.41,30.47) 103.28,30.34 103.28,28.97 UH1.BB20
  IN1 w0.058: 101.6,22.69 101.6,20.45
  IN1 w0.081: 101.6,20.45 v8(101.6,19.87)
  IN1 w0.089: 101.6,22.69 101.6,22.89 100.84,23.65 100.84,24.28 101.48,24.92 101.48,25.68 102.3,26.51 102.3,29.11 103.41,30.22 v5(103.41,30.47)
DGPU_PEX_RST#: length 254.5
  TOP w0.081: v8(136.65,140.62) QV96.2 ; v1(90.73,139.63) 90.85,139.74 91.81,139.74 v2(93.11,138.44) 93.52,138.03 95.98,138.03 96.56,138.61 96.84,138.61 97.45,139.22 98.86,139.22 98.93,139.3 113.41,139.3 114.12,138.58 UX1.2 120.52,139.22 120.52,139.6 121.01,140.08 121.01,142.03 121.09,142.11 121.89,142.11 122.03,141.97 122.03,141.37 122.32,141.08 122.82,141.08 123.6,141.86 126.09,141.86 v8(126.49,142.27) ; QG7.5 62.17,89.97 61.98,89.79 61.21,89.79 60.86,90.15 60.86,92.14 61.36,92.64 61.84,92.64 62.18,92.98 v8(62.2,92.98) 62.26,92.93 62.26,92.71 62.17,92.62 QG7.2 ; v5(68.45,88.42) 69.16,89.13 69.16,90.96 69.53,91.33 69.53,93.94 71.73,96.15 71.73,99 70.14,100.6 65.9,100.6 65.39,101.11 62.54,101.11 62.31,100.88 RG4.1 ; v5(91.95,18.89) 92.08,18.89 92.46,19.27 RG537.2
  TOP w0.117: v1(68.33,121.41) 68.12,121.62 67.31,121.62 67.07,121.85 67.05,121.85 65.79,123.12 64.01,123.12 63.06,122.17 62.87,122.17 62.71,122.01 62.65,122.01 61.77,121.13 61.77,121.11 60.61,119.96 60.61,116.47 63.5,113.58 63.5,110.75 61.72,108.97 61.72,101.5 61.98,101.24 RG4.1
  IN1 w0.058: v5(68.45,88.42) 67.13,89.74 66.52,89.74 63.28,92.98 v8(62.2,92.98) ; v8(136.65,140.62) 136.5,140.62 134.85,142.27 v8(126.49,142.27)
  GND2 w0.081: v12(68.58,121.69) 68.58,121.67 v1(68.33,121.41) ; v1(90.73,139.63) 90.58,139.47 90.57,139.47 90.57,139.45 v12(90.54,139.45)
  IN2 w0.058: v12(68.58,121.69) 68.99,122.1 68.99,122.64 74.01,127.67 74.01,130.11 70.94,133.18 70.94,136.3 72.55,137.91 72.79,138.15 75.2,138.15 76.97,139.92 79.25,139.92 79.47,139.7 85.76,139.7 86.6,138.85 86.6,138.42 87.69,137.33 88.69,137.33 90.54,139.18 v12(90.54,139.45)
  IN3 w0.058: v9(84.62,36.93) 84.55,36.86 83.52,36.86 82.13,38.25 82.04,38.34 82.04,38.84 82.04,38.97 82.04,39.1 82.13,39.2 82.13,43.94 81.05,45.02 81.05,56.8 v9(81.2,56.95)
  GND4 w0.081: v4(81.47,57.66) 81.47,57.27 81.2,57.01 v9(81.2,56.95) ; v9(84.62,36.93) 84.44,36.75 v6(84.44,36.73)
  IN4 w0.058: v7(70.29,84.58) 70.18,84.69 70.18,86.37 v7(70.29,86.48) ; v5(91.95,18.89) 91.88,18.95 91.88,22.69 ; v6(84.44,36.73) 84.45,36.72 84.45,36.37 84.52,36.3 84.52,30.91 89.02,26.41 89.38,26.41 90.32,25.47
  IN4 w0.089: 90.32,25.47 90.44,25.47 91.88,24.03 91.88,22.69
  BOTTOM w0.081: v7(70.29,86.48) 70.29,87.22 69.98,87.53 68.77,87.53 68.45,87.85 v5(68.45,88.42) ; v4(81.47,57.66) 81.18,57.66 80.82,58.02 80.82,59.77 81.47,60.42 81.47,62.49 82.18,63.2 82.18,64.01 81.51,64.69 UG22.1 80.31,64.69 79.56,65.44 79.56,69.31 78.46,70.41 78.46,72.91 78.87,73.32 78.87,74.5 79.6,75.23 79.6,78.35 76.97,80.98 71.56,80.98 71,81.54 71,83.78 70.87,83.91 70.42,83.91 70.29,84.05 v7(70.29,84.58)
