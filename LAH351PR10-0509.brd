# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGPU_PEX_RST#_R: length 5.4
  TOP w0.117: RG4.2 61.4,101.3 61.29,101.4 v2(61.29,101.72) 60.98,101.72 60.97,101.71 58.06,101.71 57.91,101.57 57.91,101.01 UG1.BK26
DGPU_PRSNT#: length 11.3
  TOP w0.089: UH1.BD38 110.8,26.77 110.8,25.79 110.63,25.62 110.63,25.15 110.46,24.98 v5(110.46,23.36)
  IN1 w0.058: 108.77,22.69 107.17,21.1 v8(107.17,19.25)
  IN1 w0.089: 108.77,22.69 109.03,22.95 109.03,23.67 109.6,24.24 109.9,24.24 110.24,23.9 110.24,23.58 v5(110.46,23.36)
DGPU_PWR_EN_12262494: length 225.1
  TOP w0.076: UE5.B1 77.66,10.57
  TOP w0.081: v8(3.75,7.11) 3.63,6.99 2.44,6.99 2.02,7.41 RG1520.1 ; v5(5.97,4.73) 6.42,4.73 6.75,5.06 UG26.1 ; 77.66,10.57 77.66,10.56 v6(77.43,10.32)
  TOP w0.254: v5(102.13,31.62) 102.13,31.82 UH1.AN18
  IN1 w0.058: v8(3.75,7.11) 5.71,5.14 5.71,4.99 v5(5.97,4.73)
  IN2 w0.058: 90.32,24.95 89.73,25.53 89.73,38.03 88.27,39.5 v6(88.27,40.26) ; v6(77.43,10.32) 77.04,9.93 77.04,8.46 76.88,8.3 76.88,5.75 v4(77.34,5.29)
  IN2 w0.089: 90.32,24.95 v3(90.35,24.92)
  IN3 w0.058: v5(5.97,4.73) 5.97,4.03 6.6,3.4 7.62,3.4 9.09,1.93 13.22,1.93 13.46,2.18 13.73,2.18 13.85,2.3 14.49,2.3 15.11,1.68 22.94,1.68 24.95,3.69 28.4,3.69 28.4,3.69 31.13,3.69 31.99,4.55 39.01,4.55 40.48,6.02 42.75,6.02 43.43,5.89 44.07,5.62 44.18,5.55 44.65,5.24 46.54,3.35 48.56,3.35 49.57,2.33 64.86,2.33 65.43,2.9 70.19,2.9 70.31,3.02 75.99,3.02 76.4,2.61 v9(77.33,2.61) ; 90.32,24.92 88.49,24.92 83.91,20.33 80.17,20.33 80.03,20.19 77.88,20.19 77.74,20.33 75.57,20.33 73.74,18.5 73.74,17.53 74.36,16.91 74.36,16.49 74.16,16.29 74.16,15.92 74.32,15.77 74.32,12.14 74.12,11.94 74.12,10.49 v9(73.94,10.31)
  IN3 w0.089: v5(102.13,31.62) 101.95,31.62 101.54,31.21 101.54,30.41 101.45,30.32 100.52,30.32 97.79,27.59 97.79,27.08 97.35,26.63 92.62,26.63 90.91,24.92 v3(90.35,24.92) 90.32,24.92
  GND4 w0.081: v9(73.94,10.31) 74.07,10.31 v6(74.24,10.14) ; v4(77.47,2.82) 77.47,2.74 77.34,2.61 v9(77.33,2.61)
  IN4 w0.058: v6(77.43,10.32) 77.4,10.29 74.4,10.29 v6(74.24,10.14) ; v7(70.29,94.13) 71.01,93.42 v6(71.01,90.79) 71.01,90.77 71.01,90.36 69.71,89.06 69.71,85.1 69.25,84.65 69.15,84.54 69.15,83.08 70.16,82.06 70.16,81.47 72.24,79.4 72.24,73.5 72.33,73.4 72.7,73.03 72.7,72.73 74.46,70.97 75.15,70.97 75.83,70.29 75.83,69.9 80.77,64.97 80.77,58.17 81.05,57.89 81.05,49.07 80.71,48.74 80.71,45.83 86.28,40.26 v6(88.27,40.26)
  BOTTOM w0.081: v4(77.47,2.82) 77.42,2.87 77.42,5.13 77.34,5.21 v4(77.34,5.29)
  BOTTOM w0.089: RH537.1 102.93,31.59 103.37,32.02 v2(103.95,32.02)
  BOTTOM w0.254: RH537.1 102.17,31.59 v5(102.13,31.62)
  vias: v3(71.02,90.79)
DGPU_PWROK: length 5.9
  TOP w0.089: v5(99.95,24.51) 99.89,24.57 99.89,25.11 100,25.23 100,25.67 99.54,26.14 99.54,26.29 UH1.BE14
  BOTTOM w0.089: v5(99.95,24.51) 99.79,24.35 99.79,23.29 v10(99.82,23.27) 99.92,23.17 99.92,22.69
  BOTTOM w0.114: 99.92,22.69 99.92,22.38 99.39,21.85 RH516.2
DGPU_ROM_SCLK: length 39.6
  TOP w0.081: RG100.2 59.54,78.76 v8(59.26,78.48) ; v8(67.69,89.69) 68.45,90.45 68.45,92.33 67.67,93.12 ; 67.24,93.12 67.67,93.12 ; 67.67,93.12 68.69,94.15 CG895.1
  IN1 w0.058: v8(67.69,89.69) 67.82,89.69 68.91,88.6 68.91,88.04 69.6,87.35 69.6,82.27 68.58,81.26 68.58,78.82 68.28,78.51 68.28,76 69.37,74.91 69.37,74.53 69.05,74.21 v8(65.37,74.21) 65.37,75.37 63.25,77.5 61.24,77.5 60.38,78.36 59.37,78.36 v8(59.26,78.48) 58.98,78.2 v8(58.98,76.98)
DGPU_ROM_SI: length 1.6
  TOP w0.081: UG34.5 67.24,95.13 RG77.1
DGPU_ROM_SO_R: length 1.7
  TOP w0.081: RG76.2 75.87,91.85 74.49,91.85
DH_1.2V: length 0.9
  BOTTOM w0.081: v2(148.24,50.92) 147.89,50.92 v5(147.52,50.56)
  vias: v5(147.52,49.99) v5(151.38,58.96) v5(151.38,58.38)
DIFFOUT_2PH: length 3.8
  TOP w0.203: PRZ9.1 144.27,123.23 v5(144.27,123.54) 144.12,123.69 PUZ1.35
  BOTTOM w0.081: v2(143.75,124.16) 144.27,123.64 v5(144.27,123.54)
  BOTTOM w0.254: PRZ36.2 144.46,123.23 144.27,123.42 v5(144.27,123.54)
DIFFOUT_4PH: length 6
  TOP w0.203: PUZ1.4 144.52,131.53 144.78,131.79 144.78,132.35 144.97,132.54 PRZ38.2 145.48,133.17 v2(145.48,134.48) 145.48,135.22 144.84,135.85 PCZ20.2
DISP_CEC: length 13.7
  IN1 w0.058: JDP.6 114.36,150.4 118.87,150.4 119.76,149.51 119.76,144.53 v8(118.75,143.51)
DISP_CLK_AUXP_CONN: length 16.8
  BOTTOM w0.081: JDP.16 116.29,149.33 115.2,148.25 115.2,147.44 v2(118.7,143.94) 120.78,143.94 121.95,142.77 121.95,140.89 121.16,140.11 120.49,140.11 RV15.2 119.95,140.43 119.9,140.37 UV3.4
DISP_DAT_AUXN_CONN: length 16.8
  BOTTOM w0.081: JDP.18 116.33,147.47 116.33,146.97 118.9,144.4 120.58,144.4 v2(120.97,144.4) 122.41,142.96 122.41,140.7 121.35,139.64 120.25,139.64 120.17,139.56 RV16.2 119.95,138.39 119.93,138.42 UV3.7
DISP_OFF#: length 42.6
  TOP w0.081: v8(23.69,134.36) 24.53,134.36 DV1.1 24.98,133.96 25.48,134.45 25.48,134.5 25.75,134.77 RV1.1 26.09,133.89 26.17,133.81 v2(26.48,133.81)
  IN1 w0.058: v8(23.69,134.36) 23.01,135.03 23.01,138.53 31.52,147.04 31.52,151.59 34.26,154.33 43.97,154.33 v5(45.72,152.58)
  BOTTOM w0.081: v5(45.72,152.58) 45.75,152.55 JEDP.21
DL_1.2V:
  vias: v10(150.09,50.37)
DMI_CRX_PTX_N0: length 60.9
  TOP w0.089: 107.31,49.23 v5(107.14,49.41)
  TOP w0.107: UH1.C33 108.9,47.14 108.56,47.47 108.56,47.48 107.64,48.41 107.64,48.58 107.31,48.91 107.31,49.23
  TOP w0.117: UC1.E8 v5(98.46,89.5)
  IN4 w0.076: 103.19,49.77 99.93,53.04 98.44,53.04 98.03,53.44 94.87,53.44 90.25,58.07 90.25,69.73 90.97,70.45 90.97,80.39 91.88,81.31 91.88,82.32 93.37,83.81 94.01,83.81 96.08,85.88 96.08,88.01 96.87,88.8 97.89,88.8 98.12,89.03 98.12,89.32 98.3,89.5 v5(98.46,89.5)
  IN4 w0.089: v5(107.14,49.41) 107.25,49.41 107.34,49.32 107.34,49.07 107.14,48.87 105.02,48.87 104.52,49.37 103.6,49.37 103.19,49.77
DMI_CRX_PTX_N1: length 60.7
  TOP w0.089: 106.32,49.62 v5(106.14,49.8)
  TOP w0.107: 106.32,49.62 106.32,49.2 107.13,48.39 107.13,48.17 107.21,48.09 107.21,48.08 107.62,47.67 107.62,47.67 107.76,47.54 107.76,47.38 107.97,47.17 108.07,47.17 108.19,47.05 UH1.C32
  TOP w0.117: v5(99.11,88.71) 99.11,88.66 UC1.F6
  IN4 w0.076: v5(99.11,88.71) 98.97,88.71 98.6,88.34 97.56,88.34 96.94,87.72 96.94,85.26 96.53,84.85 95.61,84.85 94.2,83.44 93.64,83.44 92.52,82.32 92.52,80.93 91.77,80.18 91.77,70.42 90.83,69.48 90.83,58.31 94.63,54.51 101.83,54.51 102.73,53.61 102.73,51.06 103.8,50
  IN4 w0.089: 103.8,50 104.59,50 105.22,49.37 106.11,49.37 106.28,49.54 106.28,49.66 v5(106.14,49.8)
DMI_CRX_PTX_N2: length 58.6
  TOP w0.089: v5(105.34,50.66) 105.54,50.46 105.54,50.1 105.51,50.07 105.51,49.92 105.51,49.91
  TOP w0.107: 105.51,49.91 105.51,49.45 106.74,48.23 106.74,48 106.82,47.92 106.82,47.91 106.89,47.84 106.89,47.78 107.18,47.44 107.17,47.39 107.22,47.34 107.35,47.21 107.35,47.2 UH1.C31
  TOP w0.117: v5(98.46,87.92) 98.46,87.85 UC1.E5
  IN4 w0.076: v5(98.46,87.92) 98.31,87.92 98.23,87.85 98.23,87.53 97.85,87.15 97.85,86.77 98.03,86.59 98.03,85.87 97.66,85.5 97.66,85.05 97.05,84.45 95.73,84.45 94.36,83.07 93.9,83.07 93.15,82.32 93.15,80.61 92.6,80.05 92.6,70.42 91.41,69.24 91.41,58.58 94.88,55.12 102.59,55.12 103.45,54.26 103.45,52.21 103.46,52.2 103.46,51.19 104.01,50.64 104.71,50.64 105.08,50.27 105.43,50.27 105.52,50.37 105.52,50.47 v5(105.34,50.66)
DMI_CRX_PTX_N3: length 59.6
  TOP w0.089: v5(104.29,51.04) 104.43,50.9 104.43,49.46 104.53,49.36 104.53,49.32 104.57,49.29 104.57,49.28 104.58,49.26
  TOP w0.107: UH1.C29 106.69,47.11 106.48,47.32 106.48,47.38 106.44,47.43 106.41,47.43 106.09,47.76 105.82,47.76 105.26,48.31 105.26,48.58 104.58,49.26
  TOP w0.117: UC1.J9 v5(100.47,90.29)
  IN4 w0.076: v5(104.29,51.04) 104.31,51.04 104.59,51.32 104.59,52.03 104.01,52.61 104.01,54.24 102.67,55.58 94.96,55.58 91.8,58.74 91.8,69.08 92.98,70.27 92.98,79.58 93.65,80.25 93.65,82.13 95.8,84.28 97.68,84.28 98.51,85.11 98.51,86.54 99,87.02 99,88.01 99.56,88.57 99.56,89.52 100.11,90.08 100.26,90.08 v5(100.47,90.29)
DMI_CRX_PTX_P0: length 60.9
  TOP w0.089: 107.68,49.41 v5(107.72,49.45)
  TOP w0.107: UH1.B33 108.7,47.62 107.83,48.49 107.83,48.66 107.51,48.99 107.51,49.24 107.68,49.41
  TOP w0.117: v5(97.81,89.5) 98.14,89.17 UC1.D8
  IN4 w0.076: v5(97.81,89.5) 97.92,89.39 97.92,89.12 97.8,89 96.79,89 95.87,88.09 95.87,85.96 93.92,84.01 93.29,84.01 91.68,82.41 91.68,81.39 90.77,80.48 90.77,70.54 90.04,69.81 90.04,57.99 94.79,53.24 97.95,53.24 98.35,52.83 99.84,52.83 102.91,49.77
  IN4 w0.089: v5(107.72,49.45) 107.52,49.25 107.52,49 107.21,48.7 104.94,48.7 104.45,49.19 103.52,49.19 103.04,49.68 103,49.68 102.91,49.77
DMI_CRX_PTX_P1: length 60.6
  TOP w0.089: 106.61,49.72 106.64,49.72 v5(106.73,49.8)
  TOP w0.107: 106.61,49.72 106.52,49.63 106.52,49.28 107.33,48.47 107.33,48.25 107.7,47.88 107.71,47.88 107.96,47.62 107.96,47.47 108.06,47.37 108.1,47.37 108.19,47.47 UH1.B32
  TOP w0.117: UC1.E6 98.46,88.64 v5(98.46,88.71)
  IN4 w0.076: v5(98.46,88.71) 98.46,88.64 98.37,88.55 97.47,88.55 96.73,87.81 96.73,85.35 96.44,85.06 95.53,85.06 94.12,83.64 93.55,83.64 92.32,82.41 92.32,81.01 91.57,80.26 91.57,70.51 90.63,69.57 90.63,58.23 94.55,54.31 101.74,54.31 102.53,53.52 102.53,50.98 103.51,50
  IN4 w0.089: 103.51,50 103.69,49.82 104.52,49.82 105.15,49.19 106.18,49.19 106.46,49.46 106.46,49.53 v5(106.73,49.8)
DMI_CRX_PTX_P2: length 58.6
  TOP w0.089: v5(105.92,50.66) 105.74,50.47 105.74,50.04 105.71,50.02 105.71,50.01 105.7,50 105.71,49.99
  TOP w0.107: UH1.B31 107.53,47.4 107.47,47.41 107.09,47.85 107.09,47.92 106.93,48.08 106.93,48.31 105.71,49.53 105.71,49.99
  TOP w0.117: v5(97.81,87.92) 97.81,87.85 UC1.D5
  IN4 w0.076: v5(97.81,87.92) 97.89,87.92 98.03,87.78 98.03,87.62 97.65,87.23 97.65,86.68 97.83,86.51 97.83,85.95 97.46,85.58 97.46,85.14 96.97,84.65 95.64,84.65 94.27,83.28 93.82,83.28 92.95,82.41 92.95,80.69 92.39,80.14 92.39,70.51 91.21,69.33 91.21,58.5 94.79,54.92 102.51,54.92 103.25,54.17 103.25,52.12 103.26,52.11 103.26,51.11 103.93,50.43 104.63,50.43 105,50.07 105.51,50.07 105.73,50.28 105.73,50.47 105.77,50.51 105.78,50.51 v5(105.92,50.66)
DMI_CRX_PTX_P3: length 58.9
  TOP w0.089: v5(104.88,51.04) 104.86,51.04 104.64,50.81 104.64,50.02 104.61,50 104.61,49.57 104.72,49.46 104.72,49.4
  TOP w0.107: 104.72,49.4 105.46,48.66 105.46,48.39 105.9,47.95 106.17,47.95 106.51,47.62 UH1.B29
  TOP w0.117: UC1.J8 100.86,89.31 v5(100.41,89.5)
  IN4 w0.076: v5(100.41,89.5) 100.41,89.78 100.3,89.88 100.2,89.88 99.76,89.44 99.76,88.48 99.2,87.92 99.2,86.94 98.71,86.45 98.71,85.03 97.77,84.08 95.88,84.08 93.85,82.05 93.85,80.16 93.18,79.49 93.18,70.18 92,69 92,58.82 95.04,55.78 102.76,55.78 104.22,54.32 104.22,52.7 104.8,52.12 104.8,51.12 v5(104.88,51.04)
DMI_CTX_PRX_N0: length 68
  TOP w0.076: UC1.A8 96.26,89.03 96.44,89.03 96.52,89.11 96.52,89.33 96.44,89.41 95.89,89.41 95.72,89.59 95.1,89.59 94.83,89.32 94.37,89.32 94.33,89.28
  TOP w0.089: v6(109.18,44.22) 109.39,43.55 UH1.K34
  TOP w0.107: 94.33,89.28 93.97,89.28 93.28,88.59 92.45,88.59 v5(92.14,88.28)
  IN4 w0.076: 99.29,49.77 98.68,50.38 93.41,50.38 87.91,55.88 87.91,70.7 88.63,71.42 88.63,82.81 89.03,83.21 89.03,84.55 89.8,85.32 89.8,86.57 91.79,88.56 91.94,88.56 92.14,88.36 v5(92.14,88.28)
  IN4 w0.089: v6(109.18,44.22) 109.35,44.06 109.35,43.94 109.25,43.84 106.72,43.84 103.26,47.3 102.66,47.3 101.37,48.59 100.47,48.59 99.29,49.77
DMI_CTX_PRX_N1: length 63.6
  TOP w0.076: UC1.B6 96.84,88.25 96.92,88.17 97.03,88.17 97.16,88.3 97.16,88.4 96.96,88.6 96.33,88.6 96.31,88.62 95.08,88.62 95.06,88.65 95.02,88.65
  TOP w0.107: 95.02,88.65 95.01,88.63 94.82,88.63 94.68,88.49 94.68,88.42 v5(94.87,88.23)
  IN4 w0.076: v5(94.87,88.23) 94.78,88.32 94.78,88.52 94.86,88.6 95.14,88.6 95.36,88.37 95.36,86.06 93.69,84.38 93.02,84.38 90.18,81.54 90.18,70.78 89.46,70.05 89.46,57.66 94.52,52.61 97.63,52.61 98.04,52.2 99.62,52.2 101.99,49.84 101.99,49.77
  IN4 w0.089: v6(108.64,44.93) 108.58,44.99 108.58,46.49 107.71,47.36 106.47,47.36 106.22,47.6 106.01,47.6 105.27,48.34 104.72,48.34 104.44,48.62 102.92,48.62 102.09,49.45 102.09,49.69 102.01,49.77 101.99,49.77 101.99,49.77
DMI_CTX_PRX_N2: length 63.4
  TOP w0.076: 95.69,87.78 95.71,87.78 95.74,87.81 95.93,87.81 UC1.A5
  TOP w0.107: v6(108.67,44.14) 108.06,43.53 UH1.K32 ; v5(92.66,86.51) 92.84,86.69 93.4,86.69 94.06,87.36 95.01,87.36 95.44,87.78 95.69,87.78
  IN4 w0.076: v5(92.66,86.51) 92.48,86.69 92.01,86.69 89.73,84.41 89.73,83.01 89.22,82.5 89.22,71.18 88.49,70.45 88.49,56.98 93.87,51.6 96.82,51.6 97.46,50.97 99.18,50.97 100.32,49.82 100.32,49.77
  IN4 w0.089: v6(108.67,44.14) 108.23,44.58 106.48,44.58 105.24,45.82 105.24,47.25 104.84,47.65 102.86,47.65 101.44,49.08 100.98,49.08 100.32,49.74 100.32,49.77
DMI_CTX_PRX_N3: length 60.5
  TOP w0.076: UC1.B4 97.27,86.93 97.27,87.04 97.19,87.12 96.83,87.12 96.7,87.25 95.86,87.25 95.84,87.26 95.77,87.26 95.69,87.26 95.65,87.22 95.63,87.22 95.62,87.22
  TOP w0.107: 95.62,87.22 95.37,86.96 94.26,86.96 93.54,86.25 93.54,86 93.34,85.81 v5(93.29,85.81)
  IN4 w0.076: 101.11,49.77 99.29,51.59 97.63,51.59 97.2,52.02 94.09,52.02 88.87,57.23 88.87,70.3 89.6,71.02 89.6,81.94 90.23,82.58 90.23,83.78 90.94,84.5 92.5,84.5 92.75,84.75 93.27,84.75 93.34,84.83 93.34,85.75 v5(93.29,85.81)
  IN4 w0.089: 101.11,49.77 102.97,47.91 104.84,47.91 106.53,46.22 106.53,45.84 107.2,45.17 v6(107.2,44.96)
DMI_CTX_PRX_P0: length 68
  TOP w0.076: UC1.B8 96.77,89.1 96.71,89.17 96.71,89.41 96.51,89.6 95.98,89.6 95.8,89.78 95.02,89.78 94.75,89.52 94.36,89.52 94.35,89.5
  TOP w0.107: 94.35,89.5 93.88,89.5 93.19,88.81 92.19,88.81 v5(92.14,88.86)
  IN4 w0.076: 99.04,49.77 98.87,49.94 98.85,49.93 98.83,49.93 98.82,49.94 98.82,49.95 98.82,49.95 98.59,50.18 93.32,50.18 87.71,55.8 87.71,70.78 88.43,71.5 88.43,82.9 88.82,83.29 88.82,84.63 89.59,85.4 89.59,86.65 91.7,88.76 92.04,88.76 v5(92.14,88.86)
  IN4 w0.089: v6(109.69,44.25) 109.54,44.1 109.54,43.88 109.32,43.67 106.64,43.67 103.19,47.12 102.59,47.12 101.29,48.41 100.4,48.41 99.04,49.77
DMI_CTX_PRX_P1: length 63.7
  TOP w0.076: UC1.C6 97.03,88.77 96.41,88.77 96.38,88.8 95.15,88.8 95.13,88.82 95.1,88.82 95.09,88.83 95.03,88.83 95.02,88.85 95.01,88.85
  TOP w0.107: 95.01,88.85 94.73,88.85 94.43,88.55 v5(94.25,88.55)
  IN4 w0.076: 102.27,49.77 102.27,49.84 102.17,49.94 102.17,49.94 99.71,52.4 98.12,52.4 97.71,52.81 94.6,52.81 89.66,57.75 89.66,69.97 90.39,70.69 90.39,81.46 93.1,84.18 93.77,84.18 95.57,85.97 95.57,88.45 95.22,88.8 94.77,88.8 94.64,88.67 94.54,88.67 94.43,88.55 v5(94.25,88.55)
  IN4 w0.089: 102.27,49.77 102.27,49.52 103,48.8 104.52,48.8 104.8,48.52 105.34,48.52 106.08,47.78 106.3,47.78 106.54,47.54 107.78,47.54 108.76,46.56 108.76,45.86 v6(109.02,45.6)
DMI_CTX_PRX_P2: length 63.4
  TOP w0.076: UC1.B5 96.66,87.53 96.32,87.87 96.19,88 95.74,88 95.71,88.03 95.69,88.03
  TOP w0.107: v5(92.66,87.1) 92.84,86.91 93.3,86.91 93.97,87.58 94.92,87.58 95.37,88.03 95.69,88.03 ; v6(107.87,44.21) UH1.J32
  IN4 w0.076: v5(92.66,87.1) 92.46,86.9 91.92,86.9 89.52,84.5 89.52,83.09 89.01,82.58 89.01,71.26 88.29,70.54 88.29,56.9 93.79,51.4 96.74,51.4 97.38,50.76 99.09,50.76 100.08,49.77
  IN4 w0.089: v6(107.87,44.21) 107.69,44.4 106.41,44.4 105.07,45.74 105.07,47.17 104.76,47.48 102.74,47.48 101.31,48.9 100.91,48.9 100.15,49.66 100.15,49.66 100.12,49.7 100.12,49.74 100.08,49.77
DMI_CTX_PRX_P3: length 60.5
  TOP w0.076: UC1.D4 97.28,86.51 97.03,86.51 96.85,86.69 96.85,86.86 96.63,87.07 95.79,87.07 95.78,87.06
  TOP w0.107: v5(93.87,85.81) 93.76,85.91 93.76,86.15 94.35,86.74 95.46,86.74 95.78,87.06
  IN4 w0.076: 101.36,49.77 101.24,49.9 101.24,49.93 99.38,51.79 97.71,51.79 97.28,52.22 94.17,52.22 89.08,57.32 89.08,70.21 89.8,70.94 89.8,81.86 90.44,82.49 90.44,83.7 91.03,84.29 92.58,84.29 92.84,84.55 93.35,84.55 93.55,84.74 93.55,85.49 v5(93.87,85.81)
  IN4 w0.089: 101.36,49.77 103.05,48.08 104.91,48.08 106.71,46.29 106.71,45.91 107.11,45.51 107.3,45.51 107.39,45.59 v6(107.39,45.7)
DP_CBL_DET: length 12.1
  TOP w0.081: QG500.2 120.58,141.51 v5(120.58,141.53)
  BOTTOM w0.081: JDP.4 112.8,147.35 v10(115.26,144.89) 117.83,142.32 UV3.1 120.05,142.32 RV17.1 120.58,141.79 v5(120.58,141.53)
DP_CBL_DET#: length 129.8
  TOP w0.081: v8(66.5,87.3) 66.15,86.96 RG501.1 ; RG540.1 116.03,140.74 v2(115.46,140.17) 115.37,140.08 v3(115.37,139.52)
  IN1 w0.058: v8(53.35,85.95) 52.9,86.4 52.9,88.2 55.28,90.58 58.96,90.58 59.95,91.57 60.99,91.57 v5(61.24,91.32) 61.47,91.54 62.86,91.54 65.66,88.74 65.66,88.06 65.91,87.81 65.99,87.81 v8(66.5,87.3)
  IN2 w0.058: v5(64.26,116.87) 65.98,116.87 66.4,116.45 70.92,116.45 71.51,115.86 79.05,115.86 v3(79.58,116.39)
  IN3 w0.058: v3(115.37,139.52) 114.26,138.42 110.11,138.42 109.71,138.01 108.35,138.01 107.41,138.95 97.38,138.95 96.22,137.79 90.19,137.79 87.99,135.59 86.23,135.59 86.15,135.51 74.3,135.51 74.11,135.33 74.11,135 79.39,129.72 79.39,116.57 v3(79.58,116.39)
  IN4 w0.058: v5(64.26,116.87) 64.01,116.61 64.01,111.99 62.58,110.56 62.58,99.2 62.58,99.19 62.58,97.2 62.38,97 62.38,93.38 61.24,92.23 v5(61.24,91.32)
DP_HPD_PCH: length 192.2
  TOP w0.081: UX1.1 121.54,139.61 RX4.1 121.61,140.47 QX2.3 122.62,140 122.15,139.52 122.15,137.18 v3(122.28,137.05) 121.8,137.05 v2(121.35,136.6)
  TOP w0.089: v5(103.86,29.05) 103.86,29.09 UH1.AW24
  IN2 w0.058: v3(81.97,115.11) 81.6,114.74 71.48,114.74 v6(71.15,114.41)
  IN3 w0.058: v3(122.28,137.05) 122.12,136.89 108.47,136.89 107.77,136.2 105.84,136.2 104.95,137.08 101.11,137.08 100.36,137.83 97.92,137.83 96.76,136.67 93.31,136.67 92.48,135.84 89.82,135.84 88.45,134.47 86.7,134.47 85.93,133.71 84.98,133.71 83.44,132.17 83.36,132.17 81.28,130.08 81.28,116.75 81.97,116.06 v3(81.97,115.11)
  IN4 w0.058: v6(71.15,114.41) 72.83,112.72 72.83,111.91 72.35,111.43 72.35,108.78 72.71,108.42 72.71,103.28 72.26,102.83 69.77,102.83 68.31,101.38 68.31,94.63 69.83,93.11 69.83,91.76 69.56,91.49 69.56,91.15 69.44,91.04 69.44,89.54 69.2,89.3 69.2,87.72 68.83,87.35 68.83,86.94 69.16,86.61 69.16,85.14 69.16,85.01 68.83,84.67 68.83,82.95 69.84,81.93 69.84,81.74 69.84,81.34 70.95,80.23 70.95,79.42 71.11,79.26 71.11,75.78 71.87,75.03 71.87,73.42 71.92,73.37 72.38,72.91 72.38,72.56 80.02,64.92 80.02,58.24 80.57,57.69 80.57,49.27 80.23,48.93 80.23,45.63 86.56,39.3 89.36,39.3
  IN4 w0.089: 89.36,39.3 90.33,39.3 91.64,37.99 92.38,37.99 94.23,36.15 94.81,36.15 94.88,36.22 96.33,36.22 96.58,36.48 98.74,36.48 99.18,36.04 99.54,36.04 99.63,35.95 99.63,35.33 99.93,35.03 100.12,35.03 100.33,34.82 100.77,34.82 101.19,34.41 101.19,33.9 101.88,33.21 102.26,33.21 102.65,32.82 102.65,29.71 103.31,29.05 v5(103.86,29.05)
DPSNK_RBIAS: length 2
  TOP w0.081: v2(76.66,137.94) RT19.1 v4(77.15,138.97)
  BOTTOM w0.081: UT1.Y18 v4(77.15,138.97)
DPSRC_RBIAS: length 0.5
  TOP w0.081: v4(82.09,141.85) 82.04,141.85 81.76,142.13 v2(81.67,142.13)
DRVON: length 153.7
  TOP w0.203: v5(138.72,129.82) 138.93,129.62 138.93,129.56 139.4,129.09 140.21,129.09 PUZ1.17
  TOP w0.254: PUZ5.16 v5(114.1,130.69) ; PUZ4.6 97.72,138.47 98.23,138.98 v2(100.18,138.98) 104.46,138.98 105.26,138.18 105.26,134.04 v8(105.05,133.84) ; v8(129.36,117.63) 129.36,117.07 129.16,116.87 128.37,116.87 128.19,117.05 PUZ9.16 ; PUZ2.16 v5(97.14,130.65) ; PUZ8.16 126.6,127 v5(126.58,126.98) ; PUZ10.6 137.54,122.65 137.79,122.39 v5(137.86,122.39) ; v5(89.61,130.66) 89.49,130.54 PUZ3.16 ; PUZ6.16 v5(105.78,130.69) ; PUZ7.6 v5(135.06,132.13)
  IN1 w0.254: v8(142.56,85.5) 142.24,85.82 142.24,87.73 141.03,88.94 141.03,98.36 142.68,100.01 v1(142.68,100.74) ; v8(129.36,117.63) 129.36,119.18 130.25,120.07 133.43,120.07 134.98,121.62 137.08,121.62 v5(137.86,122.39) 138.23,122.39 138.66,122.82 138.66,125.22 139.42,125.99 139.42,126.9 138.25,128.07 138.25,129.35 v5(138.72,129.82) ; v5(105.78,130.69) 105.53,130.69 105,131.22 105,131.75 105.51,132.26 105.51,133.38 v8(105.05,133.84)
  GND2 w0.254: v1(142.68,100.74) v3(142.68,100.74)
  IN3 w0.152: v5(114.1,130.69) 114.6,130.69 115.62,129.67 115.62,125.91 115.77,125.76 121.95,125.76 123.49,127.31 126.25,127.31 v5(126.58,126.98)
  IN3 w0.254: v5(138.72,129.82) 138.66,129.82 136.35,132.13 v5(135.06,132.13) 134.16,132.13 132.84,130.81 132.28,130.81 131.37,129.9 128.07,129.9 127.51,129.34 127.51,127.9 v5(126.58,126.98) ; v5(89.61,130.66) 90.15,130.66 90.96,131.47 96.32,131.47 v5(97.14,130.65) 98.45,131.96 104.51,131.96 v5(105.78,130.69) 105.84,130.69 106.78,131.63 113.16,131.63 v5(114.1,130.69) ; v9(138.05,100.36) 138.43,100.74 v3(142.68,100.74)
  GND4 w0.254: v9(138.05,100.36) v6(137.85,100.15)
  IN4 w0.254: v5(137.86,122.39) 137.86,121.27 136.98,120.4 136.98,115.34 138.81,113.52 138.81,110.16 137.31,108.66 137.31,100.69 v6(137.85,100.15)
EAP_GPU: length 3
  TOP w0.203: PUV1.29 77.39,30.3 v2(78.04,30.95) 78.68,31.59 PRV9.2
EC_AC_BAT#: length 109.8
  TOP w0.076: UE5.D10 v6(78.12,15.86)
  TOP w0.081: UG1.BE6 54.08,86.65 55.11,85.62 55.11,84.47 55.33,84.25 55.46,84.25 55.75,83.97 55.75,83.84 56.03,83.55 56.16,83.55 56.52,83.2 56.52,82.71 57.18,82.04 v1(57.18,80.72) 57.53,80.37 58.32,80.37 58.55,80.14 RG16.1
  GND2 w0.081: v12(57.15,81.05) 57.15,80.75 v1(57.18,80.72)
  IN2 w0.058: v12(57.15,81.05) 57.56,81.05 58.09,81.59 65.02,81.59 65.58,81.03 65.58,80.34 66.89,79.03 69.99,79.03 69.99,79.03 70.09,78.94 71.91,78.94 72.09,78.75 73.25,78.75 73.32,78.68 79.01,78.68 79.3,78.39 79.3,73.84 v4(79.79,73.35)
  IN3 w0.058: v9(82.61,38.86) 82.61,44.01 82.61,44.14 81.54,45.22 81.54,56.45 81.8,56.71 81.8,57.24 80.92,58.12 80.92,59.23 81.53,59.84 v9(81.53,65.31)
  GND4 w0.081: v4(81.38,65.59) 81.53,65.44 v9(81.53,65.31) ; v9(82.61,38.86) 82.46,38.86 v6(82.17,38.57)
  IN4 w0.058: v6(82.17,38.57) 82.17,38.25 82.52,37.9 82.52,29.8 84.35,27.97 84.35,20.01 83.25,18.9 83.25,18.44
  IN4 w0.076: v6(78.12,15.86) 77.98,15.73 77.98,14.53 78.38,14.12 79.38,14.12 79.6,14.35 81.61,14.35 81.76,14.2 82.3,14.2 82.96,14.86 82.96,15.5 82.27,16.18 82.27,17.12 83.25,18.1 83.25,18.44
  BOTTOM w0.081: v4(79.79,73.35) 79.86,73.35 79.86,73.28 80.52,73.28 81.53,72.27 v2(81.53,66.11) 81.53,65.74 v4(81.38,65.59)
EC_ESB_CLK: length 12.7
  TOP w0.076: v1(83.95,14.57) 83.74,14.36 UE5.N7
  GND2 w0.076: v12(84.2,14.57) v1(83.95,14.57)
  IN2 w0.058: v3(90.95,17.12) 90.95,16.59 90.81,16.44 90.2,16.44 89.98,16.22 89.98,14.75 89.47,14.24 84.53,14.24 v12(84.2,14.57)
  GND4 w0.081: v3(90.95,17.12) 91.36,17.12 v4(91.44,17.05)
  BOTTOM w0.081: UE10.1 91.36,17.12 v4(91.44,17.05) 91.52,17.12 91.87,17.12 RE642.2
EC_ESB_DAT: length 13.7
  TOP w0.076: v1(83.62,14.76) 83.47,14.62 82.92,14.62 UE5.M7
  GND2 w0.076: v1(83.62,14.76) 83.57,14.71 v12(83.57,14.51)
  IN2 w0.058: v3(90.97,15.62) 90.97,16.12 90.81,16.28 90.27,16.28 90.14,16.16 90.14,14.68 89.54,14.08 84.2,14.08
  IN2 w0.076: v12(83.57,14.51) 83.67,14.4 83.67,14.25 83.84,14.08 84.2,14.08
  GND4 w0.081: v4(91.44,15.55) 91.36,15.62 v3(90.97,15.62)
  BOTTOM w0.081: UE10.4 91.36,15.62 v4(91.44,15.55) 91.52,15.62 91.88,15.62 RE643.2
EC_LCD_TEST: length 182.3
  TOP w0.081: RD254.1 36.58,145.47 v5(36.68,145.37) ; v8(80.67,89.84) 80.67,100.74 74.02,107.39 v2(74.02,111.98) 74.02,113.31 70.18,117.15 70.18,122 69.97,122.21 67.13,122.21 65.61,123.73 64.03,123.73 63.58,123.27 63.58,122.97 62.98,122.37 62.78,122.37 62.62,122.21 62.57,122.21 61.11,120.75 v1(60.4,120.75)
  IN1 w0.058: v8(80.67,89.84) 80.9,89.61 83.64,89.61 84.28,88.98 v12(84.89,88.98)
  GND2 w0.076: v12(81.41,16.03) 81.24,15.86 v1(81.17,15.86)
  GND2 w0.081: v12(60.2,120.93) 60.32,120.93 60.4,120.85 v1(60.4,120.75)
  IN2 w0.058: v6(58.89,138.64) 59.25,138.28 59.25,136.96 59.9,136.31 59.9,121.26 60.2,120.96 v12(60.2,120.93) ; v12(84.89,88.98) 85.19,88.67 85.19,87.05 84.78,86.63 84.78,84.1 85.11,83.77 85.11,82.08 84.57,81.54 84.57,58.16 85.11,57.61 85.11,57.53 85.32,57.32 85.32,57.3 86.66,55.96 86.66,53.7 84.2,51.23 84.2,45.34 86.29,43.25 86.39,43.16 86.39,31.22 86.24,31.08 86.24,29.82 86.51,29.55 86.51,23.85 84.3,21.64 81.48,21.64 80.95,21.11 80.95,20.09 81.64,19.41 81.64,18.44
  IN2 w0.076: 81.64,18.44 81.64,16.88 81.41,16.65 v12(81.41,16.03)
  IN4 w0.058: v6(58.89,138.64) 58.89,139.16 57.22,140.83 57.22,144.74 55.32,146.64 37.95,146.64 v5(36.68,145.37)
EC_ON: length 52.1
  TOP w0.081: v5(40.9,7.95) 40.9,8.62 v2(41.54,9.26)
  IN1 w0.076: v8(80.17,11.36) v11(79.95,11.58)
  GND2 w0.076: v11(79.95,11.58) v12(79.77,11.4)
  IN2 w0.058: v3(78.13,9.96) 78.74,10.57
  IN2 w0.076: v12(79.77,11.4) 79.77,11.34 78.99,10.57 78.74,10.57
  IN3 w0.058: v3(78.13,9.96) 78.58,9.51 78.58,7.53 78.44,7.39 78.44,5.36 77.69,4.62 69.64,4.62 69.55,4.52 64.55,4.52 63.96,3.93 58.32,3.93 57.94,4.31 54.42,4.31 54.37,4.36 50.69,8.04 45.7,8.04 45.36,7.7 44.61,7.7 44.58,7.67 44.26,7.67 44.23,7.65 41.75,7.65 41.65,7.74 41.45,7.95 v5(40.9,7.95)
  BOTTOM w0.254: PD502.2 42.42,6.34 42.17,6.59 41.76,6.59 40.9,7.45 v5(40.9,7.95)
EC_PECI_R: length 176.5
  TOP w0.081: v1(137.26,110.2) 137.54,109.91 137.54,109.63 137.69,109.48 140.02,109.48 RH1022.1
  GND2 w0.076: v1(80.67,11.86) v12(80.67,12.12)
  GND2 w0.081: v1(137.26,110.2) 137.29,110.23 v12(137.29,110.52)
  IN2 w0.058: v3(78.77,111.97) 79.12,112.32 79.68,112.32 79.86,112.14 81.94,112.14 82.2,112.4 95.55,112.4 96.09,112.95 101.18,112.95 103.09,114.86 113.27,114.86 114.43,113.7 136.3,113.7 137.41,112.59 137.41,110.64 v12(137.29,110.52) ; v3(85.72,86.57) 84.94,85.78 84.94,84.17 85.27,83.84 85.27,82.01 84.73,81.47 84.73,58.22 85.27,57.68 85.27,57.59 86.84,56.03 86.84,53.64 84.43,51.24 84.43,45.42 86.55,43.31 86.55,31.16 86.4,31.01 86.4,29.89 86.68,29.61 86.68,23.5 83.64,20.46 83.64,18.44
  IN2 w0.076: 83.64,18.44 83.64,17.25 82.12,15.73 82.12,13.24 81,12.12 v12(80.67,12.12)
  IN3 w0.058: v3(85.72,86.57) 85.41,86.88 85.41,102.19 79.25,108.35 79.25,111.48 v3(78.77,111.97)
EC_RSMRST#: length 271
  TOP w0.076: 78.23,10.57 78.41,10.75 78.41,12.04 78.41,12.04 78.67,12.3 v8(78.67,12.86)
  TOP w0.081: DE2.2 74.98,9.54 75.69,10.25 77.11,10.25 77.36,10.01 77.67,10.01 78.23,10.57 ; v8(111.05,19.69) RH1017.2 RH88.2 111.05,17.9 111.05,16.41 CE193.2 110.52,15.88 110.52,15 110.95,14.57 v8(110.95,13.78) ; v6(139.57,141.39) 139.57,141.89 139.95,142.27 RC355.2
  TOP w0.122: v5(115.14,27.89) 115.18,27.89 115.5,28.21 UH1.BA47
  IN1 w0.058: v8(110.95,13.78) 110.74,13.58 109.11,13.58 108.84,13.85 107.87,13.85 107.6,13.57 103.07,13.57 102.64,13.15 99.68,13.15 99.11,13.72 91.56,13.72 86.8,8.97 85.42,8.97 84.76,8.31 82.81,8.31 82.54,8.31 81.77,9.08 81.19,9.08 81.17,9.1 81.17,9.1 79.7,10.57 ; v8(111.05,19.69) 111.05,21.29 112.37,22.61 112.37,22.69
  IN1 w0.076: 79.7,10.57 79.26,11.01 78.66,11.01 78.42,11.26 78.42,11.97 78.48,12.03 78.48,12.68 v8(78.67,12.86)
  IN1 w0.089: 112.37,22.69 112.37,25.91 113.09,26.63 113.09,27.32 113.8,28.03 114.05,28.03 114.19,27.89 v5(115.14,27.89)
  IN4 w0.058: v7(86.36,71.88) 85.32,70.84 85.32,54.06 88.52,50.85 88.52,48.92 89.58,47.86 ; v6(139.57,141.39) 139.79,141.39 143.33,137.85 143.33,136.35 142.55,135.57 142.55,134.76 140.8,133.01 137.24,133.01 135.75,134.5 129.19,134.5 129.06,134.5 128.69,134.86 121.31,134.86 120.75,134.3 100.44,134.3 100.26,134.13 99.15,134.13 99,134.27 91.02,134.27 91.02,134.28 86.62,134.28 86.04,133.7 84.93,133.7 80.13,128.9 80.13,122.5 v7(80.01,122.38)
  IN4 w0.089: 89.58,47.86 90.49,46.96 91.25,46.96 92.23,45.98 95.78,45.98 96.92,44.84 99.39,44.84 100.53,43.7 101.17,43.7 101.86,43 102.61,43 103.09,43.49 103.81,43.49 104.24,43.06 104.24,41.64 105.12,40.77 107.98,40.77 108.41,40.34 108.41,37.49 108.77,37.12 111.24,37.12 111.65,36.72 111.65,35.39 111.7,35.33 111.7,33.75 112.66,32.78 112.66,30.75 113.15,30.26 113.28,30.13 114.34,30.13 115.44,29.03 115.44,28.35 115.14,28.04 v5(115.14,27.89)
  BOTTOM w0.081: v7(80.01,122.38) v2(79.01,122.38) 78,122.38 77.47,121.85 77.47,117.87 82.37,112.97 82.37,111.46 87.15,106.67 87.15,99.11 86.72,98.67 86.72,98.22 86.72,72.24 v7(86.36,71.88)
EC_RST: length 6
  TOP w0.076: UE5.K13 v8(81.83,17.67)
  TOP w0.081: RG1612.2 84.32,19.78 v8(84.53,19.99) 84.53,20.31 84.16,20.68 CE195.2
  IN1 w0.058: v8(84.53,19.99) 84.49,19.99 82.94,18.44
  IN1 w0.076: 82.94,18.44 82.85,18.35 82.85,18.04 82.49,17.67 v8(81.83,17.67)
EC_RTCRST: length 3.8
  BOTTOM w0.076: 84.2,16.03 84.08,16.03 QE5.2
  BOTTOM w0.081: 84.2,16.03 84.26,16.03 84.74,16.51 RE650.1 84.86,16.13 85.09,15.9 85.09,15.84 85.8,15.12 UE10.14
EC_SCI#: length 36.2
  TOP w0.081: v5(85.09,15.27) 84.75,15.27 RE694.1
  TOP w0.122: UH1.AU26 105.38,30.21 105.89,29.71 106.18,29.71 v5(106.3,29.59)
  IN3 w0.058: 103.54,22.69 103.02,22.17 102.37,22.17 99.11,18.91 96.11,18.91 95.61,18.41 94.07,18.41 93.49,17.83 93.49,17.83 92.79,17.13 92.79,16.73 92.79,16.62 91.44,15.27 v5(85.09,15.27)
  IN3 w0.089: v5(106.3,29.59) 106.15,29.59 105.6,29.04 105.6,25.87 105.86,25.62 105.86,24.4 105.34,23.88 105.21,23.88 104.28,22.95 103.8,22.95 103.54,22.69
  BOTTOM w0.089: RH521.2 105.32,26.73 105.32,29.13 v2(105.58,29.4) 105.77,29.59 v5(106.3,29.59)
EC_SMB_CK1: length 265.2
  TOP w0.076: 76.73,14.82 77.12,14.82 UE5.A8
  TOP w0.081: v5(76.97,37.24) 77.16,37.05 80.23,37.05 82.2,39.03 82.2,43.31 80.84,44.67 80.84,52.22 78.94,54.13 78.94,54.3 78.94,67.47 79.65,68.19 79.65,73.04 82.65,76.03 82.65,100.03 76.3,106.38 76.3,112.78 71.91,117.17 71.91,121.36 72.62,122.07 74.98,122.07 75.01,122.05 v3(75.18,122.05) ; 76.73,14.82 73.73,14.82 v6(73.47,15.08) 73.35,14.96 72.88,14.96 RE90.4 ; PR19.2 30.86,2.77 30.77,2.86 30.38,2.86 PD2.2 29.99,2.75 29.93,2.81 29.54,2.81 29.25,3.09 29.25,3.73 29.95,4.43 29.95,4.8 v5(29.77,4.99)
  IN2 w0.058: v5(29.77,4.99) 29.97,5.19 29.97,5.67 33.04,8.74 41.62,8.74 43.1,10.22 47.85,10.22 49.14,11.51 49.14,15.98 50.31,17.15 50.31,17.23 v4(50.18,17.36) ; v3(61.81,31.1) 61.83,31.38 61.77,31.44 61.69,31.44 61.32,31.44 61.16,31.61 61.16,32.97 59.45,34.67 59.45,34.83 59.45,36.66 59.45,36.96 59.99,37.5 60.3,37.5 66.78,37.5 67.92,36.36 72.3,36.36 72.86,36.92 76.65,36.92 v5(76.97,37.24)
  IN3 w0.058: v3(96.46,140.53) 96.23,140.75 96.23,140.86 95.4,141.7 93.97,141.7 92.77,142.89 92.77,143.6 90.05,146.33 88,146.33 87.13,147.2 85.24,147.2 84.58,147.86 82.61,147.86 78.92,144.17 76.24,144.17 71.09,139.02 71.09,134.16 74.9,130.34 74.9,122.34 v3(75.18,122.05)
  GND4 w0.081: v4(61.43,31.1) v3(61.81,31.1)
  IN4 w0.058: v4(61.43,31.1) 61.43,31.38 61.37,31.43 61.16,31.43 61.06,31.33 61.06,29.59 58.9,27.43 54.29,27.43 52.92,26.06 52.92,25.55 51.89,24.53 51.89,22.7 50.48,21.29 50.48,17.66 v4(50.18,17.36) ; v5(76.97,37.24) 76.74,37.01 76.49,37.01 76.32,36.84 76.32,36.07 76.49,35.91 77.46,35.91 79.44,33.92 79.44,24.91 79.76,24.58 79.76,21.85 76.45,18.54 76.44,18.54 76.43,18.52 76.43,18.51 75.95,18.03 75.95,15.31 75.52,14.88 73.67,14.88 v6(73.47,15.08)
EC_SMB_CK2: length 236.2
  TOP w0.076: UE5.B8 77.95,14.58 77.95,14.56 v8(77.99,14.56)
  TOP w0.081: v8(106.94,11.99) 106.86,12.08 106.86,12.85 107.22,13.22 107.22,13.22 108.29,14.28 109.14,14.28 109.73,14.87 109.73,16.48 109.08,17.13 107.94,17.13 QH5.1
  IN1 w0.058: 76.58,14.14 76.15,14.14 75.45,13.44 74.52,13.44 74.09,13.87 72.97,13.87 v3(72.84,14) 72.64,13.8 72.56,13.8 72.27,13.51 72.27,11.7 69.22,8.65 69.22,7.13 69.16,7.08 68.83,7.08 68.77,7.15 68.77,7.33 68.86,7.42 v4(68.95,7.42) 68.77,7.6 68.77,7.86 68.6,8.03 68.06,8.03 67.89,7.86 67.89,6.98 68.69,6.19 69.76,6.19 71.62,8.05 75.6,8.05 76.28,7.37 77.55,7.37 77.75,7.17 78.36,7.17 78.83,7.64 79.09,7.64 79.6,7.13 81.57,7.13 81.9,6.8 82.65,6.8 83.08,6.38 85.72,6.38 86.26,6.92 87.05,6.92 91.06,10.92 97.89,10.92 98.63,11.66 102.02,11.66 102.53,11.15 106.45,11.15 106.84,11.54 106.84,11.89 v8(106.94,11.99) ; v5(78.74,68.53) 78.61,68.53 74.2,64.12 61.55,64.12 61.21,64.47 61.19,64.47 61.13,64.53 v8(61.13,64.57)
  IN1 w0.076: v8(77.99,14.56) 77.95,14.56 77.95,14.56 77.85,14.66 77.46,14.66 76.94,14.14 76.58,14.14
  GND2 w0.081: v1(67.85,134.79) 67.7,134.64 67.7,134.53 v3(67.86,134.36)
  IN3 w0.058: v5(78.74,68.53) 78.14,67.93 78.14,60.47 77.68,60.01 77.68,54.3 77.68,53.54 78.37,52.85 78.37,43.68 78.64,43.42 78.64,37.61 82.34,33.91 82.34,31.14 83.01,30.47 83.01,25.9 79.7,22.59 74.62,22.59 74.16,22.13 74.16,21.51 72.32,19.67 72.32,16.71 72.9,16.13 72.9,14.06 72.84,14 v3(72.84,14)
  GND4 w0.081: v6(67.79,133.91) 67.7,134 67.7,134.2 v3(67.86,134.36)
  IN4 w0.058: v5(78.74,68.53) 78.95,68.32 79.19,68.32 79.25,68.38 79.25,68.98 79.04,69.18 78.08,69.18 75.76,71.5 75.21,72.06 74.53,72.06 72.84,73.75 72.84,79.64 70.76,81.72 70.76,82.76 70.23,83.29 69.78,83.29 v7(69.6,83.47) 70.64,84.5 70.64,86.94 70.43,87.14 70.43,87.91 71.72,89.2 71.72,99.5 74.99,102.77 74.99,112 68.03,118.96 68.03,122.12 67.6,122.54 67.6,125.68 66.96,126.32 66.96,134.15 67.2,134.39 67.51,134.39 67.69,134.22 67.69,134.01 v6(67.79,133.91)
  BOTTOM w0.081: QG6.3 69.6,84.55 v7(69.6,83.47)
EC_SMB_DA1: length 265.1
  TOP w0.076: UE5.A7 76.91,14.62 76.58,14.62
  TOP w0.081: v5(30.35,4.99) 30.16,4.8 30.16,4.34 29.46,3.64 29.46,3.18 29.63,3.02 29.9,3.02 29.98,3.1 29.98,3.46 PD2.3 30.38,3.07 30.78,3.07 30.86,3.14 PR21.2 ; RE90.3 72.84,14.51 v6(73.47,14.51) 73.58,14.62 76.58,14.62 ; v5(76.97,36.66) 77.16,36.85 80.32,36.85 82.41,38.94 82.41,43.4 81.05,44.76 81.05,52.31 79.15,54.22 79.15,67.39 79.86,68.1 79.86,72.96 82.85,75.95 82.85,100.12 76.51,106.46 76.51,112.86 72.12,117.26 72.12,121.28 72.7,121.87 74.6,121.87 75.03,121.44 v3(75.18,121.44)
  IN2 w0.058: v4(50.18,18.19) 50.55,17.82 50.55,17.13 49.33,15.9 49.33,11.43 47.93,10.03 43.18,10.03 41.7,8.55 33.12,8.55 30.15,5.59 30.15,5.19 v5(30.35,4.99) ; v5(76.97,36.66) 76.81,36.82 76.73,36.74 72.94,36.74 72.37,36.17 67.84,36.17 66.7,37.32 60.07,37.32 59.64,36.88 59.64,34.75 61.34,33.05 61.34,31.68 61.4,31.62 61.69,31.62 61.78,31.62 61.84,31.68 v3(61.85,31.95)
  IN3 w0.058: v3(75.18,121.44) 75.64,121.9 75.64,122.35 75.08,122.91 75.08,130.42 71.27,134.23 71.27,138.94 76.32,143.99 78.99,143.99 82.69,147.68 84.51,147.68 85.17,147.02 87.05,147.02 87.93,146.14 89.97,146.14 92.59,143.52 92.59,142.81 93.89,141.51 95.32,141.51 96.05,140.78 96.05,140.75 95.83,140.54 v3(95.81,140.54)
  GND4 w0.081: v4(61.42,31.95) v3(61.85,31.95)
  IN4 w0.058: 76.58,18.39 76.51,18.31 76.48,18.31 76.13,17.96 76.13,15.23 75.6,14.7 73.66,14.7 v6(73.47,14.51) ; 76.63,18.44 76.63,18.46 79.95,21.77 79.95,24.66 79.62,24.98 79.62,34 77.53,36.09 76.56,36.09 76.5,36.15 76.5,36.77 76.56,36.82 76.74,36.82 76.75,36.82 76.81,36.82 v5(76.97,36.66) ; v4(50.18,18.19) 50.29,18.3 50.29,21.36 51.71,22.78 51.71,24.6 52.74,25.63 52.74,26.14 54.22,27.62 58.83,27.62 60.88,29.67 60.88,31.41 61.09,31.62 61.36,31.62 61.42,31.68 v4(61.42,31.95)
  IN4 w0.076: 76.58,18.39 76.63,18.44
EC_SMB_DA2: length 235.5
  TOP w0.081: v8(106.56,11.99) 106.65,12.08 106.65,12.94 v13(106.91,13.2) 108.2,14.49 109.05,14.49 109.52,14.96 109.52,16.39 108.99,16.92 107.95,16.92 107.29,16.26 106.96,16.26 QH5.4
  IN1 w0.058: v5(78.79,67.92) 78.57,68.14 78.49,68.14 74.28,63.93 61.48,63.93 61.13,64.28 61.02,64.28 60.85,64.45 60.85,64.46 60.69,64.46 60.63,64.51 v8(60.63,64.57) ; v8(106.56,11.99) 106.65,11.9 106.65,11.62 106.37,11.34 102.61,11.34 102.1,11.85 98.55,11.85 97.81,11.11 90.98,11.11 86.97,7.1 86.18,7.1 85.64,6.56 83.15,6.56 82.73,6.99 81.98,6.99 81.65,7.32 79.68,7.32 79.17,7.83 78.76,7.83 78.28,7.35 77.83,7.35 77.62,7.55 76.36,7.55 75.68,8.23 71.54,8.23 69.68,6.37 68.76,6.37 68.08,7.06 68.08,7.79 68.14,7.84 68.53,7.84 68.59,7.78 68.59,7.55 v11(68.45,7.42) 68.58,7.29 68.58,7.07 68.76,6.89 69.24,6.89 69.41,7.06 69.41,8.57 72.45,11.62 72.45,13.43 72.64,13.62 72.72,13.62 v1(72.84,13.5) 73.02,13.69 74.01,13.69 74.45,13.25 75.53,13.25 76.15,13.87 76.56,13.87 76.57,13.86 76.58,13.86
  IN1 w0.076: 76.58,13.86 v8(77.16,13.86)
  GND2 w0.081: v3(67.33,134.36) 67.49,134.53 67.49,134.64 v1(67.35,134.79) ; v3(68.45,7.06) v11(68.45,7.42) ; v1(72.84,13.5) v3(72.84,13.16)
  IN3 w0.058: v5(78.79,67.92) 78.39,67.92 78.33,67.86 78.33,60.39 77.87,59.93 77.87,54.22 77.87,53.61 78.55,52.93 78.55,43.76 78.82,43.49 78.82,37.69 82.52,33.98 82.52,31.22 83.19,30.55 83.19,25.82 79.78,22.41 74.7,22.41 74.35,22.05 74.35,21.43 72.5,19.59 72.5,16.79 73.09,16.2 73.09,14.32 73.33,14.07 73.33,13.65 v3(72.84,13.16)
  GND4 w0.081: v4(68.45,7.42) v3(68.45,7.06) ; v6(67.41,133.91) 67.49,134 67.49,134.2 v3(67.33,134.36)
  IN4 w0.058: v6(67.41,133.91) 67.5,134.01 67.5,134.14 67.44,134.2 67.28,134.2 67.15,134.07 67.15,126.4 67.79,125.76 67.79,122.62 68.21,122.19 68.21,119.04 75.18,112.07 75.18,102.69 71.91,99.42 71.91,89.12 70.62,87.83 70.62,87.22 70.94,86.9 v7(70.94,86.48) 70.94,84.54 70.31,83.91 70.31,83.77 v7(70.6,83.47) 70.95,83.12 70.95,81.8 73.03,79.72 73.03,73.82 74.6,72.24 75.28,72.24 78.16,69.37 79.12,69.37 79.44,69.05 79.44,68.3 79.27,68.13 79,68.13 v5(78.79,67.92)
EC_SRTCRST: length 4.5
  BOTTOM w0.081: UE10.20 87.53,18.75 v2(87.3,18.98) 86.93,19.34 86.93,19.81 RE693.1 86.72,19.86 86.49,20.09 85.47,20.09 85.22,19.84 QE66.5
EC_SSD: length 68.5
  IN1 w0.058: v8(134.9,10.92) 134.39,11.43 120.14,11.43 119.84,11.74 110.92,11.74 110.59,11.41 v8(110.11,11.41) 108.2,11.41 107.11,12.5 106.35,12.5 105.92,12.07 103.79,12.07 103.51,12.35 98.38,12.35 97.61,11.59 90.8,11.59 86.82,7.61 86.04,7.61 85.47,7.03 83.77,7.03 83.51,7.03 83.11,7.43 82.17,7.43 81.77,7.83 81.12,7.83 80.78,8.17 80.39,8.17 80.19,8.37 80.19,8.94 79.68,9.45 76.86,9.45 76.66,9.65 76.66,10.57
  IN1 w0.076: v8(78.67,13.36) 78.56,13.46 77.9,13.46 77.55,13.11 77.06,13.11 76.66,12.71 76.66,10.57
EC_TX: length 63.2
  TOP w0.081: RV686.1 86,10.11 85.44,10.67 v8(85.04,10.67)
  IN1 w0.058: v8(135.87,16.66) 135.61,16.66 134.82,15.87 125.5,15.87 125.08,15.45 114.84,15.45 114.72,15.33 107.98,15.33 107.96,15.35 106.4,15.35 105.81,14.76 104.84,14.76 104.19,15.41 102.47,15.41 101.96,15.92 91.62,15.92 88.54,12.83 88.2,12.83 86.99,11.62 86.24,11.62 85.29,10.67 v8(85.04,10.67) 85.01,10.65 84.2,10.65
  IN1 w0.076: v8(81.67,15.86) 81.91,15.62 81.91,14.76 82.56,14.11 82.82,14.11 82.91,14.01 82.91,12.19 83.23,11.88 83.23,11.45 84.04,10.65 84.2,10.65
ECAGND: length 110.8
  TOP w0.076: 76.64,18.44 77.42,17.67 77.42,17.26 77.56,17.11 77.78,17.11 77.91,16.98 77.91,16.22 77.81,16.12 77.41,16.12 v1(77.16,16.36)
  TOP w0.081: CE172.2 75.2,18.67 LE5.2 76.5,19.01 CE190.1 76.57,18.52 76.64,18.44
  GND2 w0.076: v1(77.16,16.36) v12(77.4,16.6)
  IN2 w0.058: v4(86.06,54.41) 83.61,51.96 83.61,45 85.88,42.73 85.88,31.41 85.45,30.98 85.45,25.02 83.86,23.43 80.83,23.43 78.23,20.83 78.23,18.89 77.46,18.11 77.46,16.66 v12(77.4,16.6)
  BOTTOM w0.081: v4(86.06,54.41) 86.06,66.6 86.25,66.79 92.42,66.79 92.63,67 92.63,67.52 92.42,67.73 92.2,67.73 89.51,70.43 89.51,89.13 v2(90.88,90.5) 92.15,90.5 95.47,93.82 99.76,93.82 100.14,94.2 102.23,94.2 102.34,94.1 PH01.2
EDICLK: length 5.5
  TOP w0.076: v5(78.28,16.38) 78.27,16.38 78.27,16.4 78.14,16.53 78.14,16.84 UE5.C12
  BOTTOM w0.076: v5(78.28,16.38) 78.27,16.38 78.27,16.4 77.8,16.87 v2(77.8,17.05) 77.8,17.38 78.74,18.32 78.74,18.44
  BOTTOM w0.081: 80.39,20.03 80.33,20.03 78.74,18.44
EDICS: length 2.5
  TOP w0.076: UE5.D13 v4(78.67,17.71)
  BOTTOM w0.076: 80.01,18.44 79.6,18.44 v2(79.32,18.16) 78.87,17.71 v4(78.67,17.71)
  BOTTOM w0.081: 80.39,18.82 80.01,18.44
EDIDI: length 2.6
  BOTTOM w0.076: 80.39,16.41 79.12,16.41 v2(79.1,16.43) v4(78.16,17.37)
EDIDO: length 1.7
  IN1 w0.076: v8(79.17,15.86) 79.17,15.77 79.4,15.53 v4(79.4,15.32)
  BOTTOM w0.076: v4(79.4,15.32) 80.28,15.32 80.39,15.2
EDP_AUXN_C: length 17
  TOP w0.089: v5(49.18,152.65) 49.37,152.46 49.37,151.75 50.77,150.35 54.83,150.35 55.6,149.57 55.6,147.59 56.34,146.86 56.34,146.84 56.72,146.46 56.74,146.46 58.65,144.55 59.31,144.55 59.4,144.46 59.4,144.43 CV13.1
  BOTTOM w0.089: JEDP.14 49.25,151.87 49.36,151.99 49.36,152.47 v5(49.18,152.65)
EDP_AUXN_PCH: length 70.3
  TOP w0.081: UC1.B26 96.96,103.28 97.03,103.35 97.03,103.51 96.95,103.59 95.69,103.59 94.35,102.25 89.94,102.25 89.94,102.25 89.92,102.25
  TOP w0.089: 89.92,102.25 84.99,102.25 80.9,106.34 80.9,113.44 77.05,117.29 77.05,120.45 77.04,120.46 77.04,121 77.05,121.01 77.05,121.69 76.15,122.6 67.33,122.6 60.96,128.96 v13(60.96,136.98) 60.96,138.27 59.42,139.81 59.42,143.39 CV13.2
EDP_AUXP_C: length 17
  TOP w0.089: CV12.1 59.6,144.43 59.6,144.54 59.39,144.75 58.73,144.75 v13(56.68,146.8) 55.81,147.68 55.81,149.66 54.91,150.55 50.86,150.55 49.58,151.83 49.58,152.46 v5(49.77,152.65)
  BOTTOM w0.089: v5(49.77,152.65) 49.57,152.45 49.57,151.95 49.75,151.77 JEDP.13
EDP_AUXP_PCH: length 70.3
  TOP w0.081: 89.92,102.45 89.94,102.45 89.94,102.45 94.27,102.45 95.6,103.78 97.03,103.78 97.22,103.59 97.22,103.36 97.3,103.28 UC1.C26
  TOP w0.089: 89.92,102.45 85.07,102.45 81.1,106.42 81.1,113.52 77.25,117.37 v13(77.25,120.73) 77.25,121.78 76.23,122.8 67.41,122.8 61.16,129.05 61.16,136.7 61.18,136.71 61.18,137.25 61.16,137.27 61.16,138.36 59.63,139.89 59.63,143.44 CV12.2
EDP_HPD_CPU: length 158.2
  TOP w0.122: UH1.AN6 95.81,32.58 v5(95.96,32.42)
  IN3 w0.058: v5(46.22,152.24) 46.22,150.63 47.42,149.43 47.42,148.84 48.8,147.46 58.43,147.46 62.89,143 64.33,143 66.96,140.37 66.96,126.53 v9(67.21,126.28)
  GND4 w0.081: v9(67.21,126.28) 66.76,125.83 v6(66.76,125.47)
  IN4 w0.058: 90.32,33.85 86.9,37.27 86.32,37.27 78.63,44.96 78.63,49.6 78.97,49.94 78.97,54.42 77.61,55.77 77.61,63.14 76.55,64.21 76.55,66.24 70.1,72.69 70.1,74.98 70.02,75.07 69.27,75.82 69.27,76.87 69.83,77.43 69.83,78.71 68.15,80.4 68.15,80.53 68.15,80.53 68.15,81.82 67.49,82.47 67.49,84.4 67.03,84.86 67.03,88.54 67.21,88.72 67.21,91.64 66.87,91.97 66.87,96.67 63.83,99.72 63.83,109.9 65.37,111.45 65.37,114.69 67.39,116.7 67.39,121.86 66.76,122.48 v6(66.76,125.47)
  IN4 w0.089: v5(95.96,32.42) 95.83,32.56 91.62,32.56 90.32,33.85
  BOTTOM w0.081: v5(46.22,152.24) 46.25,152.21 JEDP.20
  BOTTOM w0.089: v2(94.18,30.61) 94.79,31.21 RH9.1
  BOTTOM w0.122: v5(95.96,32.42) 95.91,32.48 95.65,32.48 RH9.1
EDP_LCD_TEST: length 49.7
  TOP w0.081: RD254.2 v6(36.58,147.22) ; RV682.2 23.3,134.66 v8(24.14,134.66)
  IN1 w0.058: v8(24.14,134.66) 24.14,135.17 23.77,135.54 23.77,138.84 31.84,146.91 31.84,151.46 34.4,154.01 43.63,154.01 44.72,152.92 v5(44.72,152.58)
  IN4 w0.058: v5(44.72,152.58) 44.72,150.8 42.49,148.57 40.61,148.57 39.42,147.37 36.73,147.37 v6(36.58,147.22)
  BOTTOM w0.081: v5(44.72,152.58) 44.72,152.06 44.75,152.04 JEDP.23
EDP_PWM: length 36.5
  IN1 w0.058: v5(45.22,152.24) 45.22,152.64 43.69,154.17 34.33,154.17 31.68,151.52 31.68,146.98 23.43,138.73 23.43,135.36 v8(23.67,135.12)
  BOTTOM w0.081: v5(45.22,152.24) 45.25,152.21 JEDP.22
EDP_RCOMP: length 6.8
  TOP w0.152: UC1.D37 98.17,110.78 97.89,111.05 97.89,111.63 97.75,111.77 97.24,111.77 96.81,112.2
  TOP w0.381: RC30.1 96.42,112.59 96.81,112.2
EDP_TXN0_C: length 16.6
  TOP w0.089: v5(56.59,153.43) 57.29,153.43 58.22,152.5 58.22,148.74 59.48,147.48 61.35,147.48 61.84,146.99 61.86,146.99 62.24,146.61 62.24,146.59 v13(63,145.82) 63.37,145.45 CV2.1
  BOTTOM w0.089: JEDP.2 55.25,152.69 55.99,153.43 v5(56.59,153.43)
EDP_TXN0_PCH: length 66.7
  TOP w0.081: 89.92,105.39 89.94,105.39 89.94,105.38 91.68,105.38 92.64,106.35 96.52,106.35 96.72,106.14 98.35,106.14 98.79,105.71 UC1.E29
  TOP w0.089: 89.92,105.39 85.64,105.39 84.1,106.92 84.1,106.93 83.59,107.44 83.59,112.57 83.6,112.58 83.6,113.12 83.59,113.14 83.59,115.09 v13(81.64,117.05) 79.78,118.91 79.78,122.8 77.18,125.39 68.39,125.39 63.7,130.07 63.7,139.86 63.16,140.41 63.16,142.56 63.37,142.78 CV2.2
EDP_TXN1_C: length 14.7
  TOP w0.089: CV4.1 61.18,144.43 61.18,144.58 59.86,145.9 59.08,145.9 58.08,146.9 58.06,146.9 57.68,147.28 57.68,147.3 56.81,148.17 56.81,150.1 55.3,151.62 54.23,151.62 53.87,151.97 53.87,152.66 v5(53.64,152.89)
  BOTTOM w0.089: v5(53.64,152.89) 53.87,152.66 53.87,151.91 53.75,151.79 JEDP.5
EDP_TXN1_PCH: length 69.7
  TOP w0.081: UC1.E28 98.84,104.91 98.84,105.08 98.76,105.16 94.78,105.16 93.48,103.86 89.92,103.86
  TOP w0.089: 89.92,103.86 85.15,103.86 82.14,106.87 82.14,114.52 79.25,117.41 79.24,117.41 78.85,117.8 78.85,117.81 78.35,118.32 78.35,122.2 76.6,123.95 v13(69.89,123.95) 67.8,123.95 62.26,129.5 62.26,138.81 61.18,139.89 61.18,142.77 61.39,142.99 61.39,143.2 CV4.2
EDP_TXN2_C: length 19.6
  TOP w0.089: v5(52.18,152.65) 52.18,153.24 52.79,153.85 54.24,153.85 57.62,150.47 57.62,148.49 59.39,146.72 v13(59.65,146.72) 60.19,146.72 61.34,145.57 61.36,145.57 61.74,145.19 61.74,145.17 62.27,144.64 62.27,143.37 62.48,143.16 CV6.1
  BOTTOM w0.089: JEDP.8 52.25,152.58 v5(52.18,152.65)
EDP_TXN2_PCH: length 63.8
  TOP w0.081: UC1.B29 96.7,105.64 96.39,105.95 93.77,105.95 92.57,104.74 89.94,104.74 89.94,104.75 89.92,104.75
  TOP w0.089: CV6.2 62.48,139.91 62.56,139.84 62.57,139.84 62.95,139.46 62.95,139.44 63.08,139.32 63.08,129.84 68.13,124.79 v13(74.69,124.79) 76.92,124.79 79.17,122.55 79.17,118.63 82.96,114.84 82.96,107.22 85.43,104.75 89.92,104.75
EDP_TXN3_C: length 19.6
  TOP w0.089: CV11.1 60.71,143.26 60.49,143.47 60.49,144.62 59.75,145.36 59.04,145.36 56.41,147.99 56.41,149.92 55.13,151.21 52.6,151.21 51.77,152.05 51.77,153.05 51.56,153.25 51.33,153.25 v5(51.16,153.43)
  BOTTOM w0.089: JEDP.11 50.75,152.41 50.47,152.69 50.47,153.03 50.72,153.27 51,153.27 v5(51.16,153.43)
EDP_TXN3_PCH: length 67.6
  TOP w0.081: UC1.B28 96.95,104.96 97.06,104.96 97.21,104.82 97.21,104.67 97.08,104.54 94.93,104.54 93.55,103.17 90.91,103.14 90.9,103.15 89.93,103.15 89.92,103.14
  TOP w0.089: CV11.2 60.27,141.42 60.27,140.21 61.81,138.67 61.81,129.31 67.68,123.45 v13(72.73,123.45) 76.47,123.45 77.9,122.02 77.9,117.69 80.6,115 80.61,115 80.99,114.61 80.99,114.6 81.74,113.85 81.74,106.64 85.24,103.14 89.92,103.14
EDP_TXP0_C: length 16.5
  TOP w0.089: v5(56.59,152.85) 56.97,153.23 57.21,153.23 58.01,152.42 58.01,148.66 59.39,147.28 61.26,147.28 v13(61.89,146.64) 62.66,145.88 62.66,145.86 63.04,145.48 63.06,145.48 63.17,145.37 63.17,144.64 CV1.1
  BOTTOM w0.089: v5(56.59,152.85) 56.21,153.23 56.08,153.23 55.45,152.6 55.45,152.07 55.75,151.77 JEDP.1
EDP_TXP0_PCH: length 66.7
  TOP w0.081: UC1.D29 98.24,105.74 98.24,105.86 98.15,105.95 96.64,105.95 96.43,106.15 92.73,106.15 91.76,105.19 89.94,105.19 89.94,105.18 89.92,105.18
  TOP w0.089: 89.92,105.18 85.56,105.18 83.96,106.78 83.96,106.78 83.39,107.36 v13(83.39,112.85) 83.39,115.01 81.69,116.7 81.67,116.7 81.29,117.08 81.29,117.1 79.57,118.82 79.57,122.71 77.1,125.19 68.3,125.19 63.5,129.99 63.5,139.78 62.95,140.32 62.95,142.64 63.17,142.86 63.17,143.2 CV1.2
EDP_TXP1_C: length 14.6
  TOP w0.089: CV3.1 61.38,144.43 61.38,144.67 59.94,146.1 59.16,146.1 v13(58.02,147.25) 57.01,148.26 57.01,150.19 55.38,151.82 54.31,151.82 54.08,152.06 54.08,152.74 v5(54.23,152.89)
  BOTTOM w0.089: JEDP.4 54.25,151.8 54.08,151.98 54.08,152.74 v5(54.23,152.89)
EDP_TXP1_PCH: length 69.7
  TOP w0.081: 89.92,104.06 89.93,104.06 89.94,104.05 90,104.05 90,104.05 93.4,104.05 94.7,105.36 98.89,105.36 99.39,104.85 UC1.F28
  TOP w0.089: CV3.2 61.59,142.9 61.38,142.69 61.38,139.98 62.46,138.9 62.46,129.58 67.88,124.16 69.61,124.16 69.62,124.17 70.16,124.17 70.17,124.16 76.68,124.16 78.55,122.29 78.55,118.41 v13(79.2,117.76) 82.35,114.61 82.35,106.95 85.24,104.06 89.92,104.06
EDP_TXP2_C: length 19.6
  TOP w0.089: CV8.1 61.87,142.43 62.28,142.84 62.28,143.07 62.06,143.29 62.06,144.56 v13(61.4,145.22) 60.11,146.52 59.93,146.52 59.92,146.5 59.38,146.5 59.37,146.52 59.31,146.52 57.42,148.41 57.42,150.38 54.15,153.65 52.87,153.65 52.38,153.16 52.38,153.01 52.75,152.65 v5(52.77,152.65)
  BOTTOM w0.089: JEDP.7 52.75,151.91 52.66,151.99 52.53,151.99 52.45,152.07 52.45,152.36 52.75,152.65 v5(52.77,152.65)
EDP_TXP2_PCH: length 63.8
  TOP w0.081: UC1.A29 96.07,105.75 93.85,105.75 92.65,104.55 89.94,104.55 89.94,104.55 89.92,104.55
  TOP w0.089: CV8.2 61.85,141.57 61.91,141.51 62.19,141.51 62.28,141.42 62.28,139.83 v13(62.61,139.5) 62.88,139.23 62.88,129.76 68.04,124.59 74.41,124.59 74.42,124.58 74.96,124.58 74.97,124.59 76.84,124.59 78.97,122.46 78.97,118.54 82.75,114.76 82.75,107.13 85.34,104.55 89.92,104.55
EDP_TXP3_C: length 19.6
  TOP w0.089: CV7.1 60.07,142.71 60.13,142.78 60.41,142.78 60.5,142.86 60.5,143.17 60.29,143.39 60.29,144.53 59.68,145.14 v13(59.42,145.14) 58.97,145.14 58.48,145.64 58.46,145.64 58.08,146.02 58.08,146.04 56.21,147.9 56.21,149.84 55.04,151.01 52.52,151.01 51.56,151.96 51.56,152.96 51.47,153.05 51.36,153.05 v5(51.16,152.84)
  BOTTOM w0.089: JEDP.10 51.25,151.98 51.2,152.02 51.03,152.02 50.95,152.1 50.95,152.5 50.68,152.77 50.68,152.95 50.8,153.07 50.93,153.07 v5(51.16,152.84)
EDP_TXP3_PCH: length 67.7
  TOP w0.081: UC1.C28 97.4,104.77 97.4,104.58 97.16,104.35 95.01,104.35 93.63,102.97 90.07,102.94 89.94,102.94 89.92,102.94 89.92,102.93 89.92,102.93
  TOP w0.089: 89.92,102.93 85.16,102.93 81.53,106.56 81.53,113.77 v13(80.65,114.65) 77.7,117.6 77.7,121.94 76.39,123.24 73.02,123.24 73,123.23 72.46,123.23 72.45,123.24 67.59,123.24 61.61,129.23 61.61,138.59 60.07,140.13 CV7.2
ELC_BOOT_MODE: length 23.3
  TOP w0.122: v5(106.07,27.15) 106.23,26.99 UH1.BD29
  IN4 w0.058: v7(122.51,26.72) 122.51,26.7 120.62,24.82 117.83,24.82 117.27,24.26 117.24,24.26
  IN4 w0.089: 117.24,24.26 113.97,24.26 113.26,23.55 111.05,23.55 110.11,24.49 107.82,24.49 107.42,24.89 107.42,26.37 106.63,27.15 v5(106.07,27.15)
  BOTTOM w0.081: v7(122.51,26.72) 122.53,26.75 RE5.1 123.32,26.51 122.94,26.13 UE1.44
ELC_EC#: length 17.9
  BOTTOM w0.081: QE22.5 99.3,18.33 98.86,17.88 98.86,15.58 QE21.5 99.23,14.84 98.62,14.23 98.62,13.86 ; 98.62,13.86 96.87,13.86 96.75,13.74 94.34,13.74 v2(94.31,13.77) 91.61,13.77 90.75,14.62 UE10.6 ; 98.62,13.86 98.62,11.84 99.12,11.35 QE13.5
ELC_RESET: length 36.7
  TOP w0.081: v6(108.22,19.9) 107.37,20.76 107.37,22.63 107.42,22.69 ; JELC2.10 127.63,20.6 v4(127.61,20.58) 127.39,20.36 127.39,17.6 RE4.2 CE8.1
  TOP w0.089: UH1.BD30 107.07,26.97 106.93,26.82 106.93,26.51 107.07,26.36 107.07,25.95 107.12,25.9 107.12,25.32 107.18,25.26 107.18,24.63 107.08,24.52 107.08,23.63 v2(107.32,23.39) 107.57,23.14 107.57,22.84 107.42,22.69
  IN4 w0.058: v6(108.22,19.9) 109.83,21.52 113.21,21.52 114.71,20.02 127.05,20.02 v4(127.61,20.58)
  BOTTOM w0.081: UE1.7 v4(127.61,20.58)
EN1_NVVDD: length 0.9
  GND2 w0.254: v1(23.47,43.05) 23.54,43.05 v3(23.77,42.81)
  GND4 w0.254: v3(23.77,42.81) 23.74,42.85 v4(23.33,42.85)
EN2_NVVDD: length 0.8
  GND2 w0.254: v1(31.03,43.05) 30.91,43.05 v3(30.71,43.25)
  GND4 w0.254: v3(30.71,43.25) 30.71,43.17 v4(30.96,42.92)
EN3_NVVDD: length 0.9
  GND2 w0.254: v3(38.25,42.79) 38.51,43.05 v1(38.58,43.05)
  GND4 w0.254: v4(38.62,42.98) 38.43,42.79 v3(38.25,42.79)
EN4_NVVDD: length 0.9
  GND2 w0.254: v3(46.2,42.58) 46.21,42.58 46.21,42.61 46.2,42.62 v1(46.2,43.05)
  GND4 w0.254: v4(46.25,42.9) 46.25,42.66 46.21,42.66 46.21,42.58 v3(46.2,42.58)
EN5_NVVDD: length 0.9
  GND2 w0.254: v3(53.54,42.79) 53.8,43.05 v1(53.89,43.05)
  GND4 w0.254: v3(53.54,42.79) 53.64,42.89 v4(53.95,42.89)
