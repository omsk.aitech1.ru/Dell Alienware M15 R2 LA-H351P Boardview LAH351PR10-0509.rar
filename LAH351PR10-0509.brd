# Allegro board LAH351PR10-0509.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RG102  121_0402_1%  [R_0402]  42.13 129.93 90 top
RG103  121_0402_1%  [R_0402]  8.94 119.47 0 top
RG104  121_0402_1%  [R_0402]  11.51 119.47 180 top
RG105  121_0402_1%  [R_0402]  9.45 85.26 180 top
RG106  121_0402_1%  [R_0402]  10.21 85.26 0 top
RG107  121_0402_1%  [R_0402]  40.51 77.66 0 top
RG108  121_0402_1%  [R_0402]  44.11 77.66 0 top
RG110  549_0402_1%  [R_0402]  59.63 123.04 270 top
RG111  931_0402_1%  [R_0402]  61.19 123.04 270 top
RG112  1K_0402_1%  [R_0402]  60.41 122.13 90 top
RG121  549_0402_1%  [R_0402]  5.32 119.12 270 bottom
RG122  931_0402_1%  [R_0402]  7.9 119.12 270 bottom
RG123  1K_0402_1%  [R_0402]  6.16 118.2 90 bottom
RG132  549_0402_1%  [R_0402]  6.58 84.43 270 bottom
RG133  931_0402_1%  [R_0402]  9.15 84.43 270 bottom
RG134  1K_0402_1%  [R_0402]  7.41 83.51 90 bottom
RG135  1K_0402_1%  [R_0402]  11.33 39.69 90 top
RG150  100K_0201_5%  [R_0201]  66.08 85.69 180 top
RG154  1K_0402_1%  [R_0402]  43.05 71.19 0 bottom
RG155  549_0402_1%  [R_0402]  43.97 72.02 180 bottom
RG156  931_0402_1%  [R_0402]  43.97 69.45 180 bottom
RG501  10K_0201_5%  [R_0201]  66.08 86.96 180 top
RG504  10K_0201_5%  [R_0201]  59.18 79.24 90 top
RG506  10K_0201_5%  [R_0201]  78.87 61.98 270 bottom
RG509  10K_0402_5%  [R_0402]  70.54 99.6 0 bottom
RG510  10_0402_1%  [R_0402]  68.82 95.79 0 bottom
RG511  10K_0402_5%  [R_0402]  7.61 2.5 0 top
RG512  51_0402_5%  [R_0402]  7.62 7.22 270 top
RG513  10K_0402_5%  [R_0402]  3.39 15.56 180 top
RG514  10_0402_1%  [R_0402]  5.56 16.93 90 top
RG515  10K_0402_5%  [R_0402]  6.86 7.22 270 top
RG516  10K_0201_5%  [R_0201]  78.11 61.88 90 bottom
RG518  10K_0201_5%  [R_0201]  61.4 100.25 0 top
RG522  10K_0201_5%  [R_0201]  65.49 88.23 0 top
RG523  10K_0201_5%  [R_0201]  64.29 86.32 0 top
RG524  10K_0201_5%  [R_0201]  57.4 79.82 270 top
RG525  100K_0201_5%  [R_0201]  53.98 79.57 270 top
RG526  2.2K_0201_5%  [R_0201]  57.98 79.82 270 top
RG527  100K_0201_5%  [R_0201]  66.08 86.32 180 top
RG528  10K_0201_5%  [R_0201]  64.29 85.69 0 top
RG530  10K_0201_5%  [R_0201]  116.29 140.17 0 top
RG533  100K_0201_5%  [R_0201]  81.47 55.87 90 bottom
RG534  10K_0201_1%  [R_0201]  76.03 58.51 0 bottom
RG537  0_0201_5%  [R_0201]  93.08 19.27 180 top
RG540  0_0201_5%  [R_0201]  116.29 140.74 0 top
RG543  10K_0402_5%  [R_0402]  67.06 86.44 90 top
RG544  10K_0402_5%  [R_0402]  70.87 86.44 90 top
RG545  2.2K_0201_1%  [R_0201]  9.5 14.06 180 top
RG549  100K_0402_5%  [R_0402]  75.25 55.96 90 bottom
RG553  0_0201_5%  [R_0201]  75.12 63.57 270 bottom
RG554  0_0201_5%  [R_0201]  79.5 61.98 270 bottom
RG557  10K_0402_1%  [R_0402]  71.63 64.75 270 bottom
RG561  100K_0201_5%  [R_0201]  78.42 65.97 90 bottom
RG562  100K_0402_5%  [R_0402]  93.79 19.27 0 top
RG568  100K_0201_5%  [R_0201]  81.47 57.66 270 bottom
RG573  121_0402_1%  [R_0402]  47.89 124.33 270 top
RG574  121_0402_1%  [R_0402]  47.09 124.33 270 top
RG575  121_0402_1%  [R_0402]  10.82 121.56 180 top
RG576  121_0402_1%  [R_0402]  8.27 121.57 0 top
RG577  121_0402_1%  [R_0402]  17.7 90.1 90 top
RG578  121_0402_1%  [R_0402]  7.78 85.27 180 top
RG579  121_0402_1%  [R_0402]  37.82 77.66 180 top
RG580  121_0402_1%  [R_0402]  39.57 77.66 180 top
RG1410  60.4_0402_1%  [R_0402]  22.75 79.78 180 top
RG1411  60.4_0402_1%  [R_0402]  20.78 103.72 180 top
RG1412  60.4_0402_1%  [R_0402]  56.44 77.88 0 top
RG1413  60.4_0402_1%  [R_0402]  27.43 80.81 270 top
RG1446  60.4_0402_1%  [R_0402]  20.78 105.06 180 top
RG1451  60.4_0402_1%  [R_0402]  21.78 122.19 90 top
RG1476  60.4_0402_1%  [R_0402]  58.8 122.13 90 top
RG1478  60.4_0402_1%  [R_0402]  27.69 122.19 90 top
RG1479  10K_0402_1%  [R_0402]  38.24 124.29 180 top
RG1480  10K_0402_1%  [R_0402]  51.93 123.36 90 top
RG1481  10K_0402_1%  [R_0402]  59.69 127.61 270 top
RG1482  10K_0402_1%  [R_0402]  30.25 124.24 0 top
RG1483  10K_0402_1%  [R_0402]  17.72 112.88 270 top
RG1484  10K_0402_1%  [R_0402]  17.75 125.81 90 top
RG1485  10K_0402_1%  [R_0402]  17.7 106.89 90 top
RG1486  10K_0402_1%  [R_0402]  17.75 133.19 270 top
RG1487  10K_0402_1%  [R_0402]  17.76 81.26 270 top
RG1488  10K_0402_1%  [R_0402]  17.7 96 90 top
RG1489  10K_0402_1%  [R_0402]  17.78 74.88 270 top
RG1490  10K_0402_1%  [R_0402]  17.7 101.46 90 top
RG1491  10K_0402_1%  [R_0402]  48.3 77.66 0 top
RG1492  10K_0402_1%  [R_0402]  31.24 77.66 0 top
RG1493  10K_0402_1%  [R_0402]  55.7 77.88 180 top
RG1494  10K_0402_1%  [R_0402]  26.55 73.93 270 top
RG1495  2.2K_0201_1%  [R_0201]  85.6 27.68 90 top
RG1496  10K_0402_5%  [R_0402]  69.01 84.48 0 top
RG1497  100K_0402_5%  [R_0402]  60.64 79.67 270 top
RG1498  10K_0402_5%  [R_0402]  69.01 83.72 0 top
RG1499  1K_0402_1%  [R_0402]  61.77 95.85 0 top
RG1500  1K_0402_1%  [R_0402]  61.77 95.02 0 top
RG1501  100_0402_1%  [R_0402]  2.62 39.02 180 top
RG1502  1K_0402_1%  [R_0402]  61.77 94.2 0 top
RG1504  10K_0402_5%  [R_0402]  54.79 78.77 0 top
RG1505  10K_0201_5%  [R_0201]  65.89 89.18 180 top
RG1506  10K_0201_5%  [R_0201]  65.89 89.75 180 top
RG1507  10K_0201_5%  [R_0201]  63.67 85.05 180 top
RG1508  10K_0201_5%  [R_0201]  63.67 85.69 180 top
RG1509  10K_0201_5%  [R_0201]  65.89 90.32 180 top
RG1510  0_0402_5%  [R_0402]  70.85 90.45 0 bottom
RG1511  0_0402_5%  [R_0402]  76.15 91.66 180 bottom
RG1512  0_0402_5%  [R_0402]  5.47 8.49 180 top
RG1513  0_0402_5%  [R_0402]  71.64 62.96 180 bottom
RG1514  10K_0402_5%  [R_0402]  68.83 96.66 90 bottom
RG1516  100K_0402_5%  [R_0402]  70.54 95.79 0 bottom
RG1517  10K_0402_5%  [R_0402]  6.1 7.22 270 top
RG1518  10K_0402_5%  [R_0402]  73.34 89.13 270 bottom
RG1519  10K_0402_5%  [R_0402]  68.25 90.64 0 bottom
RG1520  0_0402_5%  [R_0402]  2.02 8.6 0 top
RG1521  0_0402_5%  [R_0402]  2.36 4.74 0 top
RG1522  10K_0201_5%  [R_0201]  100.97 19.87 90 top
RG1523  10K_0201_5%  [R_0201]  64.29 82.51 0 top
RG1524  10K_0201_5%  [R_0201]  63.67 82.51 180 top
RG1525  10K_0201_5%  [R_0201]  65.49 84.42 0 top
RG1526  10K_0201_5%  [R_0201]  63.67 83.78 180 top
RG1527  0_0201_5%  [R_0201]  65.49 82.51 0 top
RG1528  0_0201_5%  [R_0201]  65.49 83.78 0 top
RG1529  10K_0201_5%  [R_0201]  65.49 78.07 0 top
RG1530  10K_0201_5%  [R_0201]  63.67 78.7 180 top
RG1531  10K_0201_5%  [R_0201]  63.67 79.34 180 top
RG1532  10K_0201_5%  [R_0201]  65.49 81.24 0 top
RG1533  10K_0201_5%  [R_0201]  63.67 80.61 180 top
RG1534  10K_0201_5%  [R_0201]  65.49 79.97 0 top
RG1537  0_0402_5%  [R_0402]  6.35 39.39 90 top
RG1538  10K_0402_5%  [R_0402]  7.18 40.3 270 top
RG1539  0_0402_5%  [R_0402]  2.62 29.81 180 top
RG1540  75K_0402_1%  [R_0402]  1.7 29.05 0 top
RG1541  75K_0402_1%  [R_0402]  1.7 33.17 0 top
RG1542  649_0402_1%  [R_0402]  3.94 28.26 90 top
RG1543  649_0402_1%  [R_0402]  4.76 28.26 90 top
RG1544  10K_0402_5%  [R_0402]  5.31 7.74 270 top
RG1555  0_0402_5%  [R_0402]  66.87 89 270 bottom
RG1556  0_0402_5%  [R_0402]  68.83 99.29 270 bottom
RG1557  0_0402_5%  [R_0402]  65.41 91.65 90 bottom
RG1558  10K_0402_1%  [R_0402]  68.44 99.21 0 top
RG1559  2.21K_0402_1%  [R_0402]  70.74 98.72 270 top
RG1560  0_0402_5%  [R_0402]  10.73 32.62 270 top
RG1561  0_0402_5%  [R_0402]  10.73 29.96 90 top
RG1562  10K_0402_5%  [R_0402]  5.52 39.39 90 top
RG1563  287_0402_1%  [R_0402]  4.7 40.3 270 top
RG1564  287_0402_1%  [R_0402]  1.7 30.57 0 top
RG1565  10K_0402_5%  [R_0402]  10.48 39.4 90 top
RG1566  243K_0402_1%  [R_0402]  10.73 36.05 270 top
RG1567  10K_0402_5%  [R_0402]  12.55 38.93 180 top
RG1568  365K_0402_1%  [R_0402]  10.73 33.42 90 top
RG1569  681K_0402_1%  [R_0402]  11.62 34.33 270 top
RG1570  2K_0402_1%  [R_0402]  6.41 28.26 90 top
RG1571  2K_0402_1%  [R_0402]  7.24 28.26 90 top
RG1572  2K_0402_1%  [R_0402]  8.06 28.26 90 top
RG1573  2K_0402_1%  [R_0402]  8.89 28.26 90 top
RG1575  0_0402_5%  [R_0402]  5.59 29.17 270 top
RG1576  0_0402_5%  [R_0402]  1.73 34 0 top
RG1578  10K_0201_5%  [R_0201]  64.17 76.93 180 top
RG1579  10K_0402_1%  [R_0402]  63.42 76.23 0 top
RG1580  300K_0402_1%  [R_0402]  64.01 72.49 270 top
RG1581  10K_0201_5%  [R_0201]  60.07 76.76 90 top
RG1582  20K_0201_5%  [R_0201]  60.71 77.35 270 top
RG1583  10K_0402_1%  [R_0402]  59.8 76.04 0 top
RG1584  300K_0402_1%  [R_0402]  61.26 72.99 0 top
RG1585  0_0201_5%  [R_0201]  64.29 81.88 0 top
RG1586  0_0201_5%  [R_0201]  64.29 83.15 0 top
RG1587  0_0201_5%  [R_0201]  64.87 84.42 180 top
RG1588  0_0201_5%  [R_0201]  64.29 83.78 0 top
RG1589  0_0201_5%  [R_0201]  64.87 78.07 180 top
RG1590  0_0201_5%  [R_0201]  64.29 78.7 0 top
RG1591  0_0201_5%  [R_0201]  64.29 79.97 0 top
RG1592  0_0201_5%  [R_0201]  64.87 80.61 180 top
RG1593  0_0201_5%  [R_0201]  64.29 81.24 0 top
RG1594  0_0201_5%  [R_0201]  64.87 79.34 180 top
RG1595  0_0402_5%  [R_0402]  63.18 71.58 90 top
RG1596  0_0402_5%  [R_0402]  58.67 74.37 90 top
RG1600  100K_0402_1%  [R_0402]  6.9 23.19 270 top
RG1601  10K_0402_5%  [R_0402]  7.96 40.29 270 top
RG1602  0_0402_5%  [R_0402]  74.3 57.81 90 bottom
RG1604  10K_0402_5%  [R_0402]  74.24 63.22 90 top
RG1605  10_0402_1%  [R_0402]  72.16 61.6 180 top
RG1606  10K_0402_5%  [R_0402]  75.07 63.22 90 top
RG1607  3_0402_5%  [R_0402]  70.46 66.04 270 top
RG1608  0_0402_5%  [R_0402]  9.7 28.25 90 top
RG1609  0_0402_5%  [R_0402]  10.49 28.25 90 top
RG1610  0_0402_5%  [R_0402]  8.76 39.39 90 top
RG1611  0_0402_5%  [R_0402]  11.26 28.24 90 top
RG1612  300K_0402_1%  [R_0402]  82.92 19.78 0 top
RG1613  120K_0402_1%  [R_0402]  12.06 29.16 270 top
RG1615  10K_0201_5%  [R_0201]  83.29 44.67 180 bottom
RG1616  10K_0201_5%  [R_0201]  87.3 37.94 180 bottom
RH1  1.5K_0402_1%  [R_0402]  123.63 33.43 180 top
RH2  10K_0402_5%  [R_0402]  124.55 24.17 270 top
RH4  0_0402_5%  [R_0402]  113.03 19.26 90 top
RH5  1K_0402_5%  [R_0402]  88.92 28.26 0 top
RH6  0_0402_5%  [R_0402]  123.79 23.26 90 top
RH7  0_0402_5%  [R_0402]  124.08 22.38 0 top
RH9  100K_0402_5%  [R_0402]  94.79 31.61 180 bottom
RH11  10K_0402_5%  [R_0402]  115.18 24.67 0 bottom
RH12  0_0805_5%  [R_0805]  112.37 45.61 270 bottom
RH14  12.1_0402_1%  [R_0402]  93.89 35.56 270 bottom
RH15  30_0402_5%  [R_0402]  89.67 36.35 180 top
RH16  1K_0402_1%  [R_0402]  95.47 19.64 90 top
RH21  10K_0201_5%  [R_0201]  100.55 25.87 270 bottom
RH25  10K_0201_5%  [R_0201]  100.35 21.71 270 top
RH26  10K_0201_5%  [R_0201]  100.35 22.39 90 top
RH27  10K_0201_5%  [R_0201]  99.98 25.87 270 bottom
RH28  10K_0201_5%  [R_0201]  99.98 26.49 90 bottom
RH29  10K_0201_5%  [R_0201]  100.97 21.71 270 top
RH30  10K_0201_5%  [R_0201]  100.97 22.38 90 top
RH38  30_0402_5%  [R_0402]  88.63 32.03 0 top
RH39  30_0402_5%  [R_0402]  88.65 32.82 0 top
RH59  49.9_0402_1%  [R_0402]  139.31 101.95 0 top
RH63  150K_0402_1%  [R_0402]  108.89 21.96 180 top
RH70  10M_0402_5%  [R_0402]  116.88 30.03 180 bottom
RH71  2.7K_0402_1%  [R_0402]  90.58 39.45 90 top
RH72  1M_0402_5%~D  [R_0402]  88.95 49.32 270 bottom
RH73  12.1_0402_1%  [R_0402]  89.67 35.52 180 top
RH75  1K_0402_5%  [R_0402]  119.76 31.94 180 bottom
RH78  1K_0402_5%  [R_0402]  119.76 31.18 180 bottom
RH79  620_0402_5%  [R_0402]  90.28 37.2 180 top
RH83  20K_0402_5%~D  [R_0402]  119.32 27.66 270 bottom
RH84  20K_0402_5%~D  [R_0402]  120.14 27.66 270 bottom
RH85  8.2K_0402_5%  [R_0402]  106.85 26.54 270 bottom
RH88  10K_0402_5%  [R_0402]  110.55 17.48 90 top
RH89  22_0402_5%  [R_0402]  111 26.56 90 bottom
RH90  100K_0402_5%  [R_0402]  114.31 29.75 180 bottom
RH91  33_0201_5%  [R_0201]  89.68 49.28 270 bottom
RH92  33_0201_5%  [R_0201]  89.68 47.53 90 bottom
RH95  4.7K_0402_5%  [R_0402]  105.38 32.27 270 bottom
RH99  100K_0402_5%  [R_0402]  120.68 40.23 90 top
RH100  4.7K_0402_5%  [R_0402]  119.74 40.95 180 top
RH104  15_0402_1%  [R_0402]  124.76 18.62 180 top
RH109  113_0402_1%  [R_0402]  89.79 46.87 180 top
RH111  10K_0402_5%~D  [R_0402]  107.74 26.54 270 bottom
RH130  1K_0402_5%  [R_0402]  105.99 25.63 90 bottom
RH135  10K_0402_5%  [R_0402]  107.17 18.34 90 top
RH148  121_0402_1%  [R_0402]  96.29 81.58 0 top
RH149  121_0402_1%  [R_0402]  100.01 81.05 90 top
RH150  100_0402_1%  [R_0402]  100.9 81.05 90 top
RH151  100_0402_1%  [R_0402]  140.92 109.95 180 top
RH152  56.2_0402_1%  [R_0402]  140.92 110.9 180 top
RH153  220_0402_5%  [R_0402]  140.92 111.86 180 top
RH154  60.4_0402_1%  [R_0402]  97.03 91.71 90 bottom
RH155  20_0402_5%  [R_0402]  142.05 108.05 180 top
RH156  51_0402_5%  [R_0402]  140.22 105.5 180 top
RH158  499_0402_1%  [R_0402]  140.22 107.15 180 top
RH163  1K_0402_5%  [R_0402]  101.23 106.58 0 bottom
RH164  1K_0402_5%  [R_0402]  96.96 88.22 90 bottom
RH165  1K_0402_5%  [R_0402]  141.54 104.92 90 top
RH167  30_0402_5%  [R_0402]  90.37 33.62 180 top
RH168  10K_0402_5%  [R_0402]  88.82 21.92 270 top
RH181  20K_0402_1%  [R_0402]  88.95 25.81 0 top
RH182  20K_0402_1%  [R_0402]  88.95 26.63 0 top
RH184  1K_0402_5%  [R_0402]  139.31 101.06 0 top
RH185  1K_0402_5%  [R_0402]  139.3 96.62 0 top
RH186  1K_0402_5%  [R_0402]  134.4 96.98 0 bottom
RH187  1K_0402_5%  [R_0402]  139.3 97.57 0 top
RH188  1K_0402_5%  [R_0402]  139.3 98.52 0 top
RH192  30_0402_5%  [R_0402]  97.02 101.25 0 bottom
RH193  100_0402_1%  [R_0402]  98.71 51.31 270 top
RH197  100_0402_1%  [R_0402]  113.54 113.68 90 top
RH199  100K_0402_5%  [R_0402]  12.64 14.43 90 bottom
RH201  100_0402_1%  [R_0402]  95.8 115.51 270 top
RH203  100_0402_1%  [R_0402]  117.77 114.62 270 top
RH213  150_0402_1%  [R_0402]  91.76 20.49 270 top
RH214  200_0402_1%  [R_0402]  93.76 23.75 270 bottom
RH215  200_0402_1%  [R_0402]  92.81 23.75 270 bottom
RH216  200_0402_1%  [R_0402]  92.08 22.27 270 top
RH218  10K_0402_5%  [R_0402]  96.78 30.72 0 bottom
RH453  10K_0402_5%  [R_0402]  113.03 18.46 270 top
RH460  1K_0402_5%  [R_0402]  104.24 21.18 90 top
RH461  1K_0402_5%  [R_0402]  103.37 21.18 90 top
RH462  1K_0402_5%  [R_0402]  103.54 20.68 90 bottom
RH463  1K_0402_5%  [R_0402]  104.43 20.68 90 bottom
RH466  100_0402_1%  [R_0402]  115.44 114.54 270 top
RH469  100_0402_1%  [R_0402]  96.69 115.51 270 top
RH472  100_0402_1%  [R_0402]  116.33 114.54 270 top
RH489  1K_0402_5%  [R_0402]  122.72 32.54 0 top
RH493  2.2K_0402_5%  [R_0402]  122.67 31.71 0 top
RH494  51_0402_5%  [R_0402]  140.22 103.72 180 top
RH495  51_0402_5%  [R_0402]  140.22 102.83 180 top
RH496  51_0402_5%  [R_0402]  140.22 104.61 180 top
RH497  51_0402_5%  [R_0402]  140.46 143.06 0 top
RH501  499_0402_1%  [R_0402]  101.66 21.16 90 top
RH502  499_0402_1%  [R_0402]  102.49 21.16 90 top
RH506  1M_0402_5%  [R_0402]  109.66 22.01 270 top
RH512  10K_0402_5%  [R_0402]  119.85 34.6 0 top
RH515  8.2K_0402_5%  [R_0402]  112.97 22.01 270 top
RH516  10K_0402_5%  [R_0402]  98.97 20.93 90 bottom
RH517  8.2K_0402_5%  [R_0402]  103.39 25.63 90 bottom
RH518  10K_0402_5%~D  [R_0402]  110.44 22.01 270 top
RH519  0_0402_5%  [R_0402]  142.06 109.06 180 top
RH520  8.2K_0402_5%  [R_0402]  102.52 25.63 90 bottom
RH521  10K_0402_5%  [R_0402]  105.13 25.63 90 bottom
RH524  1K_0402_5%  [R_0402]  108.89 21.07 180 top
RH525  330K_0402_5%  [R_0402]  140.13 51.27 0 top
RH530  0_0402_5%  [R_0402]  101.21 91.72 0 bottom
RH531  1M_0402_5%  [R_0402]  118.49 26.75 90 bottom
RH533  8.2K_0402_5%  [R_0402]  111.32 22.01 270 top
RH537  10K_0201_5%  [R_0201]  102.84 31.59 270 bottom
RH545  10K_0402_5%  [R_0402]  112.14 22.01 270 top
RH558  10K_0201_5%  [R_0201]  108.56 23.33 270 top
RH571  8.2K_0402_5%  [R_0402]  89.48 30.04 180 top
RH580  1K_0402_5%  [R_0402]  89.8 48.54 180 top
RH581  1K_0402_5%  [R_0402]  94.17 47.01 90 bottom
RH588  10K_0402_5%  [R_0402]  106.28 19.25 270 top
RH589  10K_0402_5%  [R_0402]  105.4 19.25 270 top
RH590  60.4_0402_1%  [R_0402]  89.74 39.45 90 top
RH592  0_0402_5%  [R_0402]  96.96 106 90 bottom
RH593  0_0402_5%  [R_0402]  92.96 109.13 270 top
RH594  100K_0402_5%  [R_0402]  109.66 19.19 90 top
RH595  10K_0402_5%  [R_0402]  95.52 29.3 180 bottom
RH598  0_0402_5%  [R_0402]  101.44 36.32 270 bottom
RH599  0_0402_5%  [R_0402]  97.4 29.25 180 bottom
RH600  1K_0402_5%  [R_0402]  108.63 26.54 270 bottom
RH601  2.2K_0402_5%  [R_0402]  88.63 31.27 0 top
RH602  2.2K_0402_5%  [R_0402]  109.82 32.05 45 bottom
RH603  4.7K_0402_5%  [R_0402]  88.95 27.46 0 top
RH604  2.2K_0402_5%  [R_0402]  88.76 23.84 0 top
RH605  2.2K_0402_5%  [R_0402]  88.76 23.08 0 top
RH606  2.2K_0402_5%  [R_0402]  96.02 24.19 180 bottom
RH607  2.2K_0402_5%  [R_0402]  96.02 25.07 180 bottom
RH613  0_0402_5%  [R_0402]  86.22 11.92 90 top
RH1016  0_0402_5%  [R_0402]  108.06 18.34 90 top
RH1017  0_0402_5%  [R_0402]  110.55 20.11 270 top
RH1019  10K_0402_5%  [R_0402]  118.84 33.46 0 bottom
RH1020  10K_0402_5%  [R_0402]  118.84 32.7 0 bottom
RH1021  10K_0402_5%  [R_0402]  89.75 41.6 0 top
RH1022  33_0201_5%  [R_0201]  140.44 109.06 180 top
RH1023  10K_0201_5%  [R_0201]  98.21 18.6 90 bottom
RH1024  10K_0201_5%  [R_0201]  98.81 18.6 90 bottom
RH1025  10K_0201_5%  [R_0201]  88.93 25.11 0 top
RH1026  10K_0201_5%  [R_0201]  88.93 24.54 0 top
RH1027  10K_0201_5%  [R_0201]  89.66 20.44 90 top
RH1028  10K_0201_5%  [R_0201]  89.66 22.29 270 top
RH1029  10K_0201_5%  [R_0201]  90.93 20.44 90 top
RH1030  10K_0201_5%  [R_0201]  90.93 22.29 270 top
RH1031  33_0201_5%  [R_0201]  96.33 21.39 90 top
RH1032  10K_0201_5%  [R_0201]  90.3 20.44 90 top
RH1033  10K_0201_5%  [R_0201]  90.3 22.29 270 top
RH1035  4.7K_0402_5%  [R_0402]  103.2 20.22 180 top
RH1039  10K_0402_5%  [R_0402]  85.84 42.78 0 bottom
RH1040  10K_0402_5%  [R_0402]  88.32 40.6 270 bottom
RH1599  10M_0402_5%  [R_0402]  82.96 20.17 90 bottom
RH1600  10K_0402_5%  [R_0402]  86.06 22.89 90 bottom
RH1601  10K_0201_5%  [R_0201]  100.55 26.49 90 bottom
RM1  0_0201_5%  [R_0201]  35.94 146.75 270 top
RM2  0_0201_5%  [R_0201]  35.31 146.75 270 top
RM5  10K_0402_5%  [R_0402]  68.86 133.5 270 top
RM6  10K_0402_5%  [R_0402]  54.43 143.03 180 top
RM14  1K_0201_1%  [R_0201]  64.49 147.31 0 top
RM17  100K_0402_5%  [R_0402]  45.48 146.84 180 top
RM18  2.2_0402_1%  [R_0402]  85.23 24.72 90 bottom
RM20  1K_0402_1%  [R_0402]  88.76 36.2 270 bottom
RM21  1K_0402_1%  [R_0402]  86.98 36.2 270 bottom
RM23  1K_0201_1%  [R_0201]  65.43 133.01 90 top
RM25  475_0402_1%  [R_0402]  87.89 24.68 90 bottom
RM26  1K_0201_1%  [R_0201]  66.07 133.01 90 top
RM27  33_0402_1%  [R_0402]  90.54 24.62 90 bottom
RM28  33_0402_1%  [R_0402]  91.43 24.62 90 bottom
RM29  49.9_0402_1%  [R_0402]  91.43 23.75 270 bottom
RM38  49.9_0402_1%  [R_0402]  90.54 23.75 270 bottom
RM41  100K_0402_5%  [R_0402]  57.48 142.27 180 top
RM42  470K_0402_5%  [R_0402]  54.69 146.46 180 top
RM61  20K_0402_5%  [R_0402]  68.1 132.59 90 top
RM62  1K_0201_1%  [R_0201]  72.11 133.59 180 top
RM64  1K_0201_1%  [R_0201]  67.34 133.59 270 top
RM66  1K_0201_1%  [R_0201]  66.7 133.59 270 top
RM70  1K_0201_1%  [R_0201]  72.54 144.53 180 top
RM72  10K_0201_5%  [R_0201]  65.08 146.04 180 top
RM75  1K_0201_1%  [R_0201]  69.62 133.01 90 top
RM76  1K_0201_1%  [R_0201]  72.54 143.89 180 top
RM79  1K_0201_1%  [R_0201]  70.26 133.01 90 top
RM81  1K_0201_1%  [R_0201]  72.54 145.8 180 top
RM82  1K_0201_1%  [R_0201]  64.8 133.01 90 top
RM84  1K_0201_1%  [R_0201]  72.54 145.16 180 top
RM85  1K_0201_1%  [R_0201]  64.16 133.01 90 top
RM86  1K_0201_1%  [R_0201]  70.89 133.01 90 top
RM87  10K_0201_5%  [R_0201]  65.08 146.68 180 top
RM91  549_0402_1%  [R_0402]  50.29 141.98 0 top
RM92  100K_0402_5%~D  [R_0402]  49.43 141.98 180 top
RM93  100_0402_1%  [R_0402]  44.45 142.17 0 top
RM94  100K_0402_5%~D  [R_0402]  43.59 142.17 180 top
RM96  4.7K_0402_5%  [R_0402]  87.74 36.2 270 bottom
RP2  33_0804_8P4R_5%  [RP_0804_8P4R]  97.65 20.69 90 top
RP3  10K_0804_8P4R_5%  [RP_0804_8P4R]  105.46 20.61 90 top
RP5  10K_0804_8P4R_5%  [RP_0804_8P4R]  107.15 20.75 90 bottom
RPC7  10K_0804_8P4R_5%  [RP_0804_8P4R]  120.36 37.19 0 top
RPH5  15_0804_8P4R_5%  [RP_0804_8P4R]  120.24 33.25 0 top
RT1  0_0201_5%  [R_0201]  89.75 141.76 0 top
RT2  0_0201_5%  [R_0201]  84.95 135.69 270 bottom
RT3  3.01K_0201_1%  [R_0201]  76.69 141.53 270 top
RT4  1M_0201_1%  [R_0201]  86.63 141.3 0 bottom
RT5  14K_0402_1%  [R_0402]  82.6 141.82 0 top
RT6  10K_0201_5%  [R_0201]  84.81 139.41 180 top
RT7  10K_0201_5%  [R_0201]  84.81 140.55 180 top
RT8  10K_0201_5%  [R_0201]  84.81 139.98 180 top
RT9  10K_0201_5%  [R_0201]  84.81 138.84 180 top
RT10  0_0201_5%  [R_0201]  86.63 138.13 0 bottom
RT11  1M_0201_1%  [R_0201]  86.63 137.37 0 bottom
RT12  0_0201_5%  [R_0201]  87.96 138.5 0 top
RT13  0_0201_5%  [R_0201]  87.96 137.86 0 top
RT14  0_0201_5%  [R_0201]  86.63 141.94 0 bottom
RT15  0_0201_5%  [R_0201]  86.62 146.37 0 bottom
RT16  0_0201_5%  [R_0201]  86.63 143.21 0 bottom
RT17  100_0201_5%  [R_0201]  86.63 145.11 0 bottom
RT18  100_0201_5%  [R_0201]  83.68 135.69 270 bottom
RT19  14K_0402_1%  [R_0402]  76.66 138.97 180 top
RT20  10K_0201_5%  [R_0201]  84.31 135.11 90 bottom
RT21  10K_0201_5%  [R_0201]  83.72 144.24 0 top
RT22  0_0201_5%  [R_0201]  97.09 139.94 90 top
RT23  0_0201_5%  [R_0201]  87.96 139.77 0 top
RT25  4.75K_0402_0.5%  [R_0402]  82.44 143.47 180 top
RT26  3.3K_0201_5%  [R_0201]  87.27 139.15 180 top
RT27  3.3K_0201_5%  [R_0201]  87.27 139.78 180 top
RT28  10K_0201_5%  [R_0201]  87.21 138.76 180 bottom
RT29  10K_0201_5%  [R_0201]  87.21 139.4 180 bottom
RT30  10K_0201_5%  [R_0201]  87.21 145.75 180 bottom
RT31  10K_0201_5%  [R_0201]  87.21 142.57 180 bottom
RT32  10K_0201_5%  [R_0201]  88.54 139.13 180 top
RT33  10K_0201_5%  [R_0201]  87.21 144.48 180 bottom
RT34  100K_0201_5%  [R_0201]  86.63 140.03 0 bottom
RT35  100K_0201_5%  [R_0201]  83.29 147.92 180 top
RT36  10K_0201_5%  [R_0201]  87.21 143.84 180 bottom
RT37  100K_0201_5%  [R_0201]  82.68 146.74 90 top
RT38  100K_0201_5%  [R_0201]  84.23 137.95 0 top
RT39  100K_0201_5%  [R_0201]  81.65 138.23 270 top
RT40  1M_0201_1%  [R_0201]  81.32 149.25 180 bottom
RT41  100K_0201_5%  [R_0201]  86.69 141.69 0 top
RT42  1M_0201_1%  [R_0201]  81.94 149.25 0 bottom
RT43  499_0201_1%  [R_0201]  75.35 144.49 180 top
RT44  499_0201_1%  [R_0201]  75.35 145.06 180 top
RT45  100K_0201_5%  [R_0201]  88.43 145.13 180 bottom
RT46  100K_0201_5%  [R_0201]  80.11 149.25 180 bottom
RT47  100K_0201_5%  [R_0201]  86.63 140.67 0 bottom
RT48  3.3K_0201_5%  [R_0201]  75.98 120.11 180 top
RT49  2.2K_0201_5%  [R_0201]  75.98 119.47 180 top
RT50  2.2K_0201_5%  [R_0201]  75.98 117.57 180 top
RT51  3.3K_0201_5%  [R_0201]  64.74 118.26 180 top
RT52  15_0402_5%  [R_0402]  63.8 120.11 0 top
RT53  0_0402_5%  [R_0402]  90.36 141.05 90 bottom
RT59  0_0201_5%  [R_0201]  95.82 140.53 270 top
RT60  0_0201_5%  [R_0201]  96.46 140.53 270 top
RT61  0_0201_5%  [R_0201]  90.36 143.49 0 bottom
RT62  100K_0201_5%  [R_0201]  90.4 139.16 180 bottom
RT63  100K_0201_5%  [R_0201]  101.32 140.26 0 bottom
RT64  10K_0201_5%  [R_0201]  97.19 144.97 90 bottom
RT65  10K_0201_5%  [R_0201]  99.38 145 90 bottom
RT66  10K_0201_5%  [R_0201]  94.55 141.73 270 top
RT67  10K_0201_5%  [R_0201]  95.19 141.73 270 top
RT68  100K_0201_5%  [R_0201]  94.37 144.99 90 bottom
RT69  100K_0201_5%  [R_0201]  93.74 144.99 90 bottom
RT70  100K_0201_5%  [R_0201]  91.59 143.41 0 bottom
RT71  100K_0201_5%  [R_0201]  93.74 146.78 270 bottom
RT72  100K_0201_5%  [R_0201]  94.37 146.78 270 bottom
RT73  100K_0201_5%  [R_0201]  92.18 142.84 180 bottom
RT75  15K_0201_1%  [R_0201]  90.4 139.79 180 bottom
RT76  100K_0201_5%  [R_0201]  77.33 132.77 270 top
RT77  100K_0201_5%  [R_0201]  73.52 133.98 270 top
RT78  100K_0201_5%  [R_0201]  75.42 132.77 270 top
RT79  100K_0201_5%  [R_0201]  75.42 133.98 270 top
RT80  100K_0201_5%  [R_0201]  88.54 140.4 180 top
RT83  0_0201_5%  [R_0201]  89.81 140.38 0 bottom
RT86  10K_0201_5%  [R_0201]  87.85 144.49 0 bottom
RT88  470K_0402_5%~D  [R_0402]  95.97 15.06 0 bottom
RT89  39_0402_5%~D  [R_0402]  95.84 18.62 0 bottom
RT90  8.2_0402_5%~D  [R_0402]  98.4 15.9 270 bottom
RT94  10K_0201_5%  [R_0201]  83.25 146.74 90 top
RT95  0_0805_5%  [R_0805]  88.14 146.33 180 top
RT97  0_0402_5%  [R_0402]  84.91 147.98 180 top
RT98  0_0201_5%  [R_0201]  95.19 140.53 270 top
RT99  0_0201_5%  [R_0201]  75.4 118.84 0 top
RT100  0_0201_5%  [R_0201]  75.4 116.93 0 top
RT101  0_0201_5%  [R_0201]  94.55 140.53 270 top
RT102  0_0201_5%  [R_0201]  101.31 141 0 bottom
RT107  10K_0201_5%  [R_0201]  89.66 141.28 90 bottom
RT108  100K_0402_5%  [R_0402]  97.82 141.75 270 top
RT109  0_0402_5%  [R_0402]  96.06 141.51 0 top
RT111  0_0603_5%  [R_0603]  90.69 20 90 bottom
RT112  0_0402_5%  [R_0402]  95.06 145.05 90 bottom
RT113  0_0402_5%  [R_0402]  96.2 145.05 90 bottom
RT114  0_0402_5%  [R_0402]  95.06 147.68 270 bottom
RT115  0_0402_5%  [R_0402]  96.2 147.68 270 bottom
RT116  0_0402_5%  [R_0402]  70.1 146.29 180 bottom
RT117  0_0402_5%  [R_0402]  70.1 147.18 180 bottom
RT124  10K_0201_5%  [R_0201]  92.47 145.7 270 bottom
RT125  10K_0201_5%  [R_0201]  93.04 145.11 90 bottom
RT126  100K_0201_5%  [R_0201]  86.69 140.42 0 top
RT127  100K_0201_5%  [R_0201]  82.28 138.23 270 top
RT128  100K_0201_5%  [R_0201]  86.69 141.05 0 top
RT129  100K_0201_5%  [R_0201]  81.75 139.03 0 top
RT130  0_0201_5%  [R_0201]  101.89 142.27 180 bottom
RT131  0_0201_5%  [R_0201]  101.89 141.63 180 bottom
RT132  10K_0402_5%  [R_0402]  79.01 150.59 180 top
RT200  10K_0201_5%  [R_0201]  74.76 143.92 0 top
RT693  100K_0402_5%  [R_0402]  83.24 143.47 0 top
RT694  0_0201_5%  [R_0201]  102.03 20.98 90 bottom
RT695  10K_0201_5%  [R_0201]  88.1 145.19 0 top
RT720  0_0201_5%  [R_0201]  91.34 140.74 0 bottom
RT721  0_0201_5%  [R_0201]  91.34 141.32 0 bottom
RT722  0_0201_5%  [R_0201]  91.34 139.16 0 bottom
RT723  10K_0201_5%  [R_0201]  83.06 144.78 270 top
RT724  100K_0201_5%  [R_0201]  87.29 138.52 180 top
RT725  100K_0201_5%  [R_0201]  87.29 137.89 180 top
RT727  100K_0201_5%  [R_0201]  86.64 142.52 0 top
RT728  0_0402_5%  [R_0402]  88.77 142.86 0 bottom
RT729  0_0805_5%  [R_0805]  75.45 129.28 90 top
RU4  100K_0402_5%  [R_0402]  86.12 11.27 180 bottom
RU5  220K_0402_5%  [R_0402]  88.9 9.5 270 bottom
RU6  1M_0402_5%  [R_0402]  83.62 10.44 270 bottom
RV1  10K_0201_5%  [R_0201]  26.09 134.77 90 top
RV9  100K_0402_5%  [R_0402]  29.55 144.96 90 top
RV12  100K_0402_5%  [R_0402]  31.25 145.94 270 top
RV15  100K_0201_5%  [R_0201]  120.75 140.43 180 bottom
RV16  100K_0201_5%  [R_0201]  120.75 138.39 180 bottom
RV17  1M_0201_1%  [R_0201]  120.23 142.14 0 bottom
RV18  5.1M_0402_5%  [R_0402]  118.75 142.6 90 top
RV27  6.04 +-1% 0402  [R_0402]  134.3 143.14 90 bottom
RV28  6.04 +-1% 0402  [R_0402]  133.35 143.14 90 bottom
RV29  6.04 +-1% 0402  [R_0402]  124.78 143.02 90 bottom
RV30  6.04 +-1% 0402  [R_0402]  123.89 143.02 90 bottom
RV33  6.04 +-1% 0402  [R_0402]  129.54 143.02 90 bottom
RV34  6.04 +-1% 0402  [R_0402]  128.59 143.02 90 bottom
RV500  150_0402_1%  [R_0402]  137.59 142.27 0 bottom
RV501  150_0402_1%  [R_0402]  133.4 142.33 0 bottom
RV502  150_0402_1%  [R_0402]  123.88 142.2 0 bottom
RV503  150_0402_1%  [R_0402]  128.64 142.2 0 bottom
RV618  0_0402_5%  [R_0402]  110.82 139.35 180 bottom
RV619  0_0402_5%  [R_0402]  110.82 138.46 180 bottom
RV638  5.6_0402_1%  [R_0402]  128.65 140.16 90 bottom
RV639  5.6_0402_1%  [R_0402]  123.89 140.1 90 bottom
RV640  5.6_0402_1%  [R_0402]  137.67 140.16 90 bottom
RV641  5.6_0402_1%  [R_0402]  138.56 140.16 90 bottom
RV642  5.6_0402_1%  [R_0402]  124.78 140.1 90 bottom
RV643  5.6_0402_1%  [R_0402]  134.3 140.16 90 bottom
RV645  5.6_0402_1%  [R_0402]  129.54 140.16 90 bottom
RV646  5.6_0402_1%  [R_0402]  133.41 140.16 90 bottom
RV648  10K_0402_5%  [R_0402]  135.06 142.32 90 top
RV649  3.3K_0402_1%  [R_0402]  138.37 142.32 90 top
RV650  33_0402_1%  [R_0402]  136.65 143.23 270 top
RV651  33_0402_1%  [R_0402]  139.19 143.23 270 top
RV652  10K_0402_5%  [R_0402]  135.87 142.32 90 top
RV653  3.3K_0402_1%  [R_0402]  137.48 142.32 90 top
RV655  10K_0402_5%  [R_0402]  133.34 143.22 0 top
RV664  100K_0402_5%  [R_0402]  110.82 137.63 180 bottom
RV665  100K_0402_5%  [R_0402]  110.82 140.17 180 bottom
RV671  2.2K_0201_5%  [R_0201]  111.57 137.66 90 bottom
RV672  2.2K_0201_5%  [R_0201]  111.57 139.45 270 bottom
RV673  6.04 +-1% 0402  [R_0402]  138.56 143.08 90 bottom
RV674  6.04 +-1% 0402  [R_0402]  137.54 143.08 90 bottom
RV679  0_0402_5%  [R_0402]  40.64 145.01 270 top
RV681  0_0402_5%  [R_0402]  23.67 136.03 270 top
RV682  0_0402_5%  [R_0402]  22.85 136.03 270 top
RV683  100K_0402_1%  [R_0402]  27.44 141.73 180 bottom
RV684  100_0402_5%  [R_0402]  29.55 146.66 180 bottom
RV685  10.5K_0402_1%  [R_0402]  30.56 146.64 0 bottom
RV686  100K_0402_5%  [R_0402]  86.4 10.11 0 top
RX1  100K_0402_5%  [R_0402]  132.54 143.22 180 top
RX2  150K_0402_5%  [R_0402]  123.58 142.78 180 top
RX3  10K_0201_5%  [R_0201]  103 146.04 90 top
RX4  10K_0402_5%  [R_0402]  121.54 140.54 90 top
RX5  10K_0402_5%  [R_0402]  128.45 137.87 90 top
RX6  150K_0402_5%  [R_0402]  128.13 143.22 0 top
RX7  10K_0402_5%  [R_0402]  129.22 138.76 270 top
RX8  10K_0402_5%  [R_0402]  127.27 143.22 180 top
RX9  10K_0201_5%  [R_0201]  107.25 146.56 270 top
RX31  499_0201_1%  [R_0201]  134.75 138.88 270 bottom
RX32  499_0201_1%  [R_0201]  133.03 138.88 270 bottom
RX33  499_0201_1%  [R_0201]  139.51 138.81 270 bottom
RX34  499_0201_1%  [R_0201]  137.73 138.81 270 bottom
RX35  499_0201_1%  [R_0201]  125.29 138.75 270 bottom
RX36  499_0201_1%  [R_0201]  123.51 138.75 270 bottom
RX37  499_0201_1%  [R_0201]  130.05 138.81 270 bottom
RX38  499_0201_1%  [R_0201]  128.27 138.81 270 bottom
RX39  10K_0402_5%  [R_0402]  111.33 142.28 270 bottom
SW1  TST71A-N-220-S017 SPST H0.6 2P  [SW_TST71-N-220-T170-S017_2P]  14.49 19.52 180 bottom
T2  PAD~D  [TPC12]  85.79 139.85 0 bottom
T6  PAD~D  [TPC12]  61.35 88.03 0 top
T10  PAD~D  [TPC12]  57.77 99.62 270 bottom
T11  PAD~D  [TPC12]  60.74 97.48 270 bottom
T12  PAD~D  [TPC12]  62.03 98.75 270 bottom
T13  PAD~D  [TPC12]  60.12 100.08 270 bottom
T14  PAD~D  [TPC12]  61.4 113.87 0 top
T15  PAD~D  [TPC12]  62.73 99.29 270 top
T16  PAD~D  [TPC12]  61.47 100.19 270 bottom
T18  PAD~D  [TPC12]  55.93 81.02 0 top
T21  PAD~D  [TPC12]  55.75 79.73 0 top
T22  PAD~D  [TPC12]  53.84 81.08 0 top
T24  PAD~D  [TPC12]  53.09 80.01 0 top
T25  PAD~D  [TPC12]  52.35 81.07 0 top
T49  PAD~D  [TPC12]  95.97 37.94 270 bottom
T50  PAD~D  [TPC12]  95.03 39.4 270 bottom
T62  PAD~D  [TPC12]  90.72 138.18 180 bottom
T63  PAD~D  [TPC12]  89.45 137.71 180 bottom
T64  PAD~D  [TPC12]  91.48 137.15 180 bottom
T65  PAD~D  [TPC12]  92.11 138.29 180 bottom
T70  PAD~D  [TPC12]  98.07 139.83 180 top
T114  PAD~D  [TPC12]  99.99 140.36 180 bottom
T120  PAD~D  [TPC12]  100.39 141.73 180 bottom
T121  PAD~D  [TPC12]  102.81 140.79 180 bottom
T122  PAD~D  [TPC12]  102.74 142.24 180 bottom
T135  PAD~D  [TPC12]  109.05 33.56 270 bottom
T144  PAD~D  [TPC12]  138.8 93.97 0 top
T145  PAD~D  [TPC12]  102.97 34.41 270 bottom
T146  PAD~D  [TPC12]  96.44 22.81 90 top
T194  PAD~D  [TPC12]  93.94 107.89 0 top
T195  PAD~D  [TPC12]  107.36 33.34 180 bottom
T197  PAD~D  [TPC12]  75.92 12.7 0 top
TC13  PAD~D  [TPC12]  95.47 80.6 0 top
TC20  PAD  [TPC12]  88.02 13.21 90 top
TC21  PAD  [TPC12]  84.29 12.65 90 bottom
TC22  PAD  [TPC12]  85.48 11.03 90 top
TC23  PAD  [TPC12]  85.29 12.64 90 top
TC24  PAD  [TPC12]  83.4 11.48 90 bottom
TC25  PAD  [TPC12]  84.35 13.5 90 top
TC26  PAD  [TPC12]  84.37 11.75 90 top
U16  -  [AOZ1334DI-02_DFN8-7_3X3]  91.74 17.14 180 top
U17  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  66.81 13.12 0 bottom
U18  -  [SY6288C20AAC_SOT23-5]  99.88 17.42 180 top
U19  -  [AOZ1334DI-01_DFN8-7_3X3]  86.46 108.51 270 top
U20  -  [AOZ1334DI-01_DFN8-7_3X3]  86.46 112.32 270 top
U2407  -  [F75305M_MSOP10]  61.13 68.87 180 top
UC1  CFL-H_BGA1440  [CFL-H_BGA_1440P-T]  96.19 84.79 270 top
UC2  -  [74AUP1G07GW_TSSOP5]  142.37 48.97 90 top
UD1  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  139.9 71.05 180 bottom
UD2  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  129.5 71.05 180 bottom
UD3  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  133.5 71.05 0 top
UD4  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  123.1 71.05 0 top
UD5  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  114 71.05 180 bottom
UD6  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  103.6 71.05 180 bottom
UD7  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  107.6 71.05 0 top
UD8  K4A8G165WB-BCPB_FBGA96  [K4A8G165WB-BCPB_FBGA_96P]  97.2 71.05 0 top
UE1  -  [STM32F070CBT6TR_LQFP48_7X7]  126.52 23.58 180 bottom
UE2  GD25Q80CSIGR SOP8  [EN25F80-75HCP_SO8]  137.86 18.31 180 bottom
UE5  KB9542G-B_VFBGA124  [KB9542G-B_VFBGA_124P]  77.16 11.36 90 top
UE8  -  [TLC59116FIRHBR_VQFN32_5X5]  109.37 16.16 270 bottom
UE9  -  [SY6288C20AAC_SOT23-5]  138.23 15.58 270 bottom
UE10  KC3810_QFN24_4X4  [KC3810NF-A0_QFN24_4X4]  90.33 17.12 180 bottom
UE12  -  [SY6288D20AAC_SOT23-5]  81.79 24.14 180 top
UG1  U_GPU_GB4B_256  [N18E-G3-ES-A1_FCBGA_2228P]  23.25 83.15 90 top
UG9  -  [GS7616SC-R_SOT363-6]  69.7 96.91 90 top
UG10  -  [NL17SZ08DFT2G_SC70-5]  94.35 22.12 180 top
UG11  MT61K256M32JE-13-A_FBGA180~D  [MT61K256M32JE-13-A_FBGA_180P]  29.78 139.12 0 top
UG12  MT61K256M32JE-13-A_FBGA180~D  [MT61K256M32JE-13-A_FBGA_180P]  57.12 126.38 180 top
UG13  MT61K256M32JE-13-A_FBGA180~D  [MT61K256M32JE-13-A_FBGA_180P]  2.88 107.09 90 top
UG14  MT61K256M32JE-13-A_FBGA180~D  [MT61K256M32JE-13-A_FBGA_180P]  15.62 133.91 270 top
UG15  MT61K256M32JE-13-A_FBGA180~D  [MT61K256M32JE-13-A_FBGA_180P]  2.88 72.93 90 top
UG16  MT61K256M32JE-13-A_FBGA180~D  [MT61K256M32JE-13-A_FBGA_180P]  15.62 99.75 270 top
UG17  MT61K256M32JE-13-A_FBGA180~D  [MT61K256M32JE-13-A_FBGA_180P]  55.32 62.78 180 top
UG18  MT61K256M32JE-13-A_FBGA180~D  [MT61K256M32JE-13-A_FBGA_180P]  29.43 75.52 0 top
UG22  -  [NL17SZ08DFT2G_SC70-5]  80.96 64.69 270 bottom
UG23  -  [BSS138DW_SC88-6]  80.71 57.38 270 bottom
UG26  -  [NL17SZ08DFT2G_SC70-5]  6.75 5.42 180 top
UG27  -  [74LVC1G32GW_TSSOP5]  73.99 63.14 180 bottom
UG29  -  [NL17SZ08DFT2G_SC70-5]  65.46 93.3 90 top
UG34  -  [W25Q80EWSSIG_SO8]  74.49 90.58 90 top
UG36  -  [AOZ1334DI-01_DFN8-7_3X3]  6.84 15.11 0 top
UG37  -  [NCP45491XMNTWG_QFN32_4X4]  4.59 34.51 0 top
UG39  -  [74LVC1G32GW_TSSOP5]  74.47 90.33 0 bottom
UG40  -  [NL17SZ08DFT2G_SC70-5]  72.28 87.62 180 bottom
UG41  -  [NL17SZ08DFT2G_SC70-5]  74.38 94.49 0 bottom
UG42  -  [NL17SZ08DFT2G_SC70-5]  69.76 89.56 270 bottom
UG43  -  [74LVC1G32GW_TSSOP5]  76.02 61 270 bottom
UG44  -  [74LVC1G32GW_TSSOP5]  71.72 59.53 180 bottom
UG45  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  67.68 93.99 180 bottom
UG46  -  [74LVC1G32GW_TSSOP5]  70.29 93.48 90 bottom
UG47  -  [NL17SZ08DFT2G_SC70-5]  3.94 7.58 180 top
UH1  CNP-H_BGA874  [CNP-H_BGA_874P-T]  92.99 48.11 0 top
UH3  -  [TC7SH08FU_SSOP5]  15.68 16.49 270 bottom
UH4  S IC FL 128M W25Q128JVSIQ SOIC8P SPI ROM  [W25Q128FVSIQ_SO8]  115.04 21.79 270 top
UM3  -  [TC7SH08FU_SSOP5]  54.42 144.03 90 top
UM4  PI6CEQ20200LIEX  [PI6CEQ20200LIEX_TSSOP20]  87.02 33.34 0 bottom
UM7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  55.87 143.35 0 top
UM8  -  [DS80PCI402SQNOPB_WQFN54_10X5P5]  70.65 135.59 90 top
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  84.55 147.56 180 bottom
UT2  -  [W25Q80DVSSIG_SO8]  73.6 117.57 90 top
UT3  -  [NL17SZ08DFT2G_SC70-5]  89.55 144.42 180 top
UT4  SN1703018ZQZR BGA96P  [TPS65982_BGA_96P]  93.69 138.62 0 bottom
UT5  -  [AOZ1336_DFN8_2X2]  92.15 19.79 90 bottom
UT8  -  [SY6288D20AAC_SOT23-5]  82.48 149.38 90 top
UU5  TC7SZ14FU_SSOP5~D  [TC7SZ14FU_SSOP5]  85.99 8.27 180 bottom
UV1  -  [AP2330W-7_SC59-3]  78.17 11.27 0 bottom
UV3  -  [SN74CBT3257CPWR_TSSOP16]  118.71 142.32 270 bottom
UV4  -  [G517AH1TP1U_TSOT23-6]  30.59 142.43 180 bottom
UX1  -  [NL17SZ08DFT2G_SC70-5]  121.16 139.23 270 top
UX2  -  [NL17SZ08DFT2G_SC70-5]  127.14 142.27 180 top
UX3  -  [SY6288C20AAC_SOT23-5]  106.29 145.45 90 top
UZ21  -  [AOZ1336DI_DFN8_2X2]  91.81 84.63 180 top
UZ45  -  [AOZ1336_DFN8_2X2]  78.8 7.71 90 bottom
YE1  12MHZ 12PF +-10PPM X3S012000DC1H-X  [Y_X3G024000DC1H_4P]  131.93 22.31 270 bottom
YG1  27MHZ 16PF +-30PPM 7M27070004F50Q5  [Y_5YEA27000163IF50Q5_4P]  62.67 89.05 270 bottom
YH1  32.768KHZ_X1A000141000300  [Y_CM31532768DZFT_2P]  117.63 32.58 180 bottom
YH2  24MHZ 12PF +-10PPM 7M24090001  [Y_X3G024000DC1H_4P]  87.71 50.07 270 bottom
YT2  25MHZ_20PF_XRCGB25M000F2P18R0  [Y_XRCGB25M000F2P18R0_4P]  66.62 146.04 90 bottom

## Library data of the parts
C2-C4 C6 C7 C10 C11 C256 C258 C260 C263 C265 C266 C268 C270 C617 C618 C621-C623 C629 C630 C632-C636 C639 C640 C2498 C2500 C2502 C2504-C2507 C2510 C2511 C2516 C2518-C2528 CC39 CD69 CD111-CD113 CD256 CD264 CD273 CD275-CD278 CD281 CD284 CD287 CD290-CD292 CD295 CD297 CD298 CD301 CD310 CD318 CD320 CD321 CD324 CD326 CD328 CD329 CD331-CD333 CD338-CD342 CD344 CD347-CD354 CD357-CD359 CD363 CD365 CD366 CD368 CD369 CD371-CD376 CE1 CE2 CE5-CE8 CE19 CE20 CE27-CE32 CE34 CE41 CE43-CE46 CE51 CE59 CE60 CE62-CE65 CE79 CE81 CE86 CE168-CE172 CE184 CE186 CE189-CE197 CG27-CG29 CG42 CG43 CG45 CG63 CG64 CG66 CG75 CG76 CG78 CG148 CG240 CG256 CG270 CG322 CG323 CG384 CG385 CG481 CG511 CG552 CG571 CG625 CG678 CG727 CG770 CG827 CG888 CG895 CG911 CG6506 CG6802 CG6804 CG6818-CG6823 CG6825 CG6826 CG7089 CG7090 CG7094-CG7097 CG7099 CG7101 CG7103 CG7107 CG7109 CG7115-CG7125 CG7136 CG7141 CG7142 CG7159 CG7160 CH36 CH45-CH49 CH80 CH82 CH118-CH128 CH173-CH176 CH180 CH186-CH188 CH190 CH192-CH195 CH197 CH226 CH231 CH242 CH244-CH253 CI38 CI39 CM9 CM16-CM18 CM20 CM21 CM23 CM30 CM32-CM36 CM70 CM98 CM99 CT50-CT53 CT81 CT82 CT88 CT94-CT98 CT101 CT103 CT104 CT114 CT115 CT117 CT118 CT121 CT123 CT5361 CU26 CU28 CU29 CV15 CV17 CV20 CV34 CV375 CV1056 CV1071 CV1074 CV1075 CV1080 CV1081 CV7160 CV7161 CX1 CX2 CZ120 CZ121 PC1-PC4 PC6-PC9 PC13 PC15 PC301 PC309-PC315 PC501 PC510-PC518 PC1105 PC1107-PC1115 PC1812 PC1815 PC1816 PC1818-PC1821 PC2501 PC2507-PC2511 PC2513-PC2517 PC2520 PC2521 PCA1-PCA3 PCA9-PCA12 PCB1-PCB8 PCB19 PCB20 PCB22-PCB35 PCG01 PCG02 PCG07 PCG8 PCG10-PCG12 PCH1 PCH4 PCH6-PCH9 PCH13 PCH18 PCH20-PCH28 PCM1-PCM3 PCM10 PCM11 PCM13-PCM16 PCM18 PCM19 PCV1 PCV3-PCV16 PCV18-PCV21 PCV23 PCV24 PCV34-PCV42 PCV48-PCV51 PCV62-PCV71 PCV82-PCV85 PCV96-PCV105 PCV112-PCV115 PCV126-PCV135 PCV142-PCV145 PCV156-PCV165 PCV207-PCV212 PCW2-PCW4 PCW6-PCW16 PCW21 PCW23-PCW25 PCW29-PCW31 PCW36 PCW38-PCW44 PCZ1-PCZ3 PCZ5-PCZ7 PCZ10-PCZ40 PCZ47 PCZ48 PCZ55-PCZ58 PCZ61-PCZ71 PCZ73 PCZ80 PCZ81 PCZ88-PCZ91 PCZ94-PCZ104 PCZ106 PCZ109 PCZ110 PCZ117-PCZ120 PCZ123-PCZ135 PCZ230-PCZ239 PCZ251-PCZ253 = C_0402
C8 C257 C261 C262 C264 C267 C269 C2512-C2515 CE22 CF4 CG1-CG10 CG62 CG101-CG112 CG516-CG521 CG546-CG551 CG573-CG584 CG638-CG649 CG679-CG690 CG732-CG743 CG785-CG796 CG838-CG849 CG6501 CG6507 CG6876-CG6896 CG7084 CG7098 CG7100 CG7104 CG7110 CH52 CH53 CH102-CH104 CH129-CH132 CH182 CH233 CM19 CM29 CM31 CT73-CT75 CT90-CT93 CT99 CT100 CT106 CT116 CT124 CT154 CT155 CT157 CU27 CV14 CV18 CV1068 CV1076-CV1079 PC14 PC302-PC308 PC502-PC509 PC1101-PC1104 PC1106 PC1808-PC1811 PC1813 PC1814 PC1817 PC2502-PC2506 PC2518 PCA4 PCA6 PCA7 PCB9-PCB18 PCB21 PCG03 PCG04 PCG09 PCH2 PCH3 PCH5 PCH10 PCH14-PCH17 PCH19 PCM4-PCM9 PCM12 PCM17 PCV22 PCV26-PCV33 PCV52-PCV61 PCV86-PCV95 PCV116-PCV125 PCV146-PCV155 PCV175 PCV180-PCV201 PCV214-PCV245 PCW1 PCW5 PCW17-PCW20 PCW22 PCW32-PCW35 PCW37 PCZ49 PCZ50 PCZ52 PCZ53 PCZ59 PCZ60 PCZ84-PCZ87 PCZ92 PCZ93 PCZ111 PCZ113 PCZ114 PCZ116 PCZ121 PCZ122 PCZ138-PCZ158 PCZ160 PCZ162 PCZ164 PCZ169 PCZ173 PCZ175 PCZ176 PCZ181 PCZ240-PCZ244 = C_0603
C631 C641 PCV43 PCV44 PCV213 = C_B2
CC1-CC24 CC36 CC37 CC40-CC55 CD114 CD263 CD265-CD272 CD274 CD279 CD280 CD282 CD283 CD285 CD286 CD288 CD289 CD293 CD296 CD299 CD300 CD302-CD309 CD311-CD317 CD319 CD322 CD323 CD325 CD327 CD334-CD337 CD343 CD345 CD346 CD355 CD356 CD360-CD362 CD364 CD367 CD370 CD377-CD402 CG11-CG26 CG30-CG41 CG59-CG61 CG65 CG246 CG312 CG476 CG478 CG483 CG512-CG515 CG553-CG556 CG569 CG570 CG621-CG624 CG674 CG676 CG677 CG718 CG722 CG723 CG726 CG768 CG769 CG771-CG784 CG823 CG826 CG835 CG837 CG878 CG882 CG887 CG889 CG896 CG907-CG910 CG6502 CG6508 CG6509 CG6522-CG6797 CG6803 CG6815-CG6817 CG6824 CG6828-CG6875 CG6897-CG7083 CG7085 CG7087 CG7088 CG7091-CG7093 CG7105 CG7106 CG7108 CG7126 CG7127 CG7133-CG7135 CG7137-CG7140 CG7143-CG7153 CG7157 CH105-CH107 CH201-CH225 CM62-CM69 CT2 CT6-CT12 CT14 CT16 CT23-CT49 CT54-CT72 CT77-CT80 CT83-CT86 CT102 CT108-CT113 CT153 CV1-CV4 CV6-CV8 CV11-CV13 CV23-CV33 CV35 CV1057-CV1064 CV1069 PCZ182-PCZ229 = C_0201
CD330 = C_X
CE183 CF5 CH181 CT122 PC2512 PC2519 PCV172-PCV174 PCV176-PCV179 PCZ159 PCZ161 PCZ163 PCZ165-PCZ168 PCZ170-PCZ172 PCZ174 PCZ177-PCZ180 = C_0805
CLIP1 = CLIP_10P2X7P2_SHIELDING_CASE1
CLRP1 = SHORTPADS: User Part Number: PART#
DE1 DF1 DF2 DU6 DU8 = SDMK0340L-7-F_SOD323-2
DE2 DE3 DH1 DV1 PD501 PDM01 PDV01 = RB751V-40_SOD323-2
DG2-DG4 DG7-DG10 DT1 DV12 DV13 = RB520SM-30T2R_EMD2-2
DK1-DK3 PD2 PD3 = TVNST52302AB0_SOT523-3
DT2-DT9 DT11-DT14 DT16 = PESD5V0H1BSF_SOD962-2-2
DT10 = TVWDF1004AD0_DFN9
DT15 PD1 = PESD24VS2UT_SOT23-3
DV4 = AZC199-02SPR7G_SOT23-3
FD1-FD4 = FIDUCIAL_C40M80
FV2 FV3 = F_SPR-P110
FV4 = F_SMD1812P150TF-24
H1 = H_4P0
H2 = H_3P7-G
H3-H5 H10 H11 H13 = H_2P6-G
H6 = H_4P3X3P7-G
H7 H14 H15 = H_4P0-G
H12 = H_1P8
J4-J6 PJP42 PJP1101 PJP1803 PJP2502 PJPG01 = JUMP_43X79
JCDRA = TE_2260531-1_46P
JDP = ACON_MAR2A-2061801_20P
JEDP = ACES_50473-0400M-P01_40P
JELC2 = CVILU_CH51102M100-0P_10P-T
JFAN1 JFAN2 = CVILU_CI4204M2HR0-NH_4P
JGYRO = ACES_50208-00601-P01_6P
JHDMI = ACON_HMRF5-AK1L0C_19P
JIO1 JIO2 = UNIMI_FBGCAX011_68P-T
JP1 PJP303 PJP2501 PJP2503 PJP2504 PJPG02 PJPM04 = JUMP_43X39
JPCMC = INTEL_CMC_PRIMARY_36P-T
JPK = CVILU_CF5020FD0RK-05-NH_20P
JPTRON = ACES_50208-01201-P01_12P-T
JRTC1 = TWVM_WTB1220-02RD-MAGHB_2P
JSSD1 JSSD3 = LOTES_YPCI0020-P001A_75P-T
JTOBII = HRS_DF52-6S-0P8H-21_6P-T
JTP15 = STARC_106A08-001020-A2-R_8P
JTP17 = ACES_51678-0080N-001_8P-T
JUSBC = JAE_DX07SA24XJ2R1000_24P
JWDB JWDB1 = ACES_50207-00471-P01_4P-T
LE1 LE5 = KC_FBMA-L11-160808-800LMT_2P
LE3 LE7 LT2 LT3 LV2 = MURAT_DLM0NSN900HY2D_4P
LE4 = MURAT_BLM15AG121SN1D_L0402_2P
LG1 LG6 LG8-LG10 = CHILI_PBY160808T-300Y-N_2P
LM1 = MURAT_DLM0NSN900HY2D_4P: signal model: INPAQ_MCM1012B900F06BP_4P_MCM1012B900F06BP_4P
LT1 = MAG_MND-04ABIR60M-XGL_2P
LT4 = MURAT_LQM18PN1R0MFHD_2P
LV3-LV6 = INPAQ_HCM1012GH900BP_4P-NPM
LX1-LX8 = CHILI_PBY100505T-300Y-N_2P
PBATT1 = OCTEK_WTB-10FPBLAB-U_10P
PCH11 PCH12 PCV78 PCV79 PCV108 PCV109 PCV138 PCV139 PCV168 PCV169 PCV202 PCV203 PCW26 PCW28 PCZ246 PCZ248 PCZ249 = C_D2
PCM20 = C_D2E
PCV74 PCV75 PCZ74 PCZ75 = C_T521D107M025ATE060
PCV76 PCV77 = C_EEFCX1E330R
PD4 PD502 = BAS40CW_SOT323-3
PD1202 = SX34F_SMAF2
PDB1 = BAT54CW_SOT323-3
PH01 PHV01 PHZ01 PHZ02 PHZ03 PHZ04 PHZ05 PR2-PR4 PR6 PR8 PR9 PR11 PR16 PR19 PR21-PR26 PR28 PR29 PR31-PR34 PR303-PR308 PR503-PR511 PR1103-PR1111 PR1809-PR1816 PR2501-PR2508 PR2510-PR2512 PRA3 PRB1 PRB6-PRB9 PRB16-PRB28 PRB30-PRB42 PRG01 PRG03 PRH3-PRH9 PRH12-PRH21 PRM5-PRM18 PRV2-PRV4 PRV6 PRV7 PRV9-PRV16 PRV18 PRV20 PRV22-PRV28 PRV30-PRV32 PRV34 PRV36 PRV37 PRV39 PRV40 PRV45 PRV50-PRV54 PRV59 PRV61 PRV66 PRV67 PRV69 PRV70 PRV72-PRV79 PRV81-PRV84 PRV88 PRV91 PRV95-PRV99 PRV101-PRV105 PRV112 PRV113 PRV117 PRV121 PRV123 PRV126 PRV134 PRV135 PRV138 PRV139 PRV149 PRV151 PRV156 PRV157 PRV160 PRV170-PRV172 PRV178 PRV179 PRV182 PRV183 PRV187 PRV193 PRV196-PRV223 PRV225-PRV227 PRW1-PRW4 PRW6-PRW33 PRW37 PRW39 PRW40 PRW42 PRW43 PRW47 PRW50-PRW53 PRW56 PRW58-PRW60 PRZ1-PRZ10 PRZ12-PRZ42 PRZ44 PRZ45 PRZ48-PRZ78 PRZ83-PRZ87 PRZ90 PRZ91 PRZ96-PRZ101 PRZ106-PRZ110 PRZ113 PRZ115 PRZ116 PRZ120-PRZ124 PRZ129-PRZ133 PRZ135 PRZ138 PRZ139 PRZ143-PRZ148 PRZ153-PRZ155 R174 R181 R182 R307 R325 R367 R369-R374 RC2 RC9 RC30 RC35 RC62 RC63 RC66 RC348 RC353-RC355 RC693 RD31 RD35 RD157-RD164 RD194-RD197 RD226-RD237 RE1-RE17 RE20 RE21 RE23 RE28 RE64 RE66 RE70 RE71 RE75 RE83-RE85 RE100 RE101 RE154-RE158 RE160-RE167 RE201 RE530 RE642 RE643 RE645 RE650-RE657 RE662 RE684 RE685 RE688 RE689 RE693 RE713 RE717 RE1615 RE1616 RF1-RF6 RG7 RG17-RG20 RG23 RG28 RG29 RG35 RG59 RG62 RG64 RG66-RG69 RG74-RG95 RG98-RG108 RG110-RG112 RG121-RG123 RG132-RG135 RG154-RG156 RG509-RG515 RG543 RG544 RG549 RG557 RG562 RG573-RG580 RG1410-RG1413 RG1446 RG1451 RG1476 RG1478-RG1494 RG1496-RG1502 RG1504 RG1510-RG1514 RG1516-RG1521 RG1537-RG1544 RG1555-RG1573 RG1575 RG1576 RG1579 RG1580 RG1583 RG1584 RG1595 RG1596 RG1600-RG1602 RG1604-RG1613 RH1 RH2 RH4-RH7 RH9 RH11 RH14-RH16 RH38 RH39 RH59 RH63 RH70-RH73 RH75 RH78 RH79 RH83-RH85 RH88-RH90 RH95 RH99 RH100 RH104 RH109 RH111 RH130 RH135 RH148-RH156 RH158 RH163-RH165 RH167 RH168 RH181 RH182 RH184-RH188 RH192 RH193 RH197 RH199 RH201 RH203 RH213-RH216 RH218 RH453 RH460-RH463 RH466 RH469 RH472 RH489 RH493-RH497 RH501 RH502 RH506 RH512 RH515-RH521 RH524 RH525 RH530 RH531 RH533 RH545 RH571 RH580 RH581 RH588-RH590 RH592-RH595 RH598-RH607 RH613 RH1016 RH1017 RH1019-RH1021 RH1035 RH1039 RH1040 RH1599 RH1600 RM5 RM6 RM17 RM18 RM20 RM21 RM25 RM27-RM29 RM38 RM41 RM42 RM61 RM91-RM94 RM96 RT5 RT19 RT25 RT52 RT53 RT88-RT90 RT97 RT108 RT109 RT112-RT117 RT132 RT693 RT728 RU4-RU6 RV9 RV12 RV18 RV27-RV30 RV33 RV34 RV500-RV503 RV618 RV619 RV638-RV643 RV645 RV646 RV648-RV653 RV655 RV664 RV665 RV673 RV674 RV679 RV681-RV686 RX1 RX2 RX4-RX8 RX39 = R_0402
PJP81 PJP302 PJP502 PJPH02 PJPH04 PJPM03 = JUMP_43X118
PJP301 PJP501 = JUMP_43X79-NPM
PJP503 PJPH01 PJPH03 PJPM01 = JUMP_43X39-NPM
PJPDC1 = OCTEK_WTB-12GCBWAB-U_12P
PL11 PL12 PL14 PL15 PLW11-PLW14 PLZ11 PLZ12 = 9A_Z80_1812_2P
PL13 = MURAT_BLM15AX601SN1D_2P
PL301 PLH01 = L_7X7X3_M_2P
PL311 PL511 PL1011 PL1811 PL6123 PLH11 PLM11 = 5A_Z80_0805_2P
PL501 PLV09 PLV10 = MAG_MMD-06CZ-1R5M-V1_2P
PL711 = L_5X5X3_M_2P
PL1001 PL1802 = CYNTE_PCMB042T-1R0MS_2P
PL6124 = MAG_SLA-05AHN2R2MX2L_2P
PLB1 = CYNTE_PCMB103T-3R3MS_2P
PLG01 PLV01 PLV02 PLV03 PLV04 PLV05 PLV06 PLV07 PLV08 PLW01 PLW02 PLZ01 PLZ02 PLZ03 PLZ04 PLZ05 PLZ06 = TAI-T_TMPA0624S-R15MNR8805D_4P
PLG02 = MAG_MMD-05BD-R68M-R1L_4P
PLH02 PLM01 = MAG_MLD-06CZH1R0M-N1L_2P
PQ1 = LMBT3904WT1G_SC70-3
PQ4 = FDV301N-G_SOT23-3
PQ5 PQB16 = 2N7002KW_SOT323-3
PQ6 PQM11 = L2N7002DW1T1G_SC88-6
PQB1 PQB11-PQB15 PQM02 = Q_N_DFN56-8-5
PQB2 = AONR36368_DFN3X3EP
PQB17 = LMUN5113T1G_SOT323-3
PQB18 = LTC015EUBFS8TL_UMT3F
PQH01 = AON7408L_DFN8-5
PQH02 = AON7506_DFN3X3-8-5
PQM01 = AON6380_DFN5X6-8-5
PQV1 PQW1 PQW2 = LBSS139DW1T1G_SOT363-6
PQV01 PQV02 = AOE6930_DFN5X6E8-10
PQV3 PQV4 = AONX38168_DFN5X6E-8-10
PR301 PR501 PR2509 PRA2 PRB4 PRG04 PRV89 PRV90 PRZ81 PRZ82 PRZ104 PRZ105 PRZ127 PRZ128 = R_1206
PR302 PR502 PR1102 PR1808 PRA1 PRB3 PRB5 PRB11-PRB15 PRG02 PRH1 PRH2 PRH11 PRM1-PRM4 PRV5 PRV93 PRV94 PRV106 PRV107 PRV110 PRV111 PRV130-PRV133 PRV152-PRV155 PRV174-PRV177 PRV224 PRW5 PRW34 PRW35 PRW44 PRW45 PRZ11 PRZ79 PRZ80 PRZ102 PRZ103 PRZ125 PRZ126 RE78 RE715 RE718-RE723 RT111 = R_0603
PR1101 PR1807 PRH10 PRV92 RH12 RT95 RT729 = R_0805
PRB2 PRB10 = R_1206_4P-D
PRV108 PRV109 = RL-3264-9W-R005-FNH_2512_2512
PU301 = SY8388BRHC_QFN16_2P5X2P5
PU501 = SY8270CTMC_QFN13_4X3
PU1101 PU1802 PUH2 = SY8386RHC_QFN16_2P5X2P5
PU2501 = RT9059GSP_SO8
PU2502 = RT9297GQW_WDFN10_3X3
PUA1 PUG01 PUZ2 PUZ3 PUZ5 PUZ6 PUZ8 PUZ9 = NCP302045MNTXG_PQFN33_5X5
PUB1 = ISL88739AHRZ-T_QFN32_4X4
PUH1 = TPS51212DSCR_SON10_3X3
PUM1 = RT8207PGQW_WQFN20_3X3
PUV1 = UP9512RQGJ_VQFN40_5X5
PUV3 = ISL95338HRTZ-T_TQFN32_4X4
PUV4-PUV11 PUW2 PUW3 = AOZ5332QI_QFN31_5X5
PUW1 = UP9529PQKF_WQFN20_3X3
PUZ1 = NCP81215DMNTXG_QFN52_6X6
PUZ4 PUZ7 PUZ10 = NCP81162MNR2G_QFN16_3X3
Q7-Q9 QH99 QH100 = DMN65D8LDW-7_SOT363-6
Q2407 Q2408 Q2411 QX2 QX3 = MMST3904-7-F_SOT323-3
QE1 QE3-QE5 QE13 QE21 QE22 QE66 QG500 QH5 QM2 QT2 = DMN66D0LDW-7_SOT363-6
QE2 QE58 QG516 QG525 QH98 QV2 QV3 = 2N7002W-T-R7_SOT323-3
QE8 QM1 QM3 = SI2301CDS-T1-GE3_SOT23-3
QG2-QG4 QG8 QG510 QG511 = MESS138W-G_SOT323-3
QG6 QG7 QG502 QG503 QG505 QG508 QG520-QG524 QV96 QV97 = 2N7002DW-7-F_SOT363-6
QV1 = SI3457CDV-T1-GE3_TSOP6
QX1 = LBSS138LT1G_SOT23-3
QX4 QX5 = MMBT3904WH_SOT323-3
R184 R185 = R0402_0OHM
R363 R364 R368 RD166-RD193 RD198-RD225 RD238-RD255 RE18 RE19 RE33 RE200 RE202 RE661 RE678-RE681 RE694 RE709 RE712 RE716 RE724 RG1-RG4 RG8 RG9 RG13 RG15 RG16 RG21 RG22 RG24-RG27 RG150 RG501 RG504 RG506 RG516 RG518 RG522-RG528 RG530 RG533 RG534 RG537 RG540 RG545 RG553 RG554 RG561 RG568 RG1495 RG1505-RG1509 RG1522-RG1534 RG1578 RG1581 RG1582 RG1585-RG1594 RG1615 RG1616 RH21 RH25-RH30 RH91 RH92 RH537 RH558 RH1022-RH1033 RH1601 RM1 RM2 RM14 RM23 RM26 RM62 RM64 RM66 RM70 RM72 RM75 RM76 RM79 RM81 RM82 RM84-RM87 RT1-RT4 RT6-RT18 RT20-RT23 RT26-RT51 RT59-RT73 RT75-RT80 RT83 RT86 RT94 RT98-RT102 RT107 RT124-RT131 RT200 RT694 RT695 RT720-RT725 RT727 RV1 RV15-RV17 RV671 RV672 RX3 RX9 RX31-RX38 = R_0201
RE90 RP2 RP3 RP5 RPC7 RPH5 = RP_0804_8P4R
RE647 RE648 = R_0402-NPM
SW1 = SW_TST71-N-220-T170-S017_2P
T2 T6 T10-T16 T18 T21 T22 T24 T25 T49 T50 T62-T65 T70 T114 T120-T122 T135 T144-T146 T194 T195 T197 TC13 TC20-TC26 = TPC12
U16 = AOZ1334DI-02_DFN8-7_3X3
U17 UG45 = TPS22966DPUR_SON14_2X3
U18 UE9 UX3 = SY6288C20AAC_SOT23-5
U19 U20 UG36 = AOZ1334DI-01_DFN8-7_3X3
U2407 = F75305M_MSOP10
UC1 = CFL-H_BGA_1440P-T
UC2 = 74AUP1G07GW_TSSOP5
UD1-UD8 = K4A8G165WB-BCPB_FBGA_96P
UE1 = STM32F070CBT6TR_LQFP48_7X7
UE2 = EN25F80-75HCP_SO8
UE5 = KB9542G-B_VFBGA_124P
UE8 = TLC59116FIRHBR_VQFN32_5X5
UE10 = KC3810NF-A0_QFN24_4X4
UE12 UT8 = SY6288D20AAC_SOT23-5
UG1 = N18E-G3-ES-A1_FCBGA_2228P
UG9 = GS7616SC-R_SOT363-6
UG10 UG22 UG26 UG29 UG40-UG42 UG47 UT3 UX1 UX2 = NL17SZ08DFT2G_SC70-5
UG11-UG18 = MT61K256M32JE-13-A_FBGA_180P
UG23 = BSS138DW_SC88-6
UG27 UG39 UG43 UG44 UG46 = 74LVC1G32GW_TSSOP5
UG34 = W25Q80EWSSIG_SO8
UG37 = NCP45491XMNTWG_QFN32_4X4
UH1 = CNP-H_BGA_874P-T
UH3 UM3 UM7 = TC7SH08FU_SSOP5
UH4 = W25Q128FVSIQ_SO8
UM4 = PI6CEQ20200LIEX_TSSOP20
UM8 = DS80PCI402SQNOPB_WQFN54_10X5P5
UT1 = ALPINE-RIDGE_BGA_337P
UT2 = W25Q80DVSSIG_SO8
UT4 = TPS65982_BGA_96P
UT5 UZ45 = AOZ1336_DFN8_2X2
UU5 = TC7SZ14FU_SSOP5
UV1 = AP2330W-7_SC59-3
UV3 = SN74CBT3257CPWR_TSSOP16
UV4 = G517AH1TP1U_TSOT23-6
UZ21 = AOZ1336DI_DFN8_2X2
YE1 YH2 = Y_X3G024000DC1H_4P
YG1 = Y_5YEA27000163IF50Q5_4P
YH1 = Y_CM31532768DZFT_2P
YT2 = Y_XRCGB25M000F2P18R0_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002DW-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
2N7002KW_SOT323-3
  oval 0.66x0.864 smd: 1(0,0) 2(0.65,1.85) 3(-0.65,1.85)
2N7002W-T-R7_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
5A_Z80_0805_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
9A_Z80_1812_2P
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74LVC1G32GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
