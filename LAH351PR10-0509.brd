# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XMP1-1: length 2.6
  TOP w0.081: PRM11.1 146.01,38.5 PCM1.1 ; PRM11.1 145.83,39.32 145.69,39.46 PQM11.2 ; PRM11.1 PRM8.1
XMP1-2: length 4.9
  TOP w0.081: PQM11.6 143.59,38.81 143.68,38.89 143.68,40.01 144.34,40.67 v2(144.34,41.73) 144.34,42.38 144.15,42.57 PRM17.2
XMP2: length 48.1
  TOP w0.081: v8(128.85,37.01) 129.24,37.01 130.37,38.14 133.43,38.14 133.8,37.77 133.8,36.9 134.9,35.79 142.8,35.79 143.48,36.48 v2(143.48,37.2) 143.48,37.7 142.99,38.19 141.94,38.19 PRM9.2
  TOP w0.089: UH1.BA33 108.2,28.67 v5(108.15,28.71)
  IN1 w0.058: v8(128.85,37.01) 128.14,36.3 122.17,36.3 121.01,35.13 118.75,35.13 117.43,36.44 117.27,36.44 117.26,36.45 117.24,36.45
  IN1 w0.089: 117.24,36.45 114.12,36.45 113.26,35.59 113.26,34.85 112.62,34.22 112.62,32.71 111.32,31.4 110.64,31.4 109.17,29.92 109.17,29.03 108.85,28.71 v5(108.15,28.71)
XMP2-1: length 3.3
  TOP w0.081: PQM11.5 143.07,39.46 142.81,39.72 142.81,40.12 142.57,40.36 PCM3.1 142.28,40.24 142.28,39.64 PRM12.1 142.39,38.7 PRM9.1
XMP2-2: length 3.1
  TOP w0.081: PRM16.2 144.91,40.19 144.99,40.11 PQM11.3
XTAL24_IN: length 13.6
  TOP w0.122: UH1.U10 97.62,40.56 v5(97.58,40.6)
  BOTTOM w0.081: 90.17,48.45 89.93,48.7 RH91.2
  BOTTOM w0.089: v5(97.58,40.6) 97.58,41.04 97.35,41.26 96.77,41.26 96.36,40.85 ; 90.17,48.45 91.03,47.6
  BOTTOM w0.122: 96.36,40.85 96.32,40.81 96.01,40.81 95.46,41.36 95.46,42.36 94.78,43.04 94.78,43.88 94.29,44.37 94.29,44.48 92.15,46.61 91.97,46.8 v2(91.81,46.8) 91.8,46.81 91.8,46.83 91.03,47.6
XTAL24_IN_R: length 2.8
  BOTTOM w0.081: RH91.1 88.98,49.28 RH72.1 CH47.1 87.77,50.13 YH2.1
XTAL24_OUT: length 12.1
  TOP w0.122: UH1.U9 96.89,40.69 v5(96.96,40.77)
  BOTTOM w0.081: RH92.2 89.83,48.11
  BOTTOM w0.089: 89.83,48.11 90.02,48.11
  BOTTOM w0.122: 90.02,48.11 v2(90.65,47.48) 91.69,46.43 92.03,46.43 94.07,44.39 94.07,44.28 94.56,43.79 94.56,42.95 95.25,42.27 95.25,41.27 95.92,40.6 96.72,40.6 96.89,40.77 v5(96.96,40.77)
XTAL24_OUT_R: length 5.2
  BOTTOM w0.081: 89.25,47.53 89.01,47.53 CH48.1 RH72.2 88.91,48.4 88.39,48.92 87.06,48.92 YH2.3
  BOTTOM w0.089: RH92.1 89.25,47.53
XTALIN: length 6.3
  BOTTOM w0.081: v4(58.25,86.65) 58.25,87.89 RG99.1 59.63,88.4 CG75.2 59.79,88.38 59.94,88.23 61.85,88.23 YG1.1
XTALOUT: length 6.2
  BOTTOM w0.081: v4(58.95,86.65) 58.63,86.65 58.55,86.73 58.55,87.27 RG99.2 59.63,87.49 CG76.2 60.05,87.91 61.66,87.91 61.79,87.78 61.79,86.96 61.67,86.85 YG1.3
XTALOUTBUFF_R: length 18
  TOP w0.081: v8(57.55,86.65) 57.55,86.65 57.86,86.34 59.16,86.34 59.59,85.91 59.59,84.23 v5(60.13,83.68) 60.64,83.17 RG1497.1
  BOTTOM w0.081: RG98.1 66.45,79.8 v2(64.54,79.8) 63.41,79.8 60.13,83.08 v5(60.13,83.68)
N16611725: length 1.7
  TOP w0.254: PRV101.1 PRV88.2 v4(51.74,30.89)
N16855291: length 2.7
  TOP w0.081: PQV1.5 69.79,17.49 70.03,17.25 70.03,17.07 69.8,16.84 PQV1.6 69.28,16.68 PRV50.2
N17123965: length 6.3
  TOP w0.203: PUV1.31 75.97,31.86 76.26,32.16 77.09,32.16 77.62,32.69 v2(77.9,32.69) 78.18,32.69 PRV36.1 79.17,34.57 PRV45.2 PCV12.2
N17123967: length 5.4
  TOP w0.203: PUV1.2 70.79,30.3 v5(70.43,30.66)
  BOTTOM w0.081: v5(70.43,30.66) 70.51,30.66 70.88,31.03 v2(71.41,31.03)
  BOTTOM w0.254: PRV72.1 70.26,30.84 v5(70.43,30.66) 71.36,29.73 PCV18.2
N17123991: length 5.5
  TOP w0.254: v3(68.19,32.35) PRV2.2
  GND4 w0.254: v3(68.19,32.35) v4(68.19,32.78)
  BOTTOM w0.081: v2(68.17,29.82) PRV72.2
  BOTTOM w0.254: v4(68.19,32.78) 67.78,32.78 67.34,32.34 67.34,31.09 67.59,30.84 PRV72.2
N17124033: length 3.4
  TOP w0.254: PCV10.2 PRV9.1 80.1,31.6 v4(81.22,31.6)
  BOTTOM w0.081: v2(82.44,31.57) 82.35,31.57 82.32,31.6 v4(81.22,31.6)
N17124270: length 4.7
  TOP w0.254: v1(80.72,33.63) 80.67,33.68 80.13,33.68 80.11,33.66 ; 80.11,33.66 PCV5.1 81.23,32.66 PRV24.1 ; 80.11,33.66 PRV36.2
  GND2 w0.254: v4(81.28,33.63) v1(80.72,33.63)
  BOTTOM w0.081: v2(82.27,34.36) 81.55,33.63 v4(81.28,33.63)
N17124417: length 2.5
  BOTTOM w0.081: PRV12.2 81.78,30.69 v2(82.25,30.22)
  BOTTOM w0.254: PRV32.1 80.07,30.57 81.1,30.57 PRV12.2
N17124541: length 1
  BOTTOM w0.081: PRV34.2 v2(81,35.52)
  vias: v1(80.07,35.54) v3(80.07,35.54) v4(80.07,35.54)
N17125752: length 2.6
  TOP w0.254: PRV6.1 67.82,33.17 67.44,32.79 v1(67.44,31.78)
  GND2 w0.254: v1(67.44,31.78) 67.45,31.77 v4(68.14,31.77)
N17956500: length 2.2
  TOP w0.081: UX3.3 106.42,147.47 107.36,147.47 v2(107.38,147.45) 107.47,147.36 107.47,146.78 RX9.1
N17957050: length 2.1
  TOP w0.081: UX3.4 103.69,147.55 102.87,147.55 ; RX3.2 102.87,146.75 102.87,147.55 ; 102.87,147.55 v2(102.86,147.56)
N18370426: length 5.5
  BOTTOM w0.081: 91.62,21.29 91.36,21.29 91.25,21.4 RT111.2 ; 91.62,21.29 UT5.4 ; 91.62,21.29 91.5,21.17 91.5,20.55 91.76,20.29 ; v2(91.48,18.63) 91.53,18.68 91.53,19.08 92.15,19.7 UT5.1 91.71,19.79 91.62,19.87 91.62,20.15 91.76,20.29 ; 91.76,20.29 UT5.2
N20112847: length 3
  BOTTOM w0.081: RT116.2 68.54,146.29 CT37.1 68.17,146.66 67.24,146.66 YT2.1
N20112857: length 1.7
  BOTTOM w0.081: RT117.2 68.54,147.18 CT38.1 67.87,147.14 YT2.3
N20124859: length 9
  TOP w0.081: v2(78.99,142.1) 79.12,141.97 v4(79.12,141.5)
  TOP w0.203: CT153.1 79.12,141.22 v4(79.12,141.5)
  GND2 w0.081: v12(85.22,143.41) v1(85.79,143.41)
  IN2 w0.058: v12(85.22,143.41) 85.17,143.36 81.41,143.36 79.55,141.5 v4(79.12,141.5)
  BOTTOM w0.081: UT1.R13 v4(79.12,141.5)
N20649294: length 22.5
  IN4 w0.058: v7(125.11,13.51) 125.26,13.36 131.27,13.36 133.5,15.6 133.5,25.58 133.83,25.91 134.49,25.91 v7(135.32,25.09)
  BOTTOM w0.081: v7(125.11,13.51) RE11.1
N20764785: length 4.9
  TOP w0.081: v2(89.4,49.69) 89.8,49.29 RH580.1
  TOP w0.381: RH580.1 90.2,48.54 92.27,46.48 92.27,46.26
N20764786: length 2.7
  TOP w0.203: v5(94.14,46.34) 94.31,46.18 94.31,45.76 93.99,45.44 UH1.G3
  BOTTOM w0.089: v2(94.91,46.01) 94.62,46.01 94.28,46.34 v5(94.14,46.34)
  BOTTOM w0.254: v5(94.14,46.34) 94.17,46.37 RH581.1
N20764806: length 2.3
  TOP w0.122: v5(111,28.22) 110.78,28 UH1.BB36
  BOTTOM w0.089: v2(110.21,28.48) 110.46,28.22 v5(111,28.22) RH89.2
N20816753: length 9.1
  GND2 w0.081: v1(146.26,84.3) v3(146.26,83.78)
  IN3 w0.058: v9(140.3,85.12) 141.97,83.44 145.92,83.44 v3(146.26,83.78)
  GND4 w0.081: v4(140.3,85.42) v9(140.3,85.12)
  BOTTOM w0.081: v2(138.95,85.73) 139.26,85.42 v4(140.3,85.42)
N20816775: length 5.6
  TOP w0.081: PRG01.2 v2(140.04,84.47)
  TOP w0.254: PUG01.3 144.26,83.84 144.08,83.66 141.05,83.66 PCG07.1 PRG01.2
N20816793: length 2.8
  TOP w0.254: PLG01.3 v5(145.28,93.71)
  BOTTOM w0.081: PRG03.1 145.67,94.35 v2(146.39,93.63)
  BOTTOM w0.254: v5(145.28,93.71) PRG03.1
N20816821: length 1.4
  TOP w0.254: PUA1.7 146.38,98.92 146.29,98.83 PCA4.2
N20816832: length 5.6
  IN1 w0.254: v11(142.72,98.22) 143.07,98.22 v8(144.38,99.53)
  GND2 w0.508: v4(142.72,98.24) v11(142.72,98.22)
  BOTTOM w0.254: v4(142.72,98.24) 142.68,98.2 v2(142.32,98.2) 141.92,98.2 PCA1.1 141.38,99.64 140.92,100.09 PRA3.2
N20905330: length 2.5
  TOP w0.081: v4(96.7,139.12) 96.7,139.55 RT22.1
  BOTTOM w0.081: UT4.A7 UT4.A8 ; UT4.A7 v4(96.7,139.12) ; UT4.A7 UT4.A6
N20905578: length 4.2
  GND2 w0.081: v1(100.41,142.97) v12(100.13,142.97)
  IN2 w0.058: v3(96.7,142.12) 98.15,142.12 99.12,143.09 99.82,143.09 99.95,142.97 v12(100.13,142.97)
  vias: v4(96.7,142.12)
N20905857: length 3.7
  IN4 w0.058: v7(93.69,141.12) 92.45,141.12 91.61,140.28 90.5,140.28 v4(90.4,140.38)
N20999302: length 1.5
  TOP w0.081: RM72.1 65.85,145.27 UM8.27
N20999314: length 1.6
  TOP w0.081: UM8.52 68.85,134.25 RM61.2
N20999316: length 1.9
  TOP w0.081: UM8.48 66.85,134.08 66.7,133.94 RM66.1 RM64.1
N21000707: length 3.7
  BOTTOM w0.081: UM4.1 87.02,34.44 86.98,34.48 RM21.2 ; RM21.2 v2(86,35.29) ; RM21.2 RM96.2
N21000709: length 1.8
  BOTTOM w0.089: RM29.1 RM28.1 CM99.1
N21000711: length 1.8
  BOTTOM w0.081: 90.32,24.62 CM98.1
  BOTTOM w0.089: RM38.1 RM27.1 90.32,24.62
N21000719: length 4.9
  BOTTOM w0.081: UM4.20 87.02,26.01 87.01,25.99 CM16.1 86.94,25.53 CM17.1 85.33,25.53 RM18.2 85.22,25.64 v2(85.22,26.75)
N21000750: length 2.1
  BOTTOM w0.081: UM4.18 88.32,26.43 87.89,26.01 RM25.2
N21000786: length 2.1
  BOTTOM w0.089: RM28.2 91.57,25.68 UM4.13
N21000788: length 2.2
  BOTTOM w0.089: RM27.2 90.61,25.61 90.61,25.94 90.92,26.24 UM4.14
N21000830: length 4.8
  TOP w0.081: QM2.6 47.51,143.73 QM1.2 48.9,142.36 RM92.2 47.73,141.98 v2(47.59,141.84)
N21000850: length 7.2
  TOP w0.081: QM2.3 44.13,145.25 43.69,144.81 43.12,144.81 QM3.2 42.17,142.7 42.67,142.19 RM94.2 42.67,141.4 v2(42.86,141.21)
N21000877: length 2
  BOTTOM w0.081: UM4.4 88.97,35.08 RM20.2
N21002214: length 2.6
  BOTTOM w0.081: UE2.3 135.32,17 RE14.2 134.21,16.86 v2(134.1,16.74)
N21002224: length 23.5
  IN4 w0.058: v7(125.07,12.88) 125.39,13.2 131.33,13.2 133.66,15.53 133.66,25.17 v7(134.05,25.56)
  BOTTOM w0.081: v7(125.07,12.88) 123.33,12.88 RE9.1 122.7,12.87 v2(122.43,12.6)
N21002246: length 2.6
  BOTTOM w0.081: RE13.2 135.92,27.05 v2(135.66,27.31)
  BOTTOM w0.254: RE13.2 136.59,26.99 UE2.7
N21002352: length 18
  IN3 w0.058: v9(123.8,13.51) 124.01,13.72 131.44,13.72 132.11,14.38 135.81,14.38 137.54,16.11 137.54,17.36 136.96,17.93 v9(136.59,17.93)
  GND4 w0.081: v9(123.8,13.51) v4(123.46,13.51) ; v9(136.59,17.93) v4(136.59,18.31)
N21002397: length 2.2
  BOTTOM w0.081: UE9.3 138.23,12.58 RE20.1 v2(138.19,11.47)
N21003330: length 2.9
  TOP w0.081: v2(58.05,63.03) R181.2 59.63,63.48 U2407.7
N21003701: length 141.3
  TOP w0.081: v5(12.76,30.58) 12.76,30.33 12.62,30.19 v2(12.62,30.11) ; v6(84.89,23.27) 85.28,22.88 DF1.1
  IN2 w0.058: v4(14.86,53.39) 14.48,53.01 14.48,49.43 13.63,48.58 13.63,38.86 13.27,38.5 13.27,31.61 12.76,31.1 v5(12.76,30.58) 10.16,27.98 10.16,23.14 9.83,22.81 9.83,16.21 10.54,15.5 10.54,13.36 12.06,11.84 12.06,8.6 14.99,5.68 28.84,5.68 32.79,9.63 40.56,9.63 v6(42.24,11.31)
  IN4 w0.058: 81.04,10.57 81.04,10.56 80.81,10.33 80.81,10.32 80.46,9.97 78.34,9.97 77.63,9.26 76.5,9.26 76.3,9.45 75.75,9.45 75.46,9.15 73.68,9.15 73.33,9.5 73.15,9.5 73.03,9.62 70.61,9.62 70.28,9.29 68.78,9.29 68.57,9.5 44.04,9.5 v6(42.24,11.31) ; v6(84.89,23.27) 84.89,20.58 85.22,20.25 85.22,16.75 84.26,15.79 84.26,15.28 84.2,15.23
  IN4 w0.076: 84.2,15.23 82.65,13.68 81.52,13.68 81.38,13.82 80.31,13.82 80.24,13.74 80.24,13.19 81.04,12.38 81.04,10.57
N21003743: length 90.5
  TOP w0.081: RF6.1 86.66,22.71 v8(86.72,22.66) ; RF6.1 87,22.94 DF2.1 ; RF6.1 86.66,24.11 86.7,24.15 86.7,24.34 86.75,24.4 v2(86.75,24.42)
  IN1 w0.058: v8(86.72,22.66) 86.72,18.85 87.44,18.13 87.44,17.49 88.65,16.28 90.68,16.28 91.2,16.81 97.65,16.81 97.9,16.56 102.32,16.56 102.72,16.16 107.4,16.16 107.86,16.62 113.28,16.62 113.93,15.97 124.78,15.97 125.33,16.52 133.54,16.52 136.27,19.25 136.27,26.09 138.99,28.81 138.99,29.72 v6(139.93,30.66)
  IN4 w0.058: v7(145.05,43.93) 144.49,43.37 143.36,43.37 138.92,38.94 138.92,32.4 139.88,31.45 139.88,30.71 v6(139.93,30.66)
N21223576: length 13
  TOP w0.076: UC1.BH31 131.92,106.86 v5(132.25,107.2)
  TOP w0.081: v8(137.79,110.56) 138.09,110.56 139.39,111.86 RH153.2
  IN1 w0.102: v5(132.25,107.2) 132.25,106.22 132.71,105.76 134.21,105.76 135.7,107.25 135.7,109.04 137.22,110.56 v8(137.79,110.56)
N21223582: length 3.5
  TOP w0.076: RH158.2 138.64,106.48 138.31,106.48 138.3,106.48 136.45,106.48 UC1.BR30
N21256667: length 2.6
  BOTTOM w0.081: UE8.24 103.04,16.16 RE166.2 102.87,15.62 103.05,15.45 v2(103.05,15.27)
N21256669: length 1.3
  BOTTOM w0.081: UE8.30 107.57,18.2 RE167.1
N22050858: length 6
  TOP w0.081: v2(65.2,100.14) 63.91,98.85 QG510.2 63.76,98.38 63.04,97.67 v8(63.04,97.28)
  IN1 w0.058: v8(63.04,97.28) 63.04,96.65 64.05,95.64 v8(64.05,95.59)
N22050873: length 1
  TOP w0.081: UG29.4 63.47,94.69 RG1.2
N22051434: length 7.5
  TOP w0.117: T15.1 62.73,98.31 62.12,97.7 61.7,97.7 61.4,97.4 RG26.1 61.23,97.51 57.91,97.51 57.73,97.68 57.73,98.37 UG1.BK23
N22051882: length 25.2
  TOP w0.081: v4(67.03,79.66) v2(67.43,79.66)
  IN1 w0.058: v1(55.45,88.05) 55.45,88.12 55.82,88.49 56.3,88.49 56.96,89.15 59.78,89.15 60.33,89.7 62.7,89.7 63.46,88.95 63.46,87.06 63.83,86.69 65.81,86.69 66.37,86.13 67.2,86.13 67.6,86.54 68.02,86.54 68.36,86.21 68.36,83.75 66.95,82.35 66.95,81.71 67.24,81.42 67.24,79.88 v4(67.03,79.66)
  BOTTOM w0.081: v4(67.03,79.66) 67.11,79.66 67.71,80.26 RG19.1
N22051884: length 17.5
  GND2 w0.081: v4(54.69,87.68) 54.75,87.75 v1(54.75,88.05)
  BOTTOM w0.081: RG20.1 67.56,79.28 63.67,79.28 59.08,83.87 57.45,83.87 v2(56.07,85.26) 54.69,86.64 v4(54.69,87.68)
N22053416: length 5
  TOP w0.081: T18.1 55.93,81.36 55.97,81.4 55.97,81.98 54.36,83.59 54.36,84.94 UG1.BE4
N22053437: length 4.8
  TOP w0.081: UG1.BE2 54.05,83.64 55.63,82.07 55.63,80.18 55.75,80.05 T21.1
N22055987: length 4.3
  BOTTOM w0.081: RG568.2 81.05,57.08 UG23.2 ; RG568.2 81.71,57.08 81.88,57.24 81.88,58.49 v2(81.79,58.57) ; RG568.2 RG533.2 81.1,56.08 UG23.3
N22091215: length 2
  TOP w0.122: UH1.AR32 107.64,32.06 107.64,32.33 v5(107.35,32.62)
  BOTTOM w0.089: T195.1 107.36,32.64 v5(107.35,32.62)
N22235239: length 4.8
  TOP w0.081: QV97.5 126.68,137.03 126.44,136.78 v2(124.85,136.78) 123.93,136.78 123.06,137.65 UX1.4
N22948336: length 2.9
  BOTTOM w0.081: v2(72.31,98.76) 71.48,99.6 RG509.2 71.2,99.34 QG503.6 QG503.5
N22948350: length 2.6
  TOP w0.081: RG511.2 8.52,3.35 QG520.5 QG520.6 v2(9.95,2.8)
N22948360: length 2.1
  TOP w0.081: v2(8.56,6.35) 7.67,6.35 RG512.2
  TOP w0.254: QG520.3 7.99,5.54 7.62,5.91 RG512.2
N22948364:
  vias: v2(1.78,17.01)
N22948383: length 1
  TOP w0.081: v2(4.38,19.43) 4.76,19.05 4.76,18.57
N22948619: length 3.1
  TOP w0.081: v2(67.03,85.44) 67.46,85.86 QG508.6 QG508.5 67.89,86.51 RG543.2
N22948623: length 2.6
  TOP w0.081: v2(71.71,88.58) 70.87,87.74 RG544.2 70.1,87.35 QG508.3
N23088914: length 1.7
  TOP w0.081: RG562.1 RG537.1 93.08,19.59 93,19.66 93,19.78 93.05,19.82 UG10.4
N23260607: length 5.3
  TOP w0.381: v5(95,109.2) 95,109.5 95.42,109.93 96.05,109.93 UC1.A36
  BOTTOM w0.081: v5(95,109.2) v2(95,109.68)
  BOTTOM w0.381: RH592.2 95,108.88 v5(95,109.2)
N23260608: length 4.7
  TOP w0.381: UC1.A37 96.07,110.84 95.97,110.94 95.42,110.94 94.49,110.01 94.49,109.44 93.27,108.22 RH593.2
N23261947: length 4.5
  TOP w0.089: UC1.BP13 135.94,93.24 137.16,93.24 137.41,93.49 137.41,94.07 137.74,94.4 138.37,94.4 T144.1
N23395517: length 5
  TOP w0.081: UG1.BD4 53.22,85.25 52.7,84.74 52.7,84.29 52.96,84.04 52.96,82.27 53.84,81.4 T22.1
N23396708: length 5
  TOP w0.081: T24.1 53.09,81.82 52.7,82.2 52.7,83.11 52.25,83.56 52.25,84.25 UG1.BB3
N23495582: length 1.7
  BOTTOM w0.203: CG7099.1 67.49,96.78 67.3,96.78 66.88,96.36 UG45.12
N23495606: length 1.6
  BOTTOM w0.203: UG45.10 66.08,96.5 66.81,97.23 CG7097.1
N23527376: length 2.7
  TOP w0.254: RG1517.2 5.58,6.82 RG1544.2 5.31,6.28 CD402.1 5.41,6.11 5.61,5.91 5.63,5.91 6.1,5.43 UG26.2
N23527433: length 15.6
  TOP w0.254: UG26.4 5.93,4.01 9.57,4.01 9.84,4.28 9.84,6.68 10.39,7.23 v2(10.39,8.24) 10.86,8.71 10.86,12.98 9.78,14.06 RG545.1
N23782168: length 2.3
  BOTTOM w0.081: RG506.2 78.87,60.56 QG521.4 78.01,60.54 DG4.2
N23782192: length 1.6
  BOTTOM w0.081: QG502.2 75.9,64.1 75.56,63.77 75.56,63.43 RG553.2
N23782194: length 2.6
  BOTTOM w0.081: UG22.4 79.5,62.94 RG554.1 79.96,61.98 v2(80.35,62.37)
N23782196: length 2.5
  BOTTOM w0.081: v2(81.03,61.2) 80.73,61.5 79.6,61.5 RG554.2 QG521.5
N23782217: length 5.3
  BOTTOM w0.081: v2(81.84,63.69) 81.79,63.69 81.45,64.04 UG22.2 78.56,64.04 QG502.6 77.98,62.59 RG516.2
N23865685: length 28
  TOP w0.254: RG1610.1 8.76,39.38 RG1601.2 7.96,39.39 v8(7.18,39.39) 7.18,39.02 CG7160.2 7.62,36.86 6.87,36.11 UG37.28 ; QG525.1 9.39,23.28 v8(9.16,23.51)
  IN1 w0.254: v8(7.18,39.39) 7.18,36.92 9.35,34.74 9.35,29.44 8.69,28.78 8.69,27.63 v3(8.8,27.51) 8.8,23.87 v8(9.16,23.51)
  IN3 w0.254: v3(8.8,27.51) 11.33,27.51 v3(12.06,28.25)
N23865687: length 5.1
  TOP w0.254: UG37.9 5.27,30.16 4.76,29.66 RG1543.2 4.75,29.16 4.09,29.16 4.08,29.17 RG1542.2 3.94,29.8 v2(3.58,30.15) 3.24,29.81 RG1539.1
N23865710: length 10
  TOP w0.081: CG7115.1 2.62,27.71 v2(1.96,27.05)
  TOP w0.254: RG1542.1 3.43,28.26 3.33,28.16 CG7115.1 2.55,28.22 2.55,28.98 v8(2.62,29.05)
  IN1 w0.254: v8(2.62,29.05) 2.86,29.29 2.86,33.46 3.11,33.71 v8(4.59,33.71)
N23865723: length 9.5
  TOP w0.254: UG37.6 v8(3.46,32.51) 3.24,32.29 CG7116.1 2.55,32.35 2.55,33.09 2.62,33.15 v14(2.62,33.17) 2.64,33.2 RG1576.2 ; RG1575.2 v8(4.76,28.26)
  IN1 w0.254: v8(3.46,32.51) 3.46,29.96 4.76,28.67 v8(4.76,28.26)
N24130479: length 2.1
  TOP w0.254: RG1575.1 5.59,29.66 6.07,30.14 UG37.11
N24130488: length 7.1
  GND2 w0.254: v1(1.73,34) v3(2.1,34)
  GND4 w0.254: v3(2.1,34) v6(2.1,33.49)
  IN4 w0.254: v6(2.1,33.49) 2.6,33.49 5.06,31.04 v6(7.26,31.04)
  vias: v1(7.27,31.04)
N24131017: length 2.2
  TOP w0.081: T25.1 51.95,81.47 UG1.BB1
N24138892: length 11.4
  TOP w0.254: RH7.1 122.43,22.38 122.17,22.63 119.51,22.63 117.47,24.67 117.47,26 117.13,26.34 UH1.BE49 116.44,26.34 UH1.BE48
  TOP w0.381: RH6.1 123.79,23.04 124.08,22.75 RH7.1
N24261593: length 1.5
  TOP w0.203: UE12.3 79.89,24.25 80.23,24.59 80.39,24.59 80.48,24.69 80.55,24.69 80.95,25.09 RE161.1
N24262217: length 2.2
  TOP w0.081: CV1071.1 RV679.2 40.26,144.1 v2(39.51,144.85)
N24324320: length 3.2
  BOTTOM w0.081: UV3.15 111.63,141.67 RX39.2 110.79,141.37 QV3.1
N24377091: length 1.4
  TOP w0.081: QV97.2 126.68,139.52 UX2.4
N24377100: length 2.1
  TOP w0.081: QX3.2 129.17,142.52 128.84,142.52 128.14,143.22 RX6.1
N24542080: length 2.6
  TOP w0.076: UE5.L2 82.17,11.78 82.42,11.53 82.42,10.57
  TOP w0.081: RE712.2 82.68,10.12 82.42,10.38 82.42,10.57
N24545351: length 1.9
  TOP w0.081: UE5.N6 83.69,13.86 84.2,14.38 84.2,14.51 84.24,14.55 84.24,14.62 84.52,14.9 RE694.2
N24548199: length 2.8
  TOP w0.076: 79.92,10.57 79.92,11.55 79.67,11.8 UE5.F2
  TOP w0.081: RE713.2 79.92,10.23 79.92,10.57
N24551989: length 10.2
  IN2 w0.058: v3(89.55,20.27) 88.7,19.42 88.7,17.83 89.04,17.49 91.38,17.49 92.01,16.85 v4(92.01,16.38)
  GND4 w0.081: v4(89.55,20.78) v3(89.55,20.27)
  BOTTOM w0.081: v2(89.47,21.67) 89.47,20.85 v4(89.55,20.78) ; UE10.3 91.76,16.12 v4(92.01,16.38)
N24660253: length 2.8
  TOP w0.081: v2(99.11,14.16) 99.11,15.86 99.73,16.49 99.92,16.49
N24660259: length 1.2
  TOP w0.081: U18.3 97.98,18.5 R367.1
N24698323: length 63.7
  TOP w0.203: v1(34.13,111.53) 33.82,111.22 31.24,111.22 31.11,111.09 31.11,91.15 31.37,90.9 40,90.9 UG1.AF11 v1(41.1,90.5) 41.18,90.58 v1(51.56,90.58) 51.56,98.96 51.85,99.25 v1(51.95,99.25)
  TOP w0.254: UG1.U42 v1(34.13,111.53)
  GND2 w0.203: v1(52.65,90.85) 52.65,90.76 52.9,90.52 v3(52.96,90.52) 53.02,90.52 53.35,90.84 v1(53.35,90.85) ; v3(51.63,99.41) 51.78,99.25 v1(51.95,99.25) ; v1(34.13,111.53) 34.13,111.5 v3(33.85,111.22)
  GND2 w0.254: v1(41.1,90.5) 40.86,90.5 v4(40.61,90.24)
  GND4 w0.203: v3(51.63,99.41) 51.4,99.63 v4(51.37,99.63) ; v4(34.25,111.22) v3(33.85,111.22)
  GND4 w0.381: v3(52.96,90.52) v4(53.78,90.52)
  BOTTOM w0.381: CG6501.1 53.91,87.89 CG907.1 CG896.1 v2(54.25,89.97) 54.25,90.05 v4(53.78,90.52)
  BOTTOM w0.508: LG8.2 51.96,87.5 CG911.1 52.84,87.34 CG6501.1
N24698546: length 14.1
  TOP w0.081: v8(66.6,84.48) v2(68.02,84.48) RG1496.1 RG1498.1
  IN1 w0.058: v8(56.85,86.65) 57.11,86.39 59.12,86.39 60.23,85.28 63.69,85.28 64.06,85.65 65.43,85.65 v8(66.6,84.48)
N24698588: length 1.9
  TOP w0.081: CG6825.1 70,83.64 RG1498.2 v2(69.93,82.77)
N24830768: length 2.7
  TOP w0.081: v10(91.14,79.83) C3.1 90.81,81.44 UZ21.6
N24874551: length 2.7
  TOP w0.127: UG13.J14 8.94,116.9 RG103.1
N24874553: length 4.4
  TOP w0.081: RG104.1 12.42,119.47 v2(12.47,119.42)
  TOP w0.127: UG13.K14 9.62,117.59 RG104.1
N24875363: length 3.1
  TOP w0.127: UG14.J14 9.62,122.78 10.82,121.59 RG575.1
N24875365: length 2.9
  TOP w0.127: RG576.1 8.27,121.59 8.88,122.2 UG14.K14
N24887788: length 3.6
  BOTTOM w0.081: CG718.1 2.93,78.07 2.84,78.16 v2(2.59,78.16)
  BOTTOM w0.254: CG722.1 3.42,76.67 CG727.1 3.45,77.35 CG718.1 CG726.1 CG723.1
N24904795: length 4
  TOP w0.081: v2(9.45,86.4) RG105.1
  TOP w0.127: UG15.J14 8.88,84.66 9.45,85.24 RG105.1
N24904797: length 4.1
  TOP w0.081: v2(10.86,86.27) 10.21,85.63 RG106.1
  TOP w0.127: RG106.1 10.21,85.23 9.62,84.64 UG15.K14
N24912644: length 20
  IN4 w0.058: v7(36.07,129.52) 35.88,129.71 35.88,139.39 36.34,139.85 v7(37.67,139.85)
  BOTTOM w0.081: v7(37.67,139.85) CG515.1 38.24,139.42 CG511.1 38.47,139.65 CG513.1 ; v7(36.07,129.52) CG514.1 v2(34.95,126.01) 34.46,125.52 CG512.1
N24912933: length 2.9
  TOP w0.127: UG11.J14 40.04,133.12 40.67,132.5 RG101.1
N24912966: length 5
  TOP w0.081: v2(42.13,128.77) RG102.1
  TOP w0.127: RG102.1 42.11,129.93 40.58,131.46 40.58,131.79 39.99,132.38 UG11.K14
N24913312: length 8.7
  TOP w0.127: RG573.1 47.86,124.33 46.86,125.33 46.86,131.86 UG12.J14
N24913316: length 9.4
  TOP w0.127: UG12.K14 46.58,132.33 46.58,124.81 47.06,124.33 RG574.1
N24913638: length 3.2
  TOP w0.081: RG111.1 61.84,123.7 QG2.1 v2(60.03,124.12)
N24913936: length 1.2
  BOTTOM w0.406: QG3.1 8.6,119.12 RG122.1
N24922475: length 1.3
  BOTTOM w0.406: QG4.1 9.73,84.43 RG133.1
N24922696: length 8.4
  TOP w0.117: UG16.J14 9.96,89.67 16.94,89.67
  TOP w0.127: 16.94,89.67 17.25,89.67 17.67,90.1 RG577.1
N24922697: length 5.2
  TOP w0.117: UG16.K14 8.88,89.66
  TOP w0.127: RG578.1 7.78,86.93 v10(7.99,87.14) 8.88,88.02 8.88,89.66
N24923465: length 1.3
  BOTTOM w0.406: QG8.1 43.97,68.87 RG156.1
N24924452: length 12.5
  TOP w0.127: RG107.1 40.51,77.63 42.39,75.76 v2(42.39,69.33) 42.94,68.78 UG17.J14
N24924454: length 10.9
  TOP w0.081: v2(43.05,76.79) 43.05,77.09 43.62,77.66 RG108.1
  TOP w0.127: UG17.K14 45.48,69.43 44.83,69.43 44.16,70.11 44.16,77.61 RG108.1
N24924464: length 9.4
  TOP w0.127: UG18.J14 40.05,70.4 40.05,75.4 37.82,77.63 RG579.1
N24924466: length 9.8
  TOP w0.127: UG18.K14 40.45,70.05 40.45,76.17 39.57,77.05 RG580.1
N24929376: length 2.7
  TOP w0.081: QG500.6 116.93,140.22 RG530.2 RG540.2 v2(116.88,141.63)
N24930799: length 4.2
  TOP w0.081: v2(65.27,76.23) RG1579.2 64.34,76.23 QX4.2 64.34,74.38 CG7141.1
N24930869: length 1.1
  TOP w0.081: RG1580.1 63.69,72.81 QX4.1
N24930890: length 2.1
  TOP w0.081: CG7142.1 60.94,75.03 QX5.2 60.72,75.25 RG1583.2
N24930951: length 2.3
  TOP w0.081: v2(59.64,72.57) 60.26,73.19 QX5.1 60.73,72.99 RG1584.1
N24932900: length 2.3
  TOP w0.081: QG516.1 85.37,27.9 RG1495.1 86.18,27.68 v2(86.55,27.31)
N24947235: length 4.1
  BOTTOM w0.081: v2(69.27,62.25) 69.27,62.19 70.14,61.32 UG44.4 70.42,62.04 70.69,62.31 71.35,62.31 71.64,62.6 RG1513.1
N24947359: length 3.2
  TOP w0.081: v2(1.85,9.93) 2.31,9.93 CG7159.1 2.9,9.35 2.9,8.64 RG1520.2 2.93,7.94 UG47.2
N24947407: length 2.2
  TOP w0.081: v10(1.56,5.64) 1.6,5.68 UG47.4 2.64,5.02 RG1521.1
N24947415: length 1.3
  BOTTOM w0.081: RG1519.2 69.16,90.15 UG42.1
N24947426: length 2.4
  BOTTOM w0.081: UG40.1 72.75,87.62 RG1518.2 73.61,87.95 v2(73.61,87.28)
N24947523: length 1
  BOTTOM w0.081: RG1510.1 70.98,90.32 UG40.4
N24947574: length 1.1
  BOTTOM w0.081: RG1511.1 75.68,92.13 UG41.4
N24947768: length 164.2
  TOP w0.081: v1(4.74,7.95) 4.76,7.95 5.3,8.49 RG1512.1
  GND2 w0.081: v3(4.95,7.69) 4.95,7.74 v1(4.74,7.95)
  IN2 w0.058: v6(87.83,40.67) 87.83,39.57 89.57,37.83 89.57,25.03 90.32,24.29
  IN2 w0.089: 90.32,24.29 v3(90.5,24.11)
  IN3 w0.058: 90.32,24.11 90.09,24.34 88.38,24.34 84.06,20.01 80.3,20.01 80.16,19.87 77.68,19.87 77.54,20.01 76.4,20.01 76.13,19.74 76.13,13.84 75.03,12.74 75.03,11.36 75.33,11.06 75.33,9.17 v9(75.07,8.91) ; v9(76.88,3.27) 76.65,3.5 70.11,3.5 69.99,3.38 65.23,3.38 64.66,2.81 49.88,2.81 48.45,4.24 46.33,4.24 44.95,5.61 44.45,5.95 44.3,6.05 43.57,6.35 42.79,6.5 40.28,6.5 38.81,5.03 31.79,5.03 30.93,4.17 25.39,4.17 25.1,4.46 22.26,4.46 20.51,2.7 15.4,2.7 14.88,3.23 11.2,3.23 10.66,3.78 9.55,3.78 8.03,5.3 8.03,6.44 7.71,6.76 5.7,6.76 5.44,7.03 5.44,7.2 v3(4.95,7.69)
  IN3 w0.089: 90.32,24.11 v3(90.5,24.11)
  GND4 w0.081: v9(76.88,3.27) 77.08,3.27 v4(77.13,3.32) ; v9(75.07,8.91) v4(74.85,8.69)
  IN4 w0.058: v7(81.51,54.79) 81.51,49.3 80.87,48.67 80.87,45.95 86.16,40.67 v6(87.83,40.67)
  BOTTOM w0.081: v4(77.13,3.32) 77.09,3.36 77.09,3.52 77.07,3.53 77.07,7.99 76.38,8.69 v4(74.85,8.69) ; UG43.4 74.3,59.63 RG1602.2 73.41,58.73 DG10.2 73.24,57.91 74.07,57.09 74.07,56.19 75.36,54.89 v2(79.07,54.89) 81.41,54.89 v7(81.51,54.79)
N25145265: length 5.7
  TOP w0.254: RV12.2 31.28,145.02 31.81,145.56 31.81,147.16 32.07,147.41 33.26,147.41 34.12,146.55 QV2.1
N25226064: length 5.9
  TOP w0.081: v2(77.19,151.3) 77.44,151.04 78.55,151.04 RT132.1 81.78,150.59 UT8.3
N25436710: length 2.5
  TOP w0.081: T194.1 94.5,108.45 UC1.A33
N25441457: length 2.4
  TOP w0.081: v2(142.11,90.12) 142.02,90.03 141.64,90.03 140.97,90.71 RD159.1
  TOP w0.508: RD159.1 140.17,90.78 CD291.2
N25463251: length 2
  TOP w0.081: RD229.1 141.02,88.17 v2(141.14,88.28)
  TOP w0.508: CD324.2 RD229.1
N25485982: length 7.8
  BOTTOM w0.081: DU8.2 86.8,7.27 85.53,7.27 85.34,7.46 UU5.2 ; DU8.2 87.63,7.08 CU27.1 ; DU8.2 88.41,8.1 RU5.2 v2(89.99,8.59)
N25487721: length 3.9
  TOP w0.081: v2(78.58,7.68) 78.36,7.9 RE85.1 78.03,8.26 77.91,8.26 77.65,8.51 QE2.2 76.98,8.51 76.85,8.64 CE51.1
N25523565: length 8.1
  TOP w0.081: v2(54.8,28.92) 54.58,28.92 v5(54.32,28.65)
  TOP w0.254: PRV225.1 54.15,27.87 54.15,28.49 v5(54.32,28.65)
  IN4 w0.254: v7(54.61,28.12) 54.57,28.12 54.32,28.37 v5(54.32,28.65) 53.76,29.21 52.97,29.21 52.5,29.68 v7(52.5,30.04)
  BOTTOM w0.254: v7(52.5,30.04) 52.67,29.87 53.57,29.87 53.89,30.19 PUV3.2 ; PRV83.1 v7(54.61,28.12)
N25523567: length 4.8
  TOP w0.254: PRV225.2 52.87,28.06 PRV84.1 52.86,28.26 53.28,28.68 v5(53.31,28.68)
  BOTTOM w0.203: PCV34.2 52.51,29.1 52.65,29.1 53.1,29.54 53.71,29.54 53.96,29.79 PUV3.1
  BOTTOM w0.254: v5(53.31,28.68) 53.29,28.7 52.88,28.7 PCV34.2
N25585283: length 8.6
  IN4 w0.058: v6(137.48,143.23) 137.67,143.42 137.67,148.49 136.68,149.48 v7(136.68,150.01)
  BOTTOM w0.081: v7(136.68,150.01) 136.68,149.94 137.5,149.11 v2(137.5,149.08)
N25585284: length 10.1
  IN4 w0.058: v7(136.68,151.28) 137.83,150.13 137.83,143.77 v6(138.37,143.23)
  BOTTOM w0.081: v2(137.78,150.66) 137.3,150.66 v7(136.68,151.28)
N25585535: length 2.1
  BOTTOM w0.081: UZ45.6 81.91,8.71 v2(82.05,8.85) 82.08,8.88 82.08,9.57 CZ121.1
N25774296: length 4.2
  TOP w0.254: PD4.3 17.59,9.7 17.59,12.02 PR11.2
N25774388: length 6.5
  TOP w0.081: v2(14.69,4.22) 15.25,4.77 PQ6.6
  TOP w0.254: PQ6.6 15.98,4.37 16.27,4.08 18.06,4.08 19.24,2.9 19.24,2.33 PR34.1
N25774390: length 2.7
  TOP w0.081: PR29.1 16.69,6.34 v2(16.93,6.58)
  TOP w0.254: PR29.1 16.68,5.62 ; 16.68,5.62 15.96,5.62 PR31.2 ; 16.68,5.62 16.68,4.97 16.63,4.93 PQ6.5
N25774400: length 3.2
  TOP w0.081: PR33.2 15.76,1.93 v2(14.8,2.9)
  TOP w0.254: PR33.2 PC15.2 16.63,1.94 PQ6.2
N25774403: length 3.1
  TOP w0.081: v2(19.32,1.3) 19.06,1.3 PR32.2
  TOP w0.254: PR32.2 18.33,1.93 PC15.1 17.28,2.19 PQ6.3
N25775574: length 0.9
  TOP w0.254: PCB19.1 PRB25.2
N25775600: length 0.9
  BOTTOM w0.203: PCB33.1 51.03,15.71 PRB22.1
N25775652: length 2.1
  BOTTOM w0.081: v2(39.07,13.97) 39.07,14.35 39.51,14.8 PRB18.1
  BOTTOM w0.254: PRB30.2 PRB18.1
N25775725: length 19.2
  TOP w0.254: PCB7.1 v5(39.18,18.58)
  IN3 w0.254: v5(40.18,23.21) 40.18,22.75 39.18,21.74 v5(39.18,18.58)
  BOTTOM w0.254: PRB15.2 41.16,23.64 41.05,23.74 v2(40.65,23.74) 40.61,23.74 40.18,23.32 v5(40.18,23.21)
N25775783: length 33.8
  IN4 w0.254: v5(18.03,20.86) 18.95,20.86 20.85,22.76 38.3,22.76 39.21,21.85 46,21.85 47.67,23.51 v7(47.67,23.99)
  BOTTOM w0.254: v5(18.03,20.86) 17.02,20.86 16.76,20.6 PRB10.2
N25775785: length 34.3
  IN4 w0.254: v7(46.71,23.99) 47.05,23.65 47.05,23.4 45.85,22.2 39.36,22.2 38.45,23.11 20.44,23.11 18.76,21.43 v5(17.99,21.43)
  BOTTOM w0.081: v7(46.71,23.99) 46.56,23.99 46.32,24.23 v2(45.66,24.23)
  BOTTOM w0.254: v5(17.99,21.43) 17.89,21.43 17.76,21.3 17.04,21.3 16.76,21.58 PRB10.3
N25775797: length 1.3
  TOP w0.081: PRB4.2 v2(41.02,11.51)
N25775817: length 8.4
  TOP w0.254: PQB18.1 21.14,7.49 v2(21.14,6.84) 22.09,5.9 25.48,5.9 25.61,6.03 25.7,6.03 26.13,6.46 26.61,6.46 26.65,6.43 PQB17.2
N25775832: length 28.3
  TOP w0.254: v5(44.89,23.65) 45.36,23.18 PQB16.1 ; v5(22.67,23.74) 22.7,23.71 22.7,23.72 22.81,23.72 24.6,21.92 v2(24.85,21.92) 27.86,21.92 v5(29.65,23.71)
  IN4 w0.254: v5(44.89,23.65) 44.89,23.46 44.16,22.73 39.72,22.73 38.89,23.56 29.81,23.56 v5(29.65,23.71)
  BOTTOM w0.254: v5(44.89,23.65) 44.89,23.25 PRB40.1 ; v5(29.65,23.71) 29.08,23.14 PQB14.4 ; v5(22.67,23.74) 22.92,23.49 PQB12.4
N25775833: length 27.2
  TOP w0.203: v5(44.32,23.65) 44.32,23.14 PQB16.3 43.24,22.05 PRB1.2
  TOP w0.254: PCB3.1 23.29,24.21 v5(23.29,24.2)
  IN4 w0.254: v5(23.29,24.2) 24.09,24.2 24.12,24.17 29.84,24.17 30.06,23.95 41.36,23.95 42.11,23.19 43.29,23.19 43.75,23.65 v5(44.32,23.65)
  BOTTOM w0.081: v5(44.32,23.65) 44.11,23.65 v2(43.7,24.06)
  BOTTOM w0.203: PRB41.1 44.32,23.54 v5(44.32,23.65)
N25775848: length 5.7
  TOP w0.081: PRB1.1 41.49,21.33 v2(41.92,20.89)
  TOP w0.203: PRB1.1 41.49,22.11 PRB32.2 42.24,23.01 42.24,24.04 42.53,24.34 43.34,24.34 43.51,24.16 PQB16.2
N25775859: length 8
  IN4 w0.254: v5(18.03,25.49) 24.22,25.49 v5(24.41,25.3)
  BOTTOM w0.081: v2(16.64,25.76) 17.23,25.76 17.5,25.49 v5(18.03,25.49)
N25775862:
  vias: v2(16.37,18.01)
N25777484: length 6.2
  BOTTOM w0.081: v2(44.87,10.65) 44.78,10.65 44.39,10.25 PR505.2
  BOTTOM w0.203: PR505.2 PR503.2 PR507.1 PC511.1 PR508.2 40.09,9.69 PD501.2
N25777547: length 2.3
  BOTTOM w0.081: v2(58.8,22.89) 59.42,23.51 PC313.2
  BOTTOM w0.254: PR303.1 PC313.2
N25777570:
  vias: v2(62.75,22.94)
N25777574: length 2.1
  TOP w0.081: PR506.1 50.77,22.32 50.1,21.64 v2(50.1,21.38)
  TOP w0.254: PC516.2 50.79,23.05 PR506.1
N25777686: length 6
  IN1 w0.254: v4(53.48,22.81) 52.66,21.99 v8(49.23,21.99)
  BOTTOM w0.081: v4(53.48,22.81) 53.13,23.15 v2(52.25,23.15)
N25780614: length 2.5
  TOP w0.081: v2(132.26,55.05) 132.71,55.05 133.32,55.67 PCH26.2
  TOP w0.254: PRH17.1 134.24,55.67 PCH26.2
N25781231: length 4.1
  TOP w0.081: v2(90.11,58.74) 89.89,58.96 PR2506.2
  TOP w0.254: PU2501.4 88.55,60.83 88.76,60.62 PC2507.1 89.91,59.74 PR2506.2
N25782005: length 0.8
  BOTTOM w0.254: PC1111.2 67.53,103.96 PR1107.1
N25782631: length 2.1
  TOP w0.081: v2(51.1,3.79) 51.12,3.77 PC1819.2
  TOP w0.254: PC1819.2 50.56,3.46 PR1812.1
N25783159: length 3.3
  TOP w0.081: v2(6.68,26.94) PRW23.2
  TOP w0.254: PQW1.6 5.37,26.64 5.64,26.91 PRW23.2 6.02,26.56 PQW1.5
N25783177: length 3.3
  TOP w0.081: v2(4.05,21.11) 4,21.11 3.44,21.67 PRW10.2
  TOP w0.254: PQW2.2 3.62,23.71 3.44,23.54 PCW3.1 PRW10.2
N25783179: length 1
  TOP w0.254: PQW2.3 4.27,23.19 PRW4.2
N25783181: length 3.5
  TOP w0.081: v2(1.96,25.62) 2.74,25.62 2.97,25.85 PQW2.6
  TOP w0.254: PQW2.6 2.95,25.96 PRW21.2 3.62,26.27 PQW2.5
N25783214: length 1.4
  TOP w0.254: PRW31.2 12.24,49.76 PCW13.1
N25783219: length 4.6
  TOP w0.081: PRW16.1 13.92,47.02 v2(14.26,47.02)
  TOP w0.254: PRW16.1 13.46,47.83 PRW56.2 12.52,48.59 PCW13.2 11.56,48.58 PCW10.2
N25783233: length 0.8
  TOP w0.254: PRW20.2 9.14,49.51 9.09,49.56 PCW11.1
N25783234: length 3.7
  TOP w0.254: PCW11.2 PRW19.2 6.59,48.67 PCW12.1 6.16,48.72 5.98,48.54 PRW7.1 PRW13.1
N25882913: length 1.5
  BOTTOM w0.081: RE160.2 99.19,13.04 99.19,12.25 99.44,12 QE13.6
N25882914: length 1.2
  BOTTOM w0.081: RE155.2 99.33,15.76 QE21.6
N25882915: length 1.2
  BOTTOM w0.081: RE157.2 99.39,19.25 QE22.6
N25890186: length 43.9
  TOP w0.089: v6(115.82,41.2) 115.61,40.99 UH1.T47
  IN4 w0.058: 110.24,22.69 108.66,21.11 106.15,21.11 105,19.97 v7(105,19.31) ; 117.24,23.32 120.24,23.32 122.83,25.91 122.83,33.35 117.24,38.94
  IN4 w0.089: 110.24,22.69 114.1,22.69 114.73,23.32 117.24,23.32 ; 117.24,38.94 117.03,39.16 117.03,39.99 v6(115.82,41.2)
  BOTTOM w0.081: v7(105,19.31) 104.64,19.67 v2(103.94,19.67) 103.78,19.67 102.82,20.64 102.82,21.48 102.74,21.56 RT694.2
N25926180: length 2.6
  TOP w0.081: RV655.2 134.25,145.23 JHDMI.13
N26140980: length 7.5
  TOP w0.089: RH1021.2 90.67,42.54 v2(90.37,42.84)
  TOP w0.254: v8(91.19,41.35) 90.94,41.6 RH1021.2 ; UH1.R6 95.5,41.43 v8(95.25,41.68)
  IN1 w0.254: v8(95.25,41.68) 94.23,41.68 93.22,40.67 91.87,40.67 v8(91.19,41.35)
N26223082: length 1.4
  BOTTOM w0.203: PD502.1 41.78,7.74 41.78,7.95 PR508.1
N26229867: length 2.9
  TOP w0.254: UH1.AF19 101.76,36.03 v5(102.13,36.39) 102.48,36.04 UH1.AF20
  BOTTOM w0.089: RH598.1 v2(100.37,36.32)
  BOTTOM w0.381: v5(102.13,36.39) 101.51,36.39 RH598.1
N26231028: length 4.6
  TOP w0.254: UH1.BG5 94.95,25.38 94.95,25.05
  TOP w0.381: T146.1 96.39,22.76 96.15,22.76 95.74,22.35 CH36.1 95.41,24.58 94.95,25.05
N26232649: length 2.2
  TOP w0.203: UH1.AK22 103.27,33.7 v5(103.63,34.06) 103.99,33.7 UH1.AK23
  TOP w0.254: UH1.AJ23 103.67,34.83 v5(103.59,34.83) 103.25,34.49 UH1.AJ22
N26327146: length 20
  TOP w0.076: v8(78.11,14.12) 78.12,14.11 78.91,14.11 UE5.E7
  TOP w0.081: v8(76.42,13.16) 76.22,12.96 76.19,12.96 76.14,12.91 76.13,12.91 T197.1
  IN1 w0.058: v11(74.23,12.77) 74.27,12.8 75.16,12.8 75.3,12.66 75.92,12.66 v8(76.42,13.16) 76.58,13.16
  IN1 w0.076: 76.58,13.16 76.72,13.3 77.46,13.3 78.11,13.95 v8(78.11,14.12)
  GND2 w0.081: v11(74.23,12.77) 74.16,12.77 v3(73.82,12.42)
  IN3 w0.058: v9(69.6,17.07) 69.6,14.99 70.51,14.07 70.51,13.12 70.59,13.04 70.59,10.12 71.04,9.66 72.67,9.66 73,10 73,11.28 73.79,12.07 73.79,12.32 73.77,12.33 73.77,12.44 73.79,12.44 73.79,12.42 v3(73.82,12.42)
N26383140: length 2.2
  BOTTOM w0.081: UV4.4 28.69,146.61 RV684.2 v2(27.74,146.66)
N26383142: length 1.6
  BOTTOM w0.081: UV4.5 29.65,145.44 29.65,145.74 30.02,146.1 RV685.1
N26383331: length 2.8
  BOTTOM w0.081: v2(27.44,142.73) RV683.1
  BOTTOM w0.254: RV683.1 28.43,141.73 28.68,141.99 28.68,142.42 UV4.3
N26440602: length 2.9
  TOP w0.081: v5(85.7,138.51) 85.71,138.52 ; 85.71,138.52 RT724.2 ; 85.71,138.52 85.71,138.89 85.78,138.95 v2(85.78,139.09)
  BOTTOM w0.081: UT1.Y1 85.39,138.82 v5(85.7,138.51)
N26440604: length 3.1
  TOP w0.081: v5(85.85,137.76) 85.97,137.76 86.09,137.89 RT725.2
  BOTTOM w0.081: UT1.Y2 84.09,138.82 84.33,138.58 84.95,138.58 85.78,137.76 v5(85.85,137.76)
N26793914: length 98.8
  TOP w0.203: v5(139.51,125.25) 139.71,125.45 PUZ1.26
  IN1 w0.254: v6(140.78,87.78) 140.78,86.66 142.43,85.01 146.66,85.01 148.69,82.98 148.69,77.73 145.07,74.11 145.07,66.8 143.76,65.49 143.76,63.17 143.95,62.98 143.95,57.39 143.36,56.8 143.36,50.65 144.73,49.28 144.73,45.51 146.27,43.97 148.53,43.97 148.84,43.65 148.84,42.33 148.59,42.08 v8(148.48,42.08)
  GND2 w0.254: v6(140.78,87.78) v3(141.11,87.78)
  GND4 w0.254: v6(140.78,87.78) v3(141.11,87.78)
  IN4 w0.254: v6(140.78,87.78) 140.77,87.8 140.77,105.51 141.33,106.08 141.33,117.5 139.17,119.67 139.17,123.75 139.84,124.43 139.84,124.92 v5(139.51,125.25)
  BOTTOM w0.081: v5(139.51,125.25) v2(139.51,125.94)
N26990754: length 5.2
  TOP w0.254: PUW2.3 4.79,60.71 4.64,60.85 4.63,60.85 v4(4.41,61.08) 4.41,61.09 3.78,61.71 PRW37.2
  BOTTOM w0.254: PCW16.1 5.07,59.02 v2(5.07,60.92) 4.91,61.08 v4(4.41,61.08)
N26991157: length 6.7
  TOP w0.081: v2(11.32,41.56) 11.61,41.26 12,41.26 PRW47.2
  TOP w0.254: PUW3.3 v3(17.06,39.82)
  IN3 w0.254: v3(17.06,39.82) 12.42,39.82 12.4,39.8 v3(12.34,39.8)
N26991610: length 1.6
  TOP w0.081: PRW34.2 1.51,61.5 v2(1.51,61.92)
N27100126: length 33.5
  TOP w0.152: PHZ01.2 v5(146.25,110.39)
  TOP w0.254: v5(147.27,136.3) 147.27,135.16 PRZ49.1
  IN4 w0.152: v5(147.27,136.3) 147.4,136.17 147.4,135.16 148.21,134.34 148.21,133.59 148.39,133.41 148.39,127.48 149.58,126.29 149.58,122.07 144.34,116.83 144.34,110.9 144.84,110.39 v5(146.25,110.39)
  BOTTOM w0.081: v5(146.25,110.39) v2(145.77,110.39)
N27100217: length 26.7
  TOP w0.152: v5(142.24,97.31) 142.38,97.17 PHZ02.2
  TOP w0.203: PRZ64.1 142.51,120.11 PRZ44.2
  TOP w0.254: PRZ44.2 142.56,119.74 v5(142.35,119.53)
  IN2 w0.152: v5(142.35,119.53) 142.35,118.51 143.07,117.8 143.07,102.71 143.38,102.39 143.38,100.38 141.86,98.86 141.86,97.69 v5(142.24,97.31)
  BOTTOM w0.081: v5(142.35,119.53) v2(142.35,118.72)
N27100816: length 75.9
  TOP w0.081: v2(80.75,125.71) 81.53,124.92 PHZ05.2
  TOP w0.203: v5(82.98,124.92) PHZ05.2
  IN1 w0.152: v5(82.98,124.92) 83.62,125.55 83.62,127.89 83.52,127.99 83.52,132.23 87.38,136.1 89.02,136.1 90.2,137.29 92.27,137.29 93.01,138.03 97.44,138.03 98.28,138.86 109.81,138.86 110.39,138.29 136.42,138.29 136.84,137.87 142.16,137.87 142.77,137.26 142.77,136.08 v4(142.05,135.36)
  BOTTOM w0.203: v4(142.05,135.36) PRZ54.1
N27278094: length 1.4
  BOTTOM w0.081: UV3.9 111.68,137.77 RV671.1
N27278095: length 1.5
  BOTTOM w0.081: UV3.12 111.84,139.72 RV672.1
N27425503:
  vias: v2(11.58,65.48)
N27662445: length 2
  TOP w0.254: PRW42.2 4.34,61.98 4.34,61.67 4.81,61.21 PUW2.2
N27693415: length 0.6
  BOTTOM w0.081: v2(92.72,133.76) 92.72,133.23 v5(92.72,133.11)
  vias: v5(92.71,132.54)
N27693535: length 0.9
  BOTTOM w0.081: v5(101.35,132.58) 100.85,132.08 v2(100.85,131.84)
  vias: v5(101.35,133.15)
N27693577: length 0.8
  BOTTOM w0.081: v5(109.67,132.58) v2(109.67,131.8)
  vias: v5(109.67,133.15)
N27693645: length 2.7
  TOP w0.254: PUW2.17 5.65,62.99 5.3,63.35 v2(5.09,63.35) 3.8,63.35 PRW43.2
N27693887: length 4.6
  TOP w0.254: PRZ121.1 129.67,135.49 PRZ123.2 131.34,134.41 PUZ7.12
  BOTTOM w0.081: v4(129.79,135.59) v2(128.73,135.59)
N27694207: length 6.9
  TOP w0.254: PUZ7.10 132.81,134.68 132.46,135.03 132.04,135.03 131.56,135.51 PRZ124.1 132.18,136.22 133.64,136.22 PCZ90.2
  BOTTOM w0.081: v2(134.71,136.64) 134.29,136.22 v4(134.29,135.59)
N27694554: length 3.1
  TOP w0.254: PUZ8.7 128.04,131.39 128.54,131.89 v5(128.54,131.92)
  BOTTOM w0.081: v5(128.54,131.92) 128.09,131.92 v2(127.67,132.34)
  BOTTOM w0.254: v5(128.54,131.92) 128.57,131.92 129.01,132.36 PCZ122.2
N27694593: length 1.5
  TOP w0.081: v2(130.24,122.96) 130.11,122.83 130.11,121.62 130.21,121.52
N27694977: length 4.8
  TOP w0.254: PUZ10.12 134.76,124.86 134.11,125.5 v2(133.68,125.5) v5(133.11,125.5) PRZ147.2 PRZ145.1
  BOTTOM w0.254: v5(133.11,125.5) 132.35,125.5 PCZ120.1
N27695609: length 4.9
  TOP w0.254: PUZ10.10 135.76,125.27 v2(135.34,125.69) 134.86,126.16 PRZ146.1 PRZ144.1 v5(134.12,127.54)
  BOTTOM w0.254: PRZ144.1 v5(134.12,127.54)
N27696433: length 5.5
  TOP w0.254: PUZ4.12 95.55,135.55 95.3,135.29 95.3,134.98 94.96,134.64 v1(93.98,134.64) 93.09,134.64 PCZ57.1
  GND2 w0.508: v3(93.81,135.02) 93.98,134.85 v1(93.98,134.64)
  GND4 w0.508: v4(93.28,135.02) v3(93.81,135.02)
  BOTTOM w0.081: v4(93.28,135.02) 93.42,135.16 v2(94.25,135.16)
N27696489: length 5.3
  TOP w0.254: v4(91.36,134.97) 91.43,134.97 v2(91.89,135.43) 93.03,136.57 PCZ58.2 v8(93.98,136.62) 95,136.62 95.06,136.55 PUZ4.10
N27712207: length 3.8
  BOTTOM w0.081: v2(18.24,55.15) PCW42.1
  BOTTOM w0.254: PCW42.1 17.45,55.39 PCW41.1 PRW58.2
N27712576: length 4.8
  BOTTOM w0.081: v2(24.03,51.46) PCW44.1
  BOTTOM w0.254: PCW44.1 22.61,51.02 PRW59.2 21.36,51.62 21.84,52.1 PCW43.1
N28556236: length 1.4
  TOP w0.081: RD186.2 RD185.2 142.61,65.95 C2527.2
N28556759: length 1.3
  BOTTOM w0.081: RD225.2 RD201.2 93.83,64.08 93.98,64.23 C2528.2
N28600394: length 7.8
  TOP w0.203: PUZ1.16 139.68,129.45 v5(139.32,129.82)
  BOTTOM w0.254: v5(139.32,129.82) 139.32,129.9 138.94,130.28 138.32,130.28 137.92,129.89 PCZ40.1 v2(136.94,128.4) 136.72,128.17 PRZ3.2
N28600396: length 16.9
  TOP w0.203: PUZ1.15 139.9,129.85 139.17,130.58 139.17,130.74 v5(138.99,130.91) 138.94,130.96 138.19,130.96 PCZ30.2
  IN3 w0.254: v5(138.99,130.91) 138.99,130.99 138.57,131.41 138.57,131.92 136.07,134.42 128.84,134.42 v3(127.95,135.31)
  BOTTOM w0.081: v5(138.99,130.91) v2(138.32,130.91)
N28600408: length 4.4
  TOP w0.203: PUZ1.36 144.52,123.92 144.84,123.6 v5(144.84,123.54) 144.86,123.54 PRZ68.1
  BOTTOM w0.081: v5(144.84,123.54) 144.84,124.44 v2(145.06,124.65)
  BOTTOM w0.254: PCZ23.1 145.29,123.09 v5(144.84,123.54)
N28600440: length 2.8
  TOP w0.203: PCZ36.1 v5(143.38,121.31)
  BOTTOM w0.081: v2(143.73,119.43) 143.18,119.98 PRZ71.2
  BOTTOM w0.254: PRZ71.2 143.18,121.11 v5(143.38,121.31)
N28600447: length 3.8
  TOP w0.203: v5(145.29,131.92) 145.29,131.85 144.92,131.49 PUZ1.3
  BOTTOM w0.081: v5(145.29,131.92) v2(145.85,131.36)
  BOTTOM w0.254: PCZ19.1 PRZ66.2 144.78,131.23 145.29,131.74 v5(145.29,131.92)
N28600456: length 1.9
  TOP w0.203: PRZ20.1 147.85,126.56 146.88,126.56 146.78,126.65 PUZ1.43
N28600519: length 1.6
  GND4 w0.203: v3(144.15,133.58) 144.5,133.58 v4(144.51,133.57)
  BOTTOM w0.081: v2(143.94,134.51) 143.94,134.14 v4(144.51,133.57)
N28600523: length 4.7
  TOP w0.254: PRZ25.2 150.62,132.68 v5(150,133.3) 149.35,133.3 PCZ33.1 PCZ25.1
  BOTTOM w0.081: v5(150,133.3) 150.18,133.3 v2(150.71,133.84)
  BOTTOM w0.254: PRZ52.1 149.82,133.12 v5(150,133.3)
N28600544: length 3.2
  TOP w0.081: PRZ53.1 151.05,129.36 151.59,128.83 v2(151.59,128.76)
  TOP w0.254: PCZ38.2 149,129.67 149.33,129.34 150.09,129.34 150.11,129.36 PRZ53.1
N28600564: length 4.2
  TOP w0.081: PCZ29.2 v2(148.67,121.94)
  TOP w0.203: PCZ29.2 PCZ32.2 v5(146.49,121.31) PRZ22.1
  BOTTOM w0.254: v5(146.49,121.31) 146.43,121.38 PRZ51.2
N28600574: length 4.9
  TOP w0.254: PRZ27.1 149.12,130.5 v1(149.76,129.86)
  GND2 w0.254: v3(150.3,130.22) 150.11,130.22 v1(149.76,129.86)
  GND4 w0.254: v4(150.29,129.82) 150.29,130.2 v3(150.3,130.22)
  BOTTOM w0.081: v2(150.66,130.8) 150.29,130.43 v4(150.29,129.82)
  BOTTOM w0.254: v4(150.29,129.82) 149.72,130.39 PCZ31.1
N28600606: length 2.6
  TOP w0.081: v2(143.98,119.66) 144.48,120.16 PCZ22.1
  TOP w0.203: PRZ9.2 144.65,121.34 144.48,121.16 PCZ22.1
N28600607: length 1
  TOP w0.254: PCZ20.1 143.48,135.83 PRZ8.2
N28600611: length 73.3
  TOP w0.081: v2(80.87,124.11) 81.71,123.27 PHZ04.1
  TOP w0.203: v5(82.98,123.27) PHZ04.1
  TOP w0.254: PRZ23.2 136.88,131.4 PRZ75.1 135.2,131.4 v5(135.1,131.5)
  IN2 w0.254: v5(82.98,123.27) 82.98,123.29 82.32,123.95 82.32,130.11 84.18,131.97 85.47,131.97 85.72,132.22 85.72,133.23 86.79,134.29 94.23,134.29 94.41,134.47 97.38,134.47 99.11,136.2 135.67,136.2 136.14,135.73 136.14,132.54 v5(135.1,131.5)
N28600613: length 47.4
  TOP w0.203: PRZ21.2 139.27,123.75 v5(139.27,124.55)
  TOP w0.254: PHZ03.1 v5(148.64,90.25)
  IN3 w0.254: v5(148.64,90.25) 146.89,90.25 145.97,91.16 141.2,91.16 v5(139.6,92.76)
  IN4 w0.254: v5(139.27,124.55) 139.2,124.55 138.81,124.16 138.81,119.1 140.72,117.2 140.72,114.87 140.18,114.33 140.18,110.04 139.81,109.67 139.81,101.56 139.32,101.07 139.32,97.46 140.21,96.57 140.21,93.37 v5(139.6,92.76)
  BOTTOM w0.081: v5(139.27,124.55) v2(138.52,124.55)
  BOTTOM w0.203: v5(139.27,124.55) 139.83,124.55 PRZ74.1
N28600615: length 5
  TOP w0.081: PRZ24.2 151.1,130.99 v2(151.57,131.46)
  TOP w0.254: PRZ148.1 149.02,131.26 149.35,131.59 v5(149.64,131.59) 150.03,131.59 PRZ24.2 150.41,130.77 PCZ26.1
  BOTTOM w0.254: v5(149.64,131.59) 149.35,131.59 PCZ28.1
N28600645: length 3.9
  TOP w0.203: PUZ1.27 140.92,124.5 140.72,124.3 140.35,124.3 139.99,123.94 v2(139.99,123.78) 139.89,123.78 139.64,123.52 139.64,122.21 PRZ37.2
N28888311:
  vias: v2(85.12,133.49) v5(85.24,133) v5(85.23,132.43)
N28888326: length 3.3
  TOP w0.254: PUZ3.3 87.24,132.81 PRZ84.2 v5(87.05,133.62)
  BOTTOM w0.081: v5(87.05,133.62) 86.92,133.62 v2(86.58,133.96)
  BOTTOM w0.254: v5(87.05,133.62) 87.06,133.61 PCZ61.1
N28888419: length 3.3
  TOP w0.254: PUZ2.3 94.72,132.82 PRZ83.2 94.53,133.11 v5(94.53,133.73)
  BOTTOM w0.081: v5(94.53,133.73) 94.22,133.73 94.07,133.89 v2(94.01,133.89)
  BOTTOM w0.254: v5(94.53,133.73) 94.55,133.71 PCZ62.1
N28891269: length 3.9
  TOP w0.254: v8(99.02,136.05) 100.51,136.05 ; 100.56,136.1 PRZ90.2
  TOP w0.508: 100.51,136.05 100.56,136.1 v1(100.58,136.1)
  GND2 w0.508: v1(100.58,136.1) 100.53,136.04 v4(100.53,135.38)
  BOTTOM w0.081: v4(100.53,135.38) 99.94,135.38 99.3,136.02 v2(99.21,136.02)
N28891277: length 1.4
  BOTTOM w0.081: v2(99.2,134.66) v5(99.68,134.66)
  BOTTOM w0.254: v5(99.68,134.66) 99.89,134.46 PRZ85.1
N28891279: length 3.8
  TOP w0.081: PRZ97.2 100.71,137.86 101.39,138.54 v2(101.74,138.54)
  TOP w0.254: PRZ97.2 100.7,137.85 PUZ4.5
N28891309: length 3.1
  TOP w0.254: v4(99.8,137.14) 99.71,137.05 PUZ4.4
  BOTTOM w0.381: v4(99.8,137.14) v2(100.41,137.14) 100.86,137.14 101.42,136.58 PRZ96.2
N28898532: length 3.5
  TOP w0.254: PUZ6.3 103.35,132.88 PRZ107.2 103.17,133.19 103.16,133.2 v5(103.16,133.77)
  BOTTOM w0.081: v2(102.36,133.91) 103.02,133.91 v5(103.16,133.77)
  BOTTOM w0.254: PCZ97.1 103.19,133.75 v5(103.16,133.77)
N28898587: length 5.1
  TOP w0.254: PUZ5.3 111.67,132.95 PRZ106.2 111.49,133.19 111.48,133.2 v5(111.48,133.77)
  BOTTOM w0.081: v2(110.34,133.77) v5(111.48,133.77) 111.76,133.49 111.76,132.5 PCZ94.1
N28898659: length 3.3
  TOP w0.254: PUZ7.2 v5(132.31,129.94) 132.31,129.81 PRZ116.2
  BOTTOM w0.081: v2(132.58,130.67) 132.31,130.41 v5(132.31,129.94)
  BOTTOM w0.254: PRZ113.2 132.31,129.68 v5(132.31,129.94)
N28898663: length 1.9
  BOTTOM w0.081: v5(130.99,130.43) 130.99,131 v2(131.04,131.05)
  BOTTOM w0.254: v5(130.99,130.43) 130.81,130.25 PRZ108.1
N28898664: length 2.5
  TOP w0.254: PUZ7.5 134.23,131.51 134.23,131.15 v5(134.04,130.95)
  BOTTOM w0.254: PRZ120.2 v2(133.96,130.34) 133.96,130.88 v5(134.04,130.95)
N28898679: length 2.8
  TOP w0.081: v2(134.91,129.31) PRZ115.2
  TOP w0.254: PRZ115.2 133.82,129.43 133.82,130.06 133.31,130.57 PUZ7.4
N28905293: length 3.4
  TOP w0.254: PCZ125.1 128.84,129.39 v5(128.5,129.39) PUZ8.3
  BOTTOM w0.081: v5(128.5,129.39) 128.08,129.39 v2(127.81,129.12)
  BOTTOM w0.254: v5(128.5,129.39) 128.98,129.39 PRZ129.2
N28905329: length 5
  TOP w0.081: PRZ130.2 131.29,116.66 v2(131,116.37)
  TOP w0.203: PUZ9.3 130.18,119.29 130.39,119.08 131.15,119.08 PCZ123.1 131.65,117.73 PRZ130.2
N28905381: length 2.4
  TOP w0.254: PUZ10.2 135.26,120.81 134.81,120.36 PRZ135.2 PRZ138.2
N28905385: length 1
  TOP w0.081: PCZ127.1 v2(132.21,123.5)
N28905386: length 1.5
  TOP w0.254: PRZ143.2 137.69,121.83 137.38,122.15 PUZ10.5
N28905401: length 1.5
  TOP w0.254: PUZ10.4 136.26,120.61 136.46,120.41 PRZ139.2
N29082093: length 3.9
  TOP w0.254: PCV60.1 25.3,41.48 26.57,41.48 27.09,42.01 PUV4.7
N29085512: length 3.5
  BOTTOM w0.081: v2(94.1,68) RD194.1 95.99,67.05 UD6.F9
N29085514: length 3.8
  BOTTOM w0.081: v2(94.12,69.67) RD235.2 96.88,67.85 UD6.E9
N29085519: length 2.7
  BOTTOM w0.122: UD6.M9 95.42,62.25 RD249.1 RD248.1
N29085573: length 3.5
  TOP w0.254: PUV5.7 34.65,42.11 34.21,41.67 33.68,41.67 33.24,41.23 33.05,41.23 PCV61.1
N29090433: length 3.7
  TOP w0.254: PCV94.2 47.51,40.26 49.06,41.81 49.66,41.81 49.83,41.98 PUV7.7
N29091042: length 3.8
  TOP w0.254: PUV6.7 42.21,42.03 41.93,41.75 41.35,41.75 41.07,41.47 41.04,41.47 41.02,41.44 40.59,41.44 39.75,40.6 PCV95.2
N29096065: length 1.5
  TOP w0.254: PCV124.2 65.26,40.9 PUV8.7
N29096332: length 3.3
  TOP w0.254: PCV125.2 55.35,40.4 56.69,41.73 57.19,41.73 57.51,42.06 PUV9.7
N29102115: length 2.1
  TOP w0.254: PCV155.2 71.94,75.61 PUV11.7
N29673235: length 6.6
  TOP w0.254: PC14.2 24.04,5.34 v2(22.91,5.34) 21.88,5.34 21.27,5.95 21.13,5.95 PR28.1 20.07,6.02 PQ5.2
N29676897: length 1
  BOTTOM w0.081: PCB24.1 v2(37.39,25.22)
N29677561: length 1.4
  BOTTOM w0.508: PCV40.1 51.51,23.71 PRV89.2
N29702846: length 1.9
  BOTTOM w0.081: v2(127.38,137.21) LX8.1 128.25,138.21 RX38.2
N29702855: length 2
  BOTTOM w0.081: RX37.2 130.92,138.23 LX7.1 v2(130.94,137.15)
N29702861: length 1.9
  BOTTOM w0.081: RX36.2 122.66,138.17 LX6.1 v2(122.62,137.18)
N29702867: length 1.8
  BOTTOM w0.081: LX5.1 126.13,138.17 RX35.2 v2(125.29,137.26)
N29702873: length 1.9
  BOTTOM w0.081: LX4.1 136.86,138.23 RX34.2 137.73,137.51 v2(137.93,137.31)
N29702889: length 2.2
  BOTTOM w0.081: RX33.2 140.38,138.23 LX3.1 140.87,138.21 141.38,138.71 v2(141.5,138.71)
N29702919: length 2
  BOTTOM w0.081: v2(133.03,137.23) RX32.2 132.95,138.21 LX2.1
N29702925: length 2.1
  BOTTOM w0.081: RX31.2 134.83,138.21 LX1.1 135.64,137.75 v2(136.12,137.26)
N29733255: length 1
  BOTTOM w0.081: RG510.2 69.9,95.95 QG503.3
N29913076: length 5.2
  BOTTOM w0.081: v2(83.25,25.57) 83.25,25.05 84.8,23.5 QH98.1 85.66,23.28 RH1600.1 86.06,22.74 RE724.1
N29990483: length 1.2
  TOP w0.508: PRV224.2 38.58,24.02 PCV212.1
N30025424: length 6.9
  TOP w0.081: QG522.5 74.18,64.14 RG1604.2 ; QG522.5 73.42,63.25 v2(74.4,62.27) ; QG522.5 72.64,63.89 72.64,66.26 72.83,66.45 QG523.6
N30025428: length 2.5
  TOP w0.081: QG522.3 71.24,62.6 71.03,62.38 71.03,61.81 RG1605.2 71.25,61.11 v2(71.77,60.59)
N30025618: length 3.9
  TOP w0.081: QG523.5 73.97,65.8 QG524.6 75.07,64.7 RG1606.2 76.05,64.14 v2(76.12,64.06)
N30025622: length 2
  TOP w0.081: v2(69.48,64.9) 69.71,65.13 RG1607.2 70.48,65.15 QG523.3
N30156278: length 3.9
  TOP w0.254: PR2.1 v5(18.29,11.97)
  BOTTOM w0.081: JRTC1.1 v2(17.73,15.03)
  BOTTOM w0.254: JRTC1.1 17.73,12.52 v5(18.29,11.97)
N30605331: length 2.6
  BOTTOM w0.081: PR504.2 39.95,5.76 v2(40.47,5.24)
  BOTTOM w0.203: PD501.1 39.62,6.49 39.5,6.36 PR504.2
N30818241: length 2.1
  BOTTOM w0.081: RD195.1 106.07,66.79 106.33,67.05 UD5.F9
N30820408: length 2.1
  TOP w0.381: RD196.1 114.06,67.11 UD7.F9
N30820514: length 2.1
  TOP w0.381: RD197.1 105.33,67.05 UD8.F9
N32205396: length 4
  BOTTOM w0.081: R369.2 R372.1 84.51,36.26 84.37,36.4 QH99.6 84.37,37.77 84.42,37.82 84.93,37.82 85.02,37.74 QH99.5
N32206391: length 4.8
  BOTTOM w0.081: R370.2 R371.1 85.4,40.91 84.87,40.38 84.3,40.38 84.09,40.59 QH100.5 84.09,41.35 83.97,41.47 83.57,41.47 83.44,41.34 QH100.6
N32296413: length 1.4
  BOTTOM w0.081: PRZ81.2 87.43,124.07 v2(86.25,124.07)
N32879277:
  vias: v2(93.43,125.82)
N32879345: length 1.5
  BOTTOM w0.081: v2(98.88,123.94) 99.2,124.26 PRZ105.2
N32879406:
  vias: v2(106.81,123.89)
N32879443:
  vias: v2(118.87,127.79)
N32879490: length 1.5
  BOTTOM w0.081: v2(121.44,125.82) 121.28,125.67 PRZ127.2
N32879537:
  vias: v2(146.61,91.85)
N32879582:
  vias: v2(142.57,104.69)
N32883717: length 7.5
  TOP w0.081: v8(14.2,38.17) 14.11,38.17 v2(13.14,37.2)
  TOP w0.254: v8(18.87,39.75) 19.06,39.94 PUW3.7
  IN1 w0.254: v8(14.2,38.17) 15.1,38.17 15.66,38.72 17.84,38.72 v8(18.87,39.75)
N32888909: length 3
  BOTTOM w0.081: PRW45.2 17.72,47.61 18.55,48.45 19.84,48.45 v2(19.91,48.53)
N34307891: length 2.4
  BOTTOM w0.081: v2(82.42,32.98) 82.16,32.72 PCV21.2
  BOTTOM w0.254: PRV73.1 81.23,32.67 PCV21.2
N35372714: length 3.2
  TOP w0.081: v2(81.46,29.59) 81.46,27.78 81.38,27.7 PRV25.2
  TOP w0.254: PRV67.1 80.82,27.78 PRV25.2
N37205985: length 5.6
  TOP w0.107: RH519.2 140.81,108.72 139.6,108.72 139.54,108.78 138.36,108.78 137.74,108.16 136.55,108.16 UC1.BR33
