# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1V8_MAIN: length 229.6
  TOP w0.508: RG512.1 RG515.1 v3(6.1,7.22) ; RX3.1 102.93,146.04 v8(102.01,145.11)
  IN1 w0.508: v11(70.69,144.86) 70.69,145.32 72.08,146.71 74.04,146.71 74.79,145.96 77.77,145.96 78.55,145.19 80.84,145.19 81.24,145.58 82.03,145.58 83.85,143.77 85.01,143.77 85.57,144.33 86.32,144.33 87.67,145.67 88.39,145.67 88.5,145.56 90.55,145.56 90.81,145.81 95.57,145.81 96.39,144.99 99.33,144.99 99.68,145.34 101.78,145.34 v8(102.01,145.11)
  GND2 w0.203: v3(52.25,101.05) v1(52.65,100.65) ; v1(52.65,102.75) 52.65,102.79 52.4,103.04 v3(52.4,103.2) ; v3(52.34,104.54) v1(52.65,104.85)
  GND2 w0.254: v1(52.65,103.45) v3(52.4,103.2) ; v1(53.35,97.15) v3(53.66,97.46) ; v1(51.95,104.85) 52.26,104.54 v3(52.34,104.54) ; v1(51.95,101.35) v3(52.25,101.05) ; v1(51.95,102.75) v3(52.26,102.44) ; v1(51.95,100.65) 51.72,100.42 v3(51.56,100.42) ; v1(52.65,101.35) v3(52.37,101.63)
  GND2 w0.508: v12(70.5,144.67) v11(70.69,144.86)
  IN2 w0.254: v6(68.5,92.76) 68.17,92.76 67.44,93.5 67.44,94.9 65.67,96.66 65.52,96.66 v5(65.41,96.78)
  IN2 w0.508: v3(6.1,7.22) 6.1,9.63 5.64,10.09 5.64,17.07 8.59,20.01 8.59,22.56 9.61,23.59 9.61,29.15 11.71,31.25 11.71,35.33 12.14,35.77 12.14,38.69 11.78,39.05 11.78,40.08 12.9,41.2 12.9,52.68 15.14,54.92 17.3,54.92 19.84,57.46 58.79,57.46 61.9,60.56 v6(61.9,62.77) ; v4(65.89,121.67) 65.89,124.92 66.01,125.05 66.01,129.96 70.26,134.2 70.26,144.43 v12(70.5,144.67)
  GND4 w0.203: v3(52.26,102.44) 52.46,102.64 v4(52.46,102.8) 52.46,102.98 52.4,103.04 v3(52.4,103.2) ; v3(52.34,104.54) 52.38,104.58 v4(52.95,104.58)
  IN4 w0.254: v6(68.5,92.76) 68.5,91.24 68.71,91.03 v7(68.71,90.2)
  IN4 w0.508: v6(61.9,62.77) 60.2,64.47 60.2,80.29 52.07,88.42 52.07,88.55
  BOTTOM w0.254: v7(68.71,90.2) 68.26,90.64 RG1519.1
  BOTTOM w0.508: v4(65.89,121.67) 60.97,121.67 51.85,112.55
  vias: v1(53.35,103.45) v1(53.35,101.35) v4(48.7,88.94) v4(48.81,90.14) v4(49.28,88.94) v4(49.87,88.94) v4(50.42,88.94) v4(51.01,88.96) v4(52.55,100.17) v4(52.55,99.53) v4(52.55,98.9) v5(64.57,95.84) v5(64.83,97.36) v5(64.83,96.78) v5(64.87,95.35) v7(49.42,90.14) v7(50.03,90.14) v7(50.25,87.9) v7(50.6,90.15) v7(52.46,101.91) v10(56.86,102.34)
+1V_MPHY: length 19.6
  TOP w0.254: v5(107.51,38.74) UH1.W31 ; UH1.W20 v5(102.09,38.74) UH1.W19 ; v5(102.09,39.51) UH1.V19
  IN2 w0.254: v5(102.09,39.51) 102.09,39.54 101.66,39.97 97.66,39.97 97.47,40.16 96.52,40.16 96.14,40.54 95.38,40.54 95.12,40.79 93.85,40.79 v5(93.28,41.37) 93,41.65 93,47.42 v5(92.39,48.03)
  BOTTOM w0.381: v5(102.09,38.74) v5(102.09,39.51)
  vias: v5(117.09,46.43) v10(114.76,46.98)
+1V_PCH: length 16.3
  TOP w0.305: UH1.W23 v5(103.64,39.51) UH1.W22
  TOP w0.381: RH71.1 92.02,39.45 v5(92.1,39.37)
  IN1 w0.381: v5(92.1,39.37) 92.1,39.42 92.71,40.03 93.22,40.03 94.36,41.18 v11(94.68,41.18)
  GND2 w0.254: v12(95,41.37) 94.87,41.37 v11(94.68,41.18)
  IN2 w0.381: v12(95,41.37) 95.5,41.87 96.65,41.87 97.35,41.18 98.26,41.18 98.33,41.24 101.91,41.24 v5(103.64,39.51)
  vias: v10(90.44,39.94)
+1V_VCCDSW: length 0.5
  TOP w0.254: UH1.BG45 UH1.BG46
+1VALW: length 135.7
  TOP w0.081: JPCMC.22 149.23,139.08 v1(149.07,138.92)
  TOP w0.089: UH1.AB23 104.33,37.57 ; UH1.AB23 104.03,37.88 ; UH1.AB23 103.72,37.57 ; UH1.AB23 104.03,37.27 ; UH1.AD20 102.78,36.8 ; UH1.AD20 102.48,37.11 ; UH1.AD20 102.17,36.8 ; 104.03,36.49 UH1.AD23 ; UH1.AD23 103.72,36.8 ; UH1.AD23 104.03,37.11 ; 102.48,37.27 UH1.AB20 ; UH1.AB20 102.17,37.57 ; UH1.AB20 102.78,37.57 ; UH1.AF23 103.72,36.03 ; UH1.AF23 104.03,36.33 ; UH1.AF23 104.03,35.72 ; 103.56,38.35 UH1.AA22 103.25,38.04 ; UH1.AB22 103.25,37.88 ; UH1.AB22 103.56,37.57 ; UH1.AB22 103.25,37.27 ; UH1.AB22 102.95,37.57 ; UH1.AA23 104.33,38.35 ; UH1.AA23 104.03,38.04 ; UH1.AA23 103.72,38.35
  TOP w0.254: v5(100.79,36.81) UH1.AE17 ; UH1.AB28 v5(106.74,37.96) UH1.AB30 v5(106.74,37.19) ; UH1.AB28 v5(105.96,37.19) ; UH1.AB28 v5(106.74,37.19) ; UH1.AB28 v5(105.96,37.96) UH1.AB27 ; v5(103.64,37.19) UH1.AB22 v5(103.64,37.96) ; v5(103.64,37.19) UH1.AB23 ; v5(103.64,37.19) UH1.AD23 v5(103.64,36.41) UH1.AF23 103.64,35.64 ; UH1.AG31 v5(107.51,35.64) ; v5(106.74,37.19) UH1.AD28 ; v5(106.74,37.19) UH1.AD30 v5(106.74,36.41) ; UH1.AD28 v5(105.96,37.19) ; UH1.AD28 v5(106.74,36.41) ; v5(105.96,37.19) UH1.AB27 ; v5(105.96,37.19) UH1.AD27 ; UH1.AB23 v5(103.64,37.96) ; UH1.AB23 v5(104.41,37.96) UH1.AA23 v5(103.64,37.96) ; UH1.AB27 v5(105.19,37.19) UH1.AD27 ; UH1.AA22 v5(103.64,37.96) ; UH1.AD27 v5(105.19,36.41) UH1.AF27 v5(105.19,35.64) ; UH1.AF31 v5(107.51,36.41) ; UH1.AD31 v5(107.51,37.19) ; v5(106.74,36.41) UH1.AF30 v5(106.74,35.64) ; UH1.AB20 v5(102.09,37.19) ; v5(91.6,48.25) 91.68,48.17 91.68,47.64 92.48,46.84 92.91,46.84 UH1.D1 UH1.E1 ; UH1.V30 v5(107.51,39.51) UH1.V31 107.51,40.29 UH1.V30 ; UH1.V30 v5(106.74,39.51) UH1.V28 v5(105.96,39.51) UH1.V27 v5(105.19,39.51) UH1.V25 ; v5(102.86,37.19) UH1.AD20
  GND2 w0.081: v1(149.07,138.92) 149.1,138.89 v12(149.1,138.58)
  IN2 w0.081: v6(140.46,141.47) 140.82,141.11 142.23,141.11 143.21,140.13 144.17,140.13 146.74,137.57 148.79,137.57 149.07,137.85 149.07,138.56 v12(149.1,138.58)
  IN4 w0.254: v7(132.38,118.54) 132.38,123.93 133.12,124.67 136.19,124.67 137.19,125.66 137.19,126.6 137.67,127.08 138.56,127.08 140.16,128.68 140.16,130.13 140.51,130.48 142.72,130.48 143.74,131.5 143.74,133.74 145.44,135.44 145.44,139.67 143.07,142.04 141.2,142.04 140.88,141.72 140.71,141.72 v6(140.46,141.47)
  BOTTOM w0.254: v7(132.38,118.54) 132.38,118.42 130.81,116.84 114.51,116.84 113.64,115.98 100.61,115.98 99.64,115.01 90.75,115.01 87.88,112.14 v5(87.88,109.18)
  vias: v5(87.25,109.18) v5(88.52,109.18) v5(99.03,37.96) v5(99.47,40.67) v5(99.47,36.88) v5(99.57,39.36) v5(99.65,38.51) v5(100.99,41.96) v5(101.96,45.19) v5(102.04,43.49) v5(103,43.98) v5(103.6,43.93) v5(103.59,42.95) v5(126.3,41.23) v5(126.94,41.23) v5(127.57,41.23) v5(128.21,41.23) v10(112.37,47.87)
+1VALWP: length 13.1
  TOP w0.254: v8(134.78,34.41) 134.9,34.53 139.35,34.53 PRH7.2
  IN1 w0.254: v8(134.78,34.41) 134.24,34.95 128.52,34.95 128.14,34.57 v5(128.14,33.87)
  vias: v5(125.77,39.41) v5(126.24,38.95) v5(126.87,38.95) v5(127,33.87) v5(127,33.3) v5(127,31.4) v5(127,30.83) v5(127.1,38.36) v5(127.1,37.76) v5(127.51,38.95) v5(127.57,33.87) v5(127.57,33.3) v5(127.57,31.4) v5(127.57,30.83) v5(127.74,38.36) v5(127.74,37.76) v5(127.99,39.32) v5(128.14,33.3) v5(128.14,31.4) v5(128.14,30.83) v10(127.23,39.54)
+1VALWP_PGOOD: length 74.6
  TOP w0.081: v8(138.79,27.07) v2(137.84,27.07)
  TOP w0.254: PUH1.1 139.16,29.14 139.51,28.79 139.51,27.79 v8(138.79,27.07)
  IN1 w0.254: v8(81.17,11.36) 81.63,10.9 81.94,10.9 82.3,10.54 83.52,10.54 83.93,10.13 86.47,10.13 91.8,15.46 99.79,15.46 100.11,15.14 103.68,15.14 104.35,14.47 105.93,14.47 106.53,15.07 114.95,15.07 115.06,15.19 135.3,15.19 136.97,16.86 136.97,25.25 v8(138.79,27.07)
+2.5V_MEM: length 202.5
  TOP w0.305: UD8.R9 104.02,59.85 104.29,60.12 CD345.1
  TOP w0.356: 127.23,57.38 127.28,57.43 131.76,57.43 v8(131.95,57.62) 132.17,57.84 132.17,59.76 131.91,60.01 CD379.1 ; 127.23,57.38 127.18,57.43 124.88,57.43 124.55,57.1 CD319.1 120.59,56.92 119.63,57.88 119.63,58.85 120.15,59.37 120.15,59.48 ; 127.23,57.38 CD293.1 ; 106.49,59.34 v5(106.49,59.85) 106.22,60.12 CD345.1 ; CD370.1 116.69,59.18 CD347.1 ; CD305.1 120.63,70.73 120.18,71.18 120.18,71.68 120.53,72.04 130.06,72.04 130.42,71.68 v5(130.42,70.77)
  TOP w0.381: v8(107.6,70.25) 107.38,70.47 CD385.1 105.19,70.47 v5(104.71,70.96) 104.01,71.66 101.03,71.66 100.71,71.34 99.44,71.34 99.06,71.72 96.71,71.72 96.58,71.59 ; UD4.B1 121.5,70.25 CD305.1 ; CD327.1 107.49,56.96 v5(107.51,56.98) ; v5(107.51,56.98) 107.51,58.32 106.49,59.34 ; v5(107.51,56.98) 113.59,56.98 115.8,59.18 CD370.1 116.13,59.24 CD377.1 114.27,60.12 UD7.R9 ; v5(130.42,70.77) 131.15,70.03 CD382.1 133.28,70.03 UD3.B1 ; CD379.1 131.03,60.01 v1(130.87,59.85) UD4.R9
  TOP w0.508: CD256.1 v5(119.13,59.48) 118.68,59.03 v5(117.86,59.03) CD347.1
  IN1 w0.254: v8(131.95,57.62) 132.57,58.23 133.85,58.23 134.74,57.34 142.02,57.34 142.89,58.21 142.89,59.74 142.68,59.95 142.38,59.95 142.05,59.61 141.36,59.61 141.12,59.85 v8(139.9,59.85)
  GND2 w0.254: v1(130.87,59.85) 130.87,59.44 v3(131.04,59.27)
  IN2 w0.508: v5(104.71,70.96) 105.09,70.58 106.93,70.58 108.2,71.85 113.98,71.85 116.46,69.37 116.46,62.26 115.82,61.62 115.82,60.29 117.08,59.03 v5(117.86,59.03)
  GND4 w0.254: v4(131.5,59.26) 131.48,59.27 v3(131.04,59.27)
  BOTTOM w0.356: 130.12,74.04 126.36,74.04 125.77,74.64 117.73,74.64 116.5,73.41 CD314.1 ; CD314.1 114.05,72.79 114.55,72.29 114.55,70.64 114.16,70.25 UD5.B1 ; CD314.1 114.05,74.06 113.73,74.39 112.71,74.39 112.46,74.64 ; CD284.1 119.96,59.26 CD282.1 CD283.1
  BOTTOM w0.381: UD5.R9 v5(106.49,59.85) 106.28,60.06 CD359.1 CD344.1 ; CD283.1 121.65,60.12 121.92,59.85 UD2.R9 ; v4(131.5,59.26) CD279.1 133.23,60.12 UD1.R9 ; v5(130.42,70.77) 130.1,70.77 129.58,70.25 UD2.B1 ; CD301.1 141.98,68.58 CD281.1 141.51,69.53 140.79,70.25 UD1.B1 139.9,70.27 140.53,70.89 140.53,71.53 140.12,71.93 132.63,71.93 132.21,72.35 130.55,72.35 ; CD331.1 96.93,60.12 UD6.R9 ; UD6.B1 104,70.25 v5(104.71,70.96) 104.71,72.03 105.08,72.41 CD365.1
  BOTTOM w0.508: v5(130.42,70.77) 130.55,70.9 CD326.1 130.55,73.62 130.12,74.04 ; CD284.1 119.74,59.48 v5(119.13,59.48) ; v5(107.51,56.98) 107.5,56.98 106.81,56.29 v10(104.84,56.29) 103.75,56.29 102.27,57.77 96.37,57.77 96.01,58.13 96.01,58.57 95.33,59.26 CD333.1 CD331.1 ; 112.46,74.64 105.98,74.64 105.08,73.74 CD365.1 ; CD366.1 117.62,59.27 v5(117.86,59.03)
  vias: v8(93.47,69.37) v8(97.2,70.25)
+2.5V_MEMP:
  vias: v10(88.25,68.66)
+2.5VOUT: length 20.8
  TOP w0.254: UM8.51 68.35,135.43 68.66,135.74 69.62,135.74 69.9,136.02 69.9,139.32 70.17,139.59 UM8.9 ; UM8.36 64.71,140.09 64.01,140.79 v4(63.69,140.79) 63.69,140.55 64.18,140.06 64.18,137.98 64.56,137.59 UM8.41
  BOTTOM w0.508: v5(71.53,142.32) 70.54,141.33 v2(66.64,141.33) 64.22,141.33 v4(63.69,140.79)
+2.5VSP_ADJ: length 6.7
  TOP w0.081: v2(84.89,68.3) 85.39,68.81 PC2504.2
  TOP w0.254: PR2504.2 84.9,71.16 PR2505.1 86.16,68.96 PC2504.2 86.16,67.52 86.01,67.36 PU2501.7
+2.5VSP_ON: length 4.1
  TOP w0.254: PU2501.2 86.01,59.36 PR2501.2 PC2501.1 PR2502.1
+2.5VSP_PGOOD: length 3.8
  TOP w0.081: PU2501.1 84.74,60.74 PR2503.2 83.22,59.35 v2(83.22,60.3)
+2.5VSP_VIN: length 1.5
  TOP w0.081: v2(85.33,57.2) 85.42,57.29 86.82,57.29
+3.3V_ANA_PCIE: length 5.2
  TOP w0.081: RT200.2 75.35,143.87 v2(74.46,142.98)
  TOP w0.203: RT200.2 75.44,143.92 76.2,143.16 77.53,143.16 v4(77.85,143.47) 77.94,143.56 CT85.1
  BOTTOM w0.081: UT1.L16 v4(77.85,143.47)
+3.3V_ANA_USB2: length 0.9
  TOP w0.203: CT86.1 77.25,143.8 v4(77.25,143.51)
  BOTTOM w0.081: v4(77.25,143.51) 77.28,143.54 UT1.J16
+3.3V_ELC: length 121.3
  TOP w0.508: v5(125.02,20.63) 125.7,19.94 125.7,19.42 125.72,19.41 RE6.2 RE7.2 125.7,17.72 RE4.1 125.49,16.83 125.07,16.41 125.07,15.06 125.59,14.54 125.59,13.43 v5(126.24,12.78) 127.76,14.3 129.77,14.3 130.98,15.52 JELC2.1
  IN2 w0.508: v5(126.24,12.78) v4(129.04,15.59)
  IN3 w0.254: v4(129.04,15.59) 129.11,15.65 v9(129.11,17.27)
  IN3 w0.508: v5(126.24,12.78) 126.19,12.73 v5(121.93,12.73) 121.08,12.73 118.75,15.06 117.81,15.06 116.54,16.33 116.1,16.33 v9(115.92,16.51) 115.92,16.57 115.27,17.22 115.27,20.96 115.47,21.16 115.47,23.34 v9(115.95,23.82) ; v9(135.76,16.86) 135.64,16.98 131.97,16.98 130.4,15.42 129.21,15.42 v4(129.04,15.59) ; v5(126.85,24.18) 130.76,24.18 131.06,23.88 135.33,23.88 137.79,26.34 v9(137.79,26.82)
  GND4 w0.089: v4(115.97,23.82) v9(115.95,23.82)
  GND4 w0.254: v4(129.12,17.27) v9(129.11,17.27)
  GND4 w0.508: v9(137.79,26.82) v4(137.79,27.21) ; v4(136.09,16.86) v9(135.76,16.86)
  IN4 w0.508: v7(127.52,26.97) 127.52,25.63 126.85,24.96 v5(126.85,24.18) 126.85,23.57 125.02,21.74 v5(125.02,20.63) ; v7(106,18.27) 106.29,17.98 106.29,17.63 106.79,17.12 110.86,17.12 v7(111.6,16.38)
  BOTTOM w0.254: LE4.1 128.52,26.86 CE65.1 ; UE1.1 127.18,23.58 127.61,24.01 127.61,26.17 CE65.1 ; CE6.1 CE60.1 125.19,28.26 124.84,28.6 122.91,28.6 122.51,28.2 RE657.1 RE1.1 RE2.1 ; CE6.1 125.19,26.53 124.94,26.29 UE1.48 ; CE6.1 125.94,27.05 126.01,26.97 CE59.1 v7(127.52,26.97) CE65.1 ; v4(115.91,16.51) 116.43,17.02 117.78,17.02 118.14,17.38 119.26,17.38 119.44,17.2 UE1.24 ; UE1.36 116.21,23.58 v4(115.97,23.82) ; UE8.27 106.07,17.65 106,17.73 v7(106,18.27) ; RE21.1 126,13.02 v5(126.24,12.78) ; RE23.1 v5(121.93,12.73) ; v4(129.12,17.27) RE16.1
  BOTTOM w0.508: UE9.1 137.23,15.58 136.75,16.06 136.75,16.14 136.75,16.14 136.75,16.54 136.75,16.55 136.75,16.78 RE12.1 v4(136.09,16.86) ; v7(106,18.27) 105.89,18.38 104.59,18.38 104.04,17.83 103.33,17.83 102.87,17.38 RE166.1 ; UE2.8 137.86,27.14 v4(137.79,27.21) 137.79,27.46 137.29,27.97 RE13.1 ; v7(111.6,16.38) 111.86,16.38 112.37,15.87 112.37,15.55 v10(112.76,15.15) 112.98,14.94 115.46,14.94 115.96,15.45 CE19.1 115.96,16.46 v4(115.91,16.51)
+3.3V_FLASH: length 77.1
  TOP w0.254: RT50.1 75.98,118.1 76.41,118.53 76.41,119.19 76.14,119.47 RT49.1 ; UT2.8 67.04,117.57 v1(67.59,118.11)
  TOP w0.356: RT51.1 64.68,118.2 CT45.1 UT2.8 ; v1(75.98,120.11) RT49.1
  TOP w0.381: v4(92.71,142.06) 92.74,142.06 93.07,141.73 RT66.1 RT67.1 95.28,141.73 95.82,142.28 97.85,142.28 98.18,142.61 98.97,142.61 v2(99.09,142.73) 99.39,142.73 99.76,142.36 101.8,142.36 v4(101.89,142.27)
  IN1 w0.254: v4(92.71,142.06) 92.71,139.35 v5(93.08,138.98)
  GND2 w0.254: v12(76.5,120.63) v1(75.98,120.11) ; v12(67.82,118.39) 67.82,118.34 v1(67.59,118.11)
  IN2 w0.254: v4(92.71,142.06) 92.81,142.17 92.81,143.66 92.47,144.01 v4(92.47,145.7) ; v12(67.82,118.39) 68.35,118.93 70.15,118.93 70.79,119.56 71.56,119.56 73.24,117.88 75.08,117.88 75.34,118.14 75.34,119.18 75.98,119.83 v1(75.98,120.11) v12(76.5,120.63) 76.5,130.76 72.96,134.31 72.96,135.67 73.42,136.13 83.49,136.13 83.5,136.12 85.38,136.12 85.61,136.35 88.81,136.35 90.95,138.48 92.58,138.48 v5(93.08,138.98)
  BOTTOM w0.254: v5(93.08,138.98) 93.22,139.12 UT4.B1 ; CT103.1 92.7,142.08 v4(92.71,142.06) 93.17,142.06 93.61,141.62 UT4.G1
+3.3V_LC: length 1
  TOP w0.081: v2(85.79,140.55) 85.74,140.6 84.86,140.6 RT7.1
  vias: v1(82.09,141.2) v3(82.09,141.2) v4(82.09,141.2)
+3.3V_TBT_SX: length 26.2
  TOP w0.356: v3(87.27,139.15) RT27.1
  IN1 w0.152: v3(87.27,139.15) 87.58,139.45 88.22,139.45 v1(88.54,139.13)
  IN2 w0.254: v4(81.44,145.1) 81.83,145.5 83.94,145.5 84.12,145.32 85.42,145.32 85.85,145.75 v4(87.21,145.75) v6(87.21,143.84) v4(87.21,142.57) 87.73,142.05 88.87,142.05 89.13,141.8 89.13,141.43 88.7,141 87.76,141 87.27,140.51 v3(87.27,139.15)
  GND4 w0.081: v6(87.21,143.84) 87.5,143.55 87.5,142.83 87.25,142.57 v4(87.21,142.57)
  GND4 w0.254: v4(87.21,138.76) 87.21,139.08 v3(87.27,139.15)
  IN4 w0.254: v4(90.94,143.49) 90.6,143.83 87.22,143.83 v6(87.21,143.84)
  BOTTOM w0.254: RT70.1 91.52,143.49 v4(90.94,143.49) ; v4(87.21,138.76) RT29.1
  BOTTOM w0.356: RT86.1 87.83,144.48 RT33.1 v6(87.21,143.84)
  vias: v2(83.17,145.77)
+3.3V_TBT_SX_R: length 5
  IN4 w0.254: v7(94.19,142.12) 93.67,142.65 92.74,142.65 92.45,142.36 90.84,142.36 v7(90.7,142.5)
  BOTTOM w0.254: RT61.1 90.39,143.46 CT102.1 90.39,142.81 90.55,142.65 90.55,142.64 90.68,142.51 90.69,142.51 v7(90.7,142.5)
+3V3_SYS: length 280.1
  TOP w0.508: RG1608.2 9.7,29.68 v3(8.99,30.39) ; QX1.2 133.62,142.94 RV655.1 v8(132.54,143.22)
  IN1 w0.508: v5(59.33,73.69) 59.81,73.69 60.09,73.97 64.5,73.97 65.29,73.18 72.07,73.18 73.02,72.23 77.74,72.23 v5(79.86,74.35) ; v8(132.54,143.22) 132.42,143.22 131.85,142.65 127.58,142.65 126.31,143.92 122.1,143.92 119.46,141.28 106.68,141.28 104.32,143.63 94.64,143.63 93.07,145.2 91.06,145.2 90.81,144.95 88.66,144.95 86.97,143.26 86.53,143.26 86.18,142.91 83.73,142.91 83.22,143.42 80.55,143.42 80.34,143.63 79.24,143.63 77.52,145.35 72.19,145.35 69.85,143.01 69.85,142.76 68.35,141.26 67.17,141.26 65.71,139.8 65.71,135.16 62.73,132.17 62.73,126.86 67.64,121.95 69.57,121.95 69.67,121.85 69.67,121.85 70.03,121.5 70.03,121.49 70.08,121.44 70.08,114.56 v5(72.09,112.55)
  IN2 w0.508: v5(59.33,73.69) 60.27,72.75 60.27,63.35 56.09,59.17 34.55,59.17 34.21,59.51 29.02,59.51 28.68,59.17 19.08,59.17 16.87,56.96 14.7,56.96 9.84,52.11 v5(9.84,41.24)
  IN3 w0.508: v5(9.84,41.24) 9.94,41.14 9.94,40.02 8.06,38.14 8.06,36.44 8.64,35.87 8.64,30.75 v3(8.99,30.39) 6.54,27.94 6.54,27.65 6.1,27.21 6.1,22.01 7.32,20.79 v5(7.32,20.2) ; v5(72.09,112.55) 72.09,103.01 72.64,102.45 v9(72.64,101.5)
  GND4 w0.508: v9(72.64,101.5) v4(72.64,101.17)
  BOTTOM w0.508: v5(79.86,74.35) 82.36,76.85 82.36,87.91 78.26,92.02 78.26,93.09 73.69,97.67 73.69,100.13 v4(72.64,101.17) 72.4,100.93 PR1108.1
+3V_OC_PWR: length 25.1
  TOP w0.254: RG135.2 11.07,40.6 v8(10.53,41.15) ; v8(9.59,39.4) 9.59,38.65 8.84,37.9 8.72,37.9 8.09,37.27 8.09,37.25 8.06,37.23 8.06,36.73 7.27,35.93 v8(7.27,35.19)
  TOP w0.508: v8(6.41,28.26) RG1571.1 RG1572.1 RG1573.1 8.9,28.27 9.68,28.27 RG1608.1 RG1609.1 11.25,28.25 RG1611.1
  IN1 w0.254: v8(9.59,39.4) 9.23,39.75 9.23,39.86 ; v8(5.52,40.3) 6.01,40.78 8.31,40.78 9.23,39.86 ; v8(10.53,41.15) 9.23,39.86 ; v8(6.41,28.26) 6.41,28.62 6.54,28.74 6.54,31.52 7.27,32.25 v8(7.27,35.19)
+3V_PCH: length 309.4
  TOP w0.254: UH1.AN44 113.96,32.44 113.51,32.44 v5(113.25,32.18) 113.25,31.94 113.51,31.69 113.55,31.69 UH1.AT44 ; UH1.AE36 v5(110.36,35.67) ; UH1.AE35 109.6,35.71 v5(109.66,35.65) ; UH1.BB7 v5(96.27,28.36) UH1.AY8 ; RH7.2 124.59,21.97 124.59,21.87 v8(124.08,21.36) ; UH1.BB14 99.5,28 v5(99.66,28.16) ; UH1.V23 v5(104.41,39.51) ; RH453.2 v1(113.03,17.07) ; UH1.AP26 v5(106.04,31.74) ; UH1.AN21 102.24,32.51 v5(102.24,32.51) ; UH1.AC36 v5(110.36,37.93) ; UH1.AN24 v5(103.67,32.5) ; UH1.AC35 v5(109.6,37.93) ; UH1.AW9 v5(96.98,28.68) ; UH1.AN26 v5(106.01,32.5) ; R367.2 v1(97.14,19.12)
  TOP w0.356: RH63.1 108.89,22.42 RH558.2 ; v5(99.83,21.12) RH25.2 RH29.2
  TOP w0.381: v8(124.08,21.36) 123.66,21.79 UH4.8
  TOP w0.457: v8(119.74,40.95) 120.48,40.95 RH99.2
  TOP w0.508: v8(120.14,55.59) 120.65,55.08 120.65,49.09 120.8,48.93 120.8,47.69 122,46.5 122,42.84 122.66,42.18 122.66,41.15 122.3,40.79 121.16,40.79 120.8,41.15 RH99.2 ; RH506.2 109.63,21.07 RH524.1 ; v5(120.04,30.48) 122.16,30.48 122.67,30.99 v8(122.67,31.71) ; RH524.1 RH63.1 ; RH524.1 108.84,21.02 v5(108.84,19.9) 108.84,19.4 109.04,19.19 RH594.1 ; RH460.1 RH461.1 ; v8(112.97,21.1) RH545.2 v3(111.32,21.1)
  IN1 w0.254: v8(112.97,21.1) v11(112.32,20.45) ; v5(104.41,39.51) 104.41,39.92 105.28,40.79 108.27,40.79 109.47,39.59 109.47,38.05 v5(109.6,37.93)
  IN1 w0.508: v1(140.45,140.68) 139.89,140.68 138.63,139.42 v11(133.48,139.42) ; v8(119.74,40.95) 118.77,40.95 116.48,38.66 v5(113.2,38.66) ; v8(122.67,31.71) 122.45,31.5 122.45,23.65 124.08,22.02 v8(124.08,21.36) ; v8(120.14,55.59) 120.14,55.74 119.72,56.16 114.23,56.16 113.99,56.4 100.92,56.4 100.2,57.11 93.11,57.11 91.06,59.17 91.06,71.18 89.23,73.01 89.23,82.78 90.8,84.36 93.6,84.36 95.1,85.86 95.1,86.58 93.08,88.6 v11(93.08,97.94)
  GND2 w0.254: v1(113.03,17.07) v12(113.03,17.5) ; v11(93.08,97.94) v12(93.08,98.28) ; v12(97.41,19.2) 97.23,19.2 v1(97.14,19.12) ; v11(112.32,20.45) 112.19,20.32 v12(112.19,20.22)
  GND2 w0.508: v11(133.48,139.42) v12(133.12,139.07)
  IN2 w0.254: v12(112.19,20.22) 112.19,18.34 v12(113.03,17.5)
  IN2 w0.508: v12(93.08,98.28) 93.08,109.34 92.04,110.38 85.87,110.38 85.21,111.04 78.14,111.04 77.31,111.87 77.31,113.25 78.07,114.01 80.74,114.01 81.03,113.72 82.43,113.72 82.97,114.27 82.97,115.37 82.09,116.25 82.09,123.06 81.63,123.52 81.63,130.37 84.35,133.1 84.35,133.17 86.17,134.99 89.62,134.99 90.22,135.59 95.78,135.59 98.17,137.98 100.08,137.98 101.12,136.93 112.75,136.93 113.56,137.75 131.8,137.75 v12(133.12,139.07)
  IN3 w0.254: v5(108.84,19.9) 110.12,19.9 v3(111.32,21.1)
  IN4 w0.508: v4(88.57,30.04) 88.57,30.03 89.97,30.03 90.99,29.01 92.39,29.01 92.83,29.44 96.01,29.44 96.77,28.68 v5(96.98,28.68)
  BOTTOM w0.381: RH95.1 105.78,32.27 v5(106.01,32.5) ; v5(105.5,25.07) 105.69,25.26 105.69,25.26 106.02,25.59 106.02,25.6 RH130.1 ; RH21.2 RH27.2 99.98,25.26 99.6,24.88 99.22,24.88 97.63,26.47 97.01,26.47 96.02,27.46 CH182.1 96.1,27.7 96.1,28.19 v5(96.27,28.36) ; v5(103.67,32.5) 103.67,32.51 v5(102.24,32.51)
  BOTTOM w0.508: v4(88.57,30.04) 88.49,29.96 84.44,29.96 83.82,29.34 83.82,25.09 84.8,24.11 85.48,24.11 85.79,23.8 RH1600.2 ; v5(113.2,38.66) 113.08,38.66 112.82,38.93 CH192.1 ; v5(113.25,32.18) 112.61,32.18 111.77,31.35 110.57,31.35 110.4,31.18 109.69,31.18 108.97,31.9 108.97,32.04 v5(108.6,32.41)
  vias: v5(103.44,18.7) v5(103.75,19.17) v5(104.08,18.7) v5(104.33,19.2) v5(104.73,29.87) v5(106.14,29.07) v10(115.7,35.54)
+3VALW: length 538.1
  TOP w0.254: v1(52.06,2.38) PR1810.2 52.06,3.44 51.28,4.22 49.89,4.22 49.57,4.54 48.83,4.54 48.68,4.69 PU1802.12 ; RE201.1 RE689.1 RE688.1 ; v5(125.48,24.16) 125.46,24.17 RH2.1 RH6.2 ; v5(134.18,54.26) 134.48,53.96 PUH2.12
  TOP w0.381: PRH15.2 v5(139.83,55.27)
  TOP w0.508: UM3.5 52.52,142.91 53.16,142.27 CM70.1 CM23.1 54.15,141.4 55.02,140.54 57.2,140.54 57.63,140.97 ; v5(17.59,3.5) 17.87,3.5 18.36,3 18.36,2.95 18.38,2.94 PR32.1 ; PRV50.1 69.96,14.87 70.23,15.14 ; v5(79.01,148.96) CT121.1 79.83,149.63 UT8.5 ; v6(4.72,26.94) PRW21.1 ; v5(148.46,28.4) 146.76,26.7 142.24,26.7 140.92,25.38 v5(140,25.38) 139.7,25.68 PRH4.1 ; PR3.2 v5(12.67,23.54) ; v1(85.47,33.48) R307.1 ; v5(134.62,16.26) 135.02,15.86 JWDB1.1
  TOP w1.524: 62.66,120.72 62.66,115.98 67.03,111.61 67.03,102.59 v3(67.3,102.33) 67.36,102.26 69.75,102.26 72.66,99.36 72.66,95.79 72.11,95.24 71.41,94.54 71.41,93.4
  IN1 w0.254: 9.99,29.21 9.99,31.81 9.79,32.01 9.79,35.09 7.96,36.92 v8(7.96,40.29) ; 9.99,29.21 10.02,29.18 10.12,29.18 10.13,29.17 v8(10.49,29.17) ; 9.99,29.21 v6(9.06,28.27) ; v1(149.21,42.97) 149.21,41.34 v5(149.02,41.15)
  IN1 w0.508: v1(89.55,142.52) 90.4,143.37 90.79,143.37 91.52,144.1 92.63,144.1 94.77,141.96 98.34,141.96 98.54,141.76 102.61,141.76 v5(103.15,141.22) 104.19,140.19 115.52,140.19 116.28,139.42 125.37,139.42 127.03,141.07 132.23,141.07 132.97,140.34 v5(135.71,140.34) ; v5(149.02,41.15) 148.49,41.15 147.19,42.45 145.54,42.45 143.51,44.48 143.51,48.29 142.24,49.56 142.24,51.84 141.35,52.73 140.46,52.73 139.83,53.37 v5(139.83,55.27) ; v5(4.51,4.73) v5(5.14,4.73) 7,2.87 7.44,2.87 8.53,1.78 12.75,1.78 13.72,2.75 16.69,2.75 17.44,3.5 v5(17.59,3.5) 17.74,3.5 18.22,3.01 21.27,3.01 22.35,1.93 24.26,1.93 25.82,3.5 30.44,3.5 32.26,5.31 39.04,5.31 40.26,6.53 43.84,6.53 44.68,5.69 44.68,4.45 47.22,1.91 49.38,1.91 49.85,2.38 v1(52.06,2.38) 54.14,2.38 54.5,2.02 58.45,2.02 v11(59.11,2.67)
  IN1 w1.524: 84.62,59.18 85.89,60.45 85.89,68.19 82.69,71.38 82.69,82.67 82.19,83.17 82.19,87.47 81.32,88.33 75.96,88.33
  GND2 w0.254: v12(68.2,133.5) v1(68.86,133.5) ; v12(81.92,8.54) 81.46,8.54 v1(81.41,8.59) ; v4(88.77,142.86) 89.11,142.52 v1(89.55,142.52) ; v1(85.47,33.48) v3(84.91,33.48) ; v3(74.73,16.59) 74.73,16.6 74.47,16.86 v1(74.28,16.86)
  GND2 w0.508: v11(59.11,2.67) v12(59.11,2.95) ; v12(86.31,6.43) 86.51,6.23 v1(86.51,5.81)
  IN2 w0.254: 64.64,134.01 66.55,134.01 67.06,133.5 v12(68.2,133.5)
  IN2 w0.508: v12(84.92,8.05) 84.92,8.14 87.53,10.75 87.53,12.73 88.01,13.21 91.59,13.21 91.99,12.81 92.63,12.81 93.22,13.4 93.22,16.27 91.69,17.79 ; v12(84.92,8.05) 86.31,6.67 v12(86.31,6.43) ; v12(84.92,8.05) 82.4,8.05 v12(81.92,8.54) ; v5(135.71,140.34) 136.35,140.34 139.24,137.44 v4(140.13,137.44) ; v5(125.48,24.16) 124.74,23.42 v3(124.74,22.18) ; v3(101.6,17.68) 101.6,15.39 100.41,14.2 v5(100.36,14.2) ; v12(59.11,2.95) 59.11,5.95 57.28,7.77 v3(57.28,12.02) ; v5(149.02,41.15) 149.02,38.41 147.73,37.11 147.73,33.45 149.99,31.19 149.99,29.92 v5(148.46,28.4)
  IN3 w0.508: v3(124.21,17.93) 127.38,14.76 130.94,14.76 132.44,16.26 v5(134.62,16.26) ; v5(140,25.38) 138.89,25.38 136.83,23.32 136.83,21.69 133.4,18.27 129.06,18.27 v3(128.24,19.08) ; v5(4.51,4.73) 2.57,6.67 2.57,17.55 4.19,19.18 4.19,21.36 3.2,22.35 3.2,23.17 4.72,24.69 v6(4.72,26.94) ; v5(12.67,23.54) 12.88,23.54 13.39,24.04 13.39,25.94 v9(14.31,26.86)
  IN3 w1.016: 62.93,146.9 64.99,148.96 v5(79.01,148.96) 79.9,148.96 81.84,150.9 84.32,150.9 86.07,149.15 91.42,149.15 93.51,147.06 93.98,147.06 95.14,145.9 97.69,145.9 99.69,143.9 99.69,141.13 100.72,140.1 102.14,140.1 103.15,141.11 v5(103.15,141.22)
  IN3 w1.524: 83.4,23.85 85.04,25.49 85.04,27.57 87.16,29.7 ; 87.37,32.84 85.55,32.84 v3(84.91,33.48) 84.91,34.52 85.93,35.54 85.93,38.85 84.56,40.23 84.56,45.1 83.45,46.21 83.45,55.25
  GND4 w0.508: v9(14.31,26.86) v6(14.86,27.41)
  IN4 w0.508: v6(14.86,27.41) 9.92,27.41 v6(9.06,28.27) 9,28.32 5.61,28.32 5.12,27.83 5.12,27.33 v6(4.72,26.94) ; v7(64.01,30.91) 64.01,27.37 65.53,25.85 65.53,25.85 66.08,25.3 66.08,21.54 68.77,18.85 69.62,18.85
  IN4 w1.016: 55.47,145.47 45.77,145.47 44.07,143.77 38.13,143.77 37.2,142.84 34.16,142.84 32.67,141.35 ; v4(66.57,102.3) 67.78,102.3 69.55,104.07 v7(69.55,106.26)
  BOTTOM w0.254: RT88.1 95.49,14.58 93.5,14.58 92.93,15.15 RE643.1 93.47,16.04 93.47,16.73 RE642.1 92.42,17.78 91.11,17.78
  BOTTOM w0.381: JIO1.A10 5.26,4.84 v5(5.14,4.73)
  BOTTOM w0.508: v5(139.83,55.27) 139.5,54.94 136.92,54.94 v10(136.59,55.27) 135.19,55.27 v5(134.18,54.26) PCH21.1 ; v5(134.62,16.26) CE22.1 134.68,15.58 UE9.5
  vias: v1(64.01,122.46) v1(64.64,122.46) v1(65.15,122.46) v1(70.38,15.55) v1(80.85,22.29) v1(80.86,21.74) v1(83.19,18.19) v1(83.28,58.37) v1(90.55,18.06) v1(91.06,18.06) v3(70.1,18.89) v3(70.1,18.38) v3(70.1,17.93) v3(70.1,17.49) v3(70.38,15.55) v3(70.55,18.89) v3(70.55,18.38) v3(70.55,17.93) v3(70.55,17.49) v3(70.99,18.89) v3(70.99,18.38) v3(70.99,17.93) v3(70.99,17.49) v3(71.44,18.89) v3(71.44,18.38) v3(71.44,17.93) v3(71.44,17.49) v3(81.34,22.32) v3(81.85,22.32) v3(82.36,22.32) v3(82.87,22.32) v3(83.19,18.19) v3(83.69,58.32) v3(83.67,57.76) v3(90.55,18.06) v3(91.06,18.06) v4(70.1,18.89) v4(70.1,18.38) v4(70.1,17.93) v4(70.1,17.49) v4(70.55,18.89) v4(70.55,18.38) v4(70.55,17.93) v4(70.55,17.49) v4(70.99,18.89) v4(70.99,18.38) v4(70.99,17.93) v4(70.99,17.49) v4(71.44,18.89) v4(71.44,18.38) v4(71.44,17.93) v4(71.44,17.49) v5(11.94,14.7) v5(11.94,14.12) v5(56.39,144.93) v5(56.79,144.53) v5(61.26,146.56) v5(61.65,146.13) v5(90.08,18.81) v5(90.61,19.27) v5(90.61,18.63) v7(31.62,140.82) v7(32.04,140.81) v8(71.5,92.19) v8(71.51,91.79) v8(71.81,92.19) v8(71.82,91.79) v8(72.11,91.99) v8(83.31,57.9) v8(83.63,57.89) v8(83.97,57.81) v10(72.38,15.85) v10(73.27,18.98) v11(70.1,17.93) v11(70.1,17.49) v12(64.26,122.71) v12(64.26,122.2) v12(64.9,122.71) v12(64.9,122.2)
+3VALW_EC: length 101.8
  TOP w0.076: v8(83.53,18.33) 83.41,18.44
  TOP w0.081: 83.41,18.44 82.97,18.89 CE32.2
  TOP w0.254: v8(86.96,13.43) 87.22,13.43 87.92,12.72 87.92,9.68 86.61,8.37 ; v11(77.11,19.64) 76.89,19.86 LE1.1 ; 86.61,8.37 87.03,7.96 87.44,7.96 87.91,7.48 RE78.2 RE723.2 ; 86.61,8.37 CE30.1 86.06,8.37 85.83,8.6 85.81,8.6 85.8,8.61 RE715.2 ; CE31.2 CE32.2 RG1612.1 82.79,19.78 82.28,20.28 v8(82.28,20.69) ; UE5.K12 81.67,16.69 81.9,16.45 82.25,16.45 v8(82.67,16.87)
  TOP w0.508: PR16.2 27.18,2.36 v5(27.52,2.71)
  IN1 w0.254: 83.99,18.07 83.64,17.72 83.02,17.72 82.67,17.37 v8(82.67,16.87) ; 83.99,18.07 84.45,17.6 84.45,17.01 86.05,15.42 86.05,14.34 v8(86.96,13.43) ; 83.99,18.07 83.79,18.07 v8(83.53,18.33) ; v8(82.28,20.69) 81.72,20.13 81.47,20.13 81.09,19.75 77.22,19.75 v11(77.11,19.64)
  GND2 w0.254: v11(77.11,19.64) v3(77.11,19.14)
  IN2 w0.508: v4(44.95,8.22) 44.95,7.86 44.35,7.27 42,7.27 41.64,6.91 39.57,6.91 38.23,5.57 32.8,5.57 29.95,2.71 v5(27.52,2.71)
  GND4 w0.254: v3(77.11,19.14) 77.18,19.07 v6(77.18,18.46)
  IN4 w0.254: v4(45.02,11.08) 44.03,12.07 44.03,12.96 44.35,13.27 44.98,13.27 45.22,13.03 49.33,13.03 49.82,13.53 54.41,13.53 56.64,11.29 67.89,11.29 69.25,12.65 69.25,14.19 69.67,14.61 70.84,14.61 v6(71.01,14.44) 71.12,14.44 71.89,13.67 75.67,13.67 76.06,14.06 76.06,14.53 76.49,14.96 76.49,17.77 v6(77.18,18.46)
  BOTTOM w0.254: v4(45.02,11.08) 45.92,10.18 45.92,9.82 v2(45.94,9.81) 45.5,9.37 45.5,8.95 44.95,8.4 v4(44.95,8.22) 44.95,8.04 44.65,7.75 PR24.2
+3VALW_PD: length 8.2
  IN4 w0.254: v7(90.36,141.96) 90.61,141.71 93.28,141.71 v7(93.69,142.12)
  BOTTOM w0.081: v2(90.12,146.08) CT88.1
  BOTTOM w0.381: CT101.1 90.12,144.05 89.69,143.61 RT728.2 89.69,142.64 v7(90.36,141.96)
  BOTTOM w0.508: CT88.1 CT101.1
+3VALW_TBT: length 27.1
  TOP w0.508: 73.85,132.68 73.92,132.26 73.99,131.79 74.01,131.76 74.02,131.73 74.04,131.71 74.56,131 74.58,130.98 RT729.2 76.83,130.98 v2(76.95,131.09) 77.33,131.47 ; v4(84.31,135.11) 84.25,135.04 83.35,135.04 82.76,134.45 82.76,134.41 82.41,134.07 81.97,134.07 80.09,132.19 78.59,132.19 78.23,131.83
  GND2 w0.254: v4(88.43,145.76) 88.43,145.7 88.35,145.62 88.35,145.44 v1(88.1,145.19)
  GND2 w0.508: v1(84.71,147.05) 84.43,147.05 v3(84.28,147.2)
  IN2 w0.508: v4(88.43,145.76) 88,145.33 v4(88,142.53)
  GND4 w0.508: v4(83.7,147.91) 83.7,147.8 84.28,147.22 v3(84.28,147.2)
  BOTTOM w0.381: v4(84.31,135.11) 84.31,134.74 84.6,134.45 87.46,134.45 88.28,135.27 88.28,137.24 88.73,137.69 88.73,138.23 88,138.97 88,139.16 CT51.1
  vias: v1(80.79,144.45) v3(80.79,144.45) v4(80.79,144.45)
+3VALW_TBT_S5: length 3.7
  GND2 w0.254: v12(89.95,143.38) 89.95,143.88 v1(90.05,143.98)
  IN2 w0.254: v12(89.95,143.38) 89.66,143.09 v4(89.66,141.28)
  BOTTOM w0.356: RT53.1 89.89,141.05 v4(89.66,141.28)
  vias: v2(83.71,149.25)
+3VALWP: length 25.7
  TOP w0.254: PR304.1 62.29,27.51 v5(62.29,27.49) ; 62.61,17.74 61.34,17.74 60.71,18.38 60.71,20.42 59.21,21.92 59.21,24.42 59.7,24.91 v5(61.86,24.91) 62.07,25.12 PU301.11
  BOTTOM w0.254: PC302.1 59.94,18.76 59.69,19.01 59.69,21.48 PR303.2 60.06,21.73 60.83,22.51 PR307.1 61.86,24.53 v5(61.86,24.91) 62.29,25.35 v2(62.29,26.67) v5(62.29,27.49) 61.58,28.2 PR304.1
  vias: v5(62.87,17.93) v5(62.87,17.3) v5(63.5,17.93) v5(63.5,17.3) v5(63.5,16.66) v5(64.14,17.93) v5(64.14,17.3) v5(64.14,16.66)
+3VLP: length 170.3
  TOP w0.254: v8(80.52,14.23) 80.66,14.36 UE5.J7 ; v5(14.21,28.03) 14.67,28.49 14.67,29.47 14.41,29.72 13.13,29.72 12.57,29.16 RG1613.1 12.06,29.17 11.28,29.17 RG1611.2
  TOP w0.508: v1(87.07,6.59) 86.65,7.01 RE78.1
  IN1 w0.254: v4(75.62,15.5) 76.21,15.5 76.3,15.41 78.14,15.41 78.44,15.71 78.8,15.71 79.06,15.45 79.06,14.98 79.81,14.23 v8(80.52,14.23) ; v4(75.45,16.14) 75.09,16.14 v8(74.28,15.33) 74.14,15.47 73.04,15.47 71.22,13.65 71.22,12.09 69.66,10.53 v6(69.61,10.53)
  IN1 w0.508: v11(67.44,3.38) 77.67,3.38 78.06,2.99 81.06,2.99 82.42,4.35 v11(82.77,4.35)
  GND2 w0.254: v12(87.53,6.64) 87.48,6.59 v1(87.07,6.59)
  GND2 w0.508: v12(67.46,3.71) 67.46,3.4 v11(67.44,3.38) ; v11(82.77,4.35) 83.2,4.35 v12(83.31,4.46)
  IN2 w0.508: v12(67.46,3.71) 67.46,7.29 67.94,7.77 67.94,9.88 68.74,10.68 69.46,10.68 v6(69.61,10.53) ; v4(46.43,10.9) 44.22,10.9 43.15,11.97 40.67,11.97 39.12,10.42 30.96,10.42 30.35,9.81 19.42,9.81 18.91,10.31 18.91,12.31 18.22,12.99 v3(18.22,13.57) ; v12(83.31,4.46) 84.39,4.46 85.38,5.45 86.64,5.45 87.53,6.34 v12(87.53,6.64) 87.53,7.6 88.75,8.82 88.75,12.04 v4(88.87,12.17) ; v5(12.7,21.74) 12.5,21.74 11.99,22.25 11.99,26.11 13.91,28.03 v5(14.21,28.03)
  IN3 w0.508: v3(18.22,13.57) 15.24,13.57 13.59,15.22 13.59,19.13 12.7,20.02 v5(12.7,21.74) ; v3(59.86,23.29) 60.58,22.57 60.58,18.57 63.69,15.46 63.69,10.44 63.34,10.09 v9(62.1,10.09)
  GND4 w0.254: v9(62.1,10.09) v6(61.85,10.09)
  IN4 w0.508: v6(69.61,10.53) 69.47,10.67 68.75,10.67 68.16,10.09 v6(61.85,10.09) 48.61,10.09 47.8,10.9 v4(46.43,10.9)
  BOTTOM w0.254: PR25.2 45.02,6.64 45.3,6.92 45.3,7.37 v10(46.23,8.3) 46.43,8.5 v4(46.43,10.9)
  BOTTOM w0.381: v4(75.62,15.5) 75.78,15.5 76.29,16 76.29,16.65 CE196.2 CE197.2 75.23,16.36 v4(75.45,16.14)
  BOTTOM w0.508: JIO1.H9 5.86,16.72 8.99,19.85 RE717.2 9.27,20.22 10.79,21.74 v5(12.7,21.74)
+3VS: length 370.2
  TOP w0.254: RM81.1 72.54,145.97 v1(72.28,146.23) ; RF5.2 RF2.2 v8(86.68,17.05) ; RH605.1 88.49,22.81 88.49,22.74 88.11,22.35 v1(88.01,22.35) ; RH605.1 RH604.1 88.93,24.01 RH1026.1 88.44,24.54 v8(87.68,25.3) ; RH605.1 88.76,22.67 88.93,22.51 89.28,22.51 89.5,22.29 RH1028.1 RH1033.1 RH1030.1 ; v6(106.77,17.85) 107.06,17.55 QH5.2 107.06,16.92 106.81,16.66 106.5,16.66 105.92,16.08 105.92,15.18 106.17,14.92 106.67,14.92 107.06,15.32 QH5.5 ; RE84.1 79.12,7.43 v4(78.85,7.16) ; R181.1 59.83,62.77 61.09,62.77 61.95,63.63 61.95,69.56 62.42,70.03 62.42,70.56 v8(62.29,70.69) 61.13,69.53 U2407.1 ; v3(148.84,127.8) 149.09,127.8 149.58,127.31 149.58,126.52 PRZ40.1 ; v8(72.3,37.43) 71.56,36.69 71.56,35.04 PRV59.1 ; PRV30.1 v1(72.26,19.61)
  TOP w0.381: v8(72.3,67.6) 73.28,68.58 73.84,68.58 v8(74.48,69.22) ; v6(139.14,50.95) 139.81,50.95 RH525.1
  TOP w0.508: RH5.1 88.36,28.26 v5(87.88,28.73) 87.88,30.5 88.63,31.24 RH601.1 ; v3(70.26,133.01) RM86.1 72.31,133.01 73.18,132.35 73.2,132.21 73.2,132.21 CM31.1 73.21,132.2 73.22,132.2 73.27,132.16 73.27,131.53 73.34,131.46 73.77,130.86 74.5,130.13 74.5,129.93 75.16,129.28 RT729.1 ; PRW15.1 6.13,22.79 6.64,22.28 RG1600.2 6.9,21.99 7.4,21.48 v5(7.77,21.48) 8.04,21.21 8.67,21.21 QG525.2 ; v6(102.49,21.16) RH501.1 ; QX2.1 124.87,141.12 125.12,141.38 v5(125.37,141.38) ; QX3.1 129.39,140.34 v5(130.2,140.34)
  IN1 w0.254: v8(71.69,13.5) 71.69,11.9 68.59,8.8 67.84,8.8 67.41,8.38 59,8.38 58.24,7.62 58.24,3.71 57.51,2.97 55.12,2.97 54.66,3.43 49.73,3.43 49.28,2.97 47.47,2.97 46.02,4.42 46.02,5.41 46.35,5.74 v4(46.61,5.74) ; v8(87.68,25.3) 87.26,25.73 87.26,28.1 v5(87.88,28.73) ; v5(74.1,37.37) 72.36,37.37 v8(72.3,37.43) ; v8(86.68,17.05) 86.68,17.9 v1(86.64,17.93)
  IN1 w0.381: v5(79.25,70.87) 76.61,70.87 74.96,69.22 v8(74.48,69.22) ; v8(72.3,67.6) 69.42,64.72 64.21,64.72 62.36,66.58 62.36,70.63 v8(62.29,70.69)
  GND2 w0.254: v12(72.26,19.2) v1(72.26,19.61) ; v1(88.01,22.35) 87.78,22.13 v12(87.58,22.13) ; v12(86.64,18.47) v1(86.64,17.93)
  GND2 w0.381: v1(72.28,146.23) 72.31,146.23 72.31,146.2 72.54,146.2 v3(72.95,145.8)
  IN2 w0.254: 71.65,13.59 72.26,14.2 v12(72.26,19.2) ; v12(86.64,18.47) 86.64,21.19 v12(87.58,22.13)
  IN2 w0.381: v4(5.86,5.44) 5.86,6.01 6.6,6.76 8.51,6.76 9.27,7.52 9.27,9.68 9.65,10.06 9.65,11.84 8.64,12.85 6.99,12.85 6.34,13.5 6.34,16.77 7.82,18.25 v5(8.76,18.25) ; v5(79.25,70.87) 78.11,70.87 77.6,70.36 v4(77.6,65.66)
  IN2 w0.508: 147.47,29.39 147.47,28.44 145.76,26.73 v3(143.95,26.73) ; 147.47,29.39 v5(148.36,29.39) ; 147.47,29.39 147.47,32.06 146.84,32.69 146.84,38.79 144.51,41.11 144.51,46.24 139.8,50.95 v6(139.14,50.95)
  IN3 w0.381: v5(79.25,70.87) v3(80.95,70.87)
  IN3 w0.508: v3(143.95,26.73) 142.71,26.73 140.4,24.41 139.23,24.41 138.31,23.49 138.31,12.95 v5(137.27,11.92) ; v9(95.77,25.07) 94.92,25.07 94.46,25.53 v9(93.95,25.53)
  GND4 w0.381: v4(111.57,138.86) v3(111.57,138.85)
  GND4 w0.508: v9(93.95,25.53) v4(93.2,25.53) ; v9(95.77,25.07) v4(96.02,25.07)
  IN4 w0.254: v6(106.77,17.85) 106.77,19.5 v5(106.3,19.97) ; v5(107.44,24.22) 107.66,24.01 v7(108.94,24.01)
  IN4 w0.381: v7(25.12,136.61) 25.51,137 28.42,137 28.8,137.38 28.8,139.09 29.87,140.16 32.63,140.16 34.07,141.6 55.97,141.6 58.37,139.2 58.37,137.94 v5(58.86,137.44) ; v4(77.6,65.66) 78.69,64.57 v7(78.69,62.56) 78.71,62.54 v7(78.71,57.89)
  IN4 w0.508: v7(103.54,20.68) 102.97,20.68 v6(102.49,21.16) 102,20.68 100.61,20.68 100.46,20.53 99.37,20.53 v7(98.97,20.93) ; v6(139.14,50.95) 139.14,49.55 138.7,49.1 138.7,48.02 136.19,45.52 131.22,45.52 128.27,42.57 126.09,42.57 125.22,41.71 v5(125.22,41.11)
  BOTTOM w0.254: RH600.2 108.76,25.63 109.3,25.1 109.3,24.36 v7(108.94,24.01) ; RG534.1 76.03,58.69 76.35,59 76.82,59 77.93,57.89 v7(78.71,57.89) ; RH1023.1 97.71,18.6 97.38,18.93 97.38,21.4 97.79,21.81 ; v5(87.88,28.73) 84.68,28.73 84.4,28.45 84.4,25.54 RM18.1 ; RH537.2 102.84,30.09 102.49,29.74 102.49,27.61 101.6,26.72 101.6,26.06 102.03,25.63 RH520.1 RH517.1 RH521.1 ; 76.83,10.06 76.83,9.17 77.47,8.54 77.47,7.52 77.97,7.03 78.71,7.03 v4(78.85,7.16) ; v4(46.61,5.74) 46.22,5.74 PR1813.1 ; RP5.1 107.7,20.75 107.95,21 107.95,22.13 107.44,22.63 v5(107.44,24.22) ; RE656.1 77.77,10.19
  BOTTOM w0.356: v4(93.2,25.53) 93.2,25.7 92.22,26.68 UM4.12 ; UH3.5 13.46,16.17 12.71,16.17 CH201.1 ; RV16.1 121.4,139.04 121.64,139.04 123.09,140.49 123.09,140.74 123.24,140.9 v5(123.28,140.9) ; RV671.2 v4(111.57,138.86)
  BOTTOM w0.381: UM4.9 92.22,35.26 CM30.1 v4(92.94,35.29) ; v4(77.6,65.66) 77.9,65.97 RG561.1 ; v7(78.69,62.56) 78.87,62.38 RG506.1 ; 89.15,26.25 89.62,26.72 UM4.16 ; RH537.2 103.02,31 103.6,31.58 103.6,31.59 v5(103.59,31.59) ; CH201.1 12.24,16.18 v5(11.96,16.46) ; UM4.5 89.62,35.26 CM33.1 ; v5(107.44,24.22) 107.12,24.54 107.12,25.36 RH85.2 ; RH602.1 109.76,32.11 109.76,32.78 110.05,33.07 v5(110.05,33.19) ; v4(96.02,25.07) RH606.1 ; v4(74.12,95.23) 73.71,94.82 73.71,93.39 72.87,92.55 CG7105.1 72.49,93.1 72.11,93.48 UG46.5
  BOTTOM w0.508: RE20.2 v5(137.27,11.92) ; v5(87.76,41.27) 87.21,41.82 R370.1 ; R369.1 83.03,34.88 v5(82.98,34.82) ; v7(98.97,20.93) 98.67,20.93 97.79,21.81 97.79,22.4 97.37,22.82 96.58,22.82 96.39,22.63 95.76,22.63 95.55,22.85 95.55,23.56 96.02,24.04 RH606.1 ; RM20.1 RM96.1 87.74,36.72 v5(87.95,36.92) ; RC62.2 RC63.2 125.36,43.69 125.27,43.6 125.27,41.74 125.22,41.7 v5(125.22,41.11) ; 89.15,26.25 88.76,25.86 CM21.1
  vias: v1(64.49,147.31) v1(66.07,133.01) v1(67.35,144.89) v1(69.82,13.62) v1(69.82,13.24) v1(69.82,12.85) v1(72.54,143.89) v1(78.09,150.59) v1(102.68,144.62) v1(103.12,144.62) v3(12.7,25.17) v3(12.7,24.67) v3(12.7,24.16) v3(61.66,19.14) v3(61.66,18.63) v3(62.17,19.14) v3(62.17,18.63) v3(62.67,19.14) v3(62.67,18.63) v3(64.49,147.31) v3(66.07,133.01) v3(67.35,144.89) v3(71.88,12.28) v3(71.88,11.78) v3(72.39,12.28) v3(72.39,11.78) v3(72.54,143.89) v3(72.9,12.28) v3(72.9,11.78) v3(78.09,150.59) v3(102.68,144.62) v3(103.12,144.62) v4(73.24,12) v4(73.32,11.7) v4(73.56,12) v4(73.62,11.7) v4(74.07,12.02) v4(74.07,11.7) v5(9.35,18.25) v10(124.94,40.57) v12(70.1,13.62) v12(70.1,13.24) v12(70.1,12.85)
+3VS_CAMERA: length 176.5
  IN2 w0.508: v4(82.22,23.84) 82.45,24.07 82.69,24.07 84.86,26.24 84.86,31.04 85.5,31.68 85.5,42.29 83.11,44.68 83.11,59.08 84.02,60 84.02,87.13 v3(84.55,87.66)
  IN3 w0.508: v3(84.55,87.66) 84.55,96.09 77.12,103.52 77.12,113.97 71.34,119.75 71.34,120.94 68.73,123.55 67.61,123.55 64.89,126.27 64.89,140.49 63.8,141.59 62.34,141.59 57.85,146.08 47.65,146.08 46.61,147.12 41.05,147.12 39.72,148.44 v5(39.72,153.06)
  BOTTOM w0.254: v5(39.72,153.06) 39.72,152.15 39.75,152.12 JEDP.33
  BOTTOM w0.762: UV1.3 79.12,14.32 77.14,16.3 77.14,17.43 77.3,17.58 78.22,18.5 78.22,18.66 79.59,20.03 79.59,20.97 v2(81.09,22.47) 81.74,23.12 81.74,23.36 v4(82.22,23.84)
+3VS_DP: length 1.4
  BOTTOM w0.081: v5(109.22,149.09) 108.27,149.09 v10(107.96,148.78)
+3VS_SSD: length 7.8
  BOTTOM w0.254: R364.2 122.28,11.81 121.17,10.71 119.92,10.71 C630.1
  BOTTOM w0.356: R363.2 93.88,11.42 93.47,11.01 C617.1
  BOTTOM w0.508: C617.1 C621.1 C635.1
  vias: v5(93.22,12.02) v5(93.78,12.02) v5(110.57,12.17) v5(111,12.6) v5(118.29,12.45) v5(118.77,12.75) v5(118.77,12.12) v5(129.78,11.98) v5(132.02,12.57) v5(132.02,11.99) v10(93.08,12.96) v10(112.7,12.84) v10(119.39,12.63)
+3VS_TOUCH: length 70.3
  TOP w0.081: v5(89.09,19.29) 88.78,19.6 v10(88.65,19.6)
  TOP w0.203: 75.86,2.64 75.82,2.68 74.65,2.68 74.23,2.26
  TOP w0.254: 74.23,2.26 72.06,2.26 v1(70.29,4.03) 68.95,4.03 68.28,3.36 62.26,3.36 60.31,5.3 JTP17.1 ; JTP15.8 79.66,4.05 79.38,3.76 79.38,3.01 79.01,2.64 75.86,2.64 ; RE100.1 v8(74.09,11.52)
  IN1 w0.254: v8(74.09,11.52) 72.86,10.29 72.52,10.29 v6(72.34,10.11) 72.16,10.29 71.66,10.29 70,8.63 70,8.14 v11(69.76,7.9)
  GND2 w0.254: v12(69.7,7.65) 69.7,7.84 v11(69.76,7.9) ; v1(70.29,4.03) 70.23,4.09 v12(69.85,4.09)
  IN2 w0.254: v12(69.7,7.65) 69.7,4.24 v12(69.85,4.09)
  IN3 w0.254: v4(95.3,19.33) 94.56,20.07 92.84,20.07 92.48,19.71 92,19.71 91.82,19.89 90.12,19.89 89.52,19.29 v5(89.09,19.29) 87.02,19.29 85.4,17.68 84.4,17.68 84.15,17.43 v9(83.69,17.43)
  GND4 w0.254: v9(83.69,17.43) 83.07,17.43 v4(83.06,17.44)
  IN4 w0.254: v4(83.06,17.44) 83.49,17.01 83.49,16 83.85,15.65 83.85,15.39 82.38,13.93 81.63,13.93 81.48,14.07 80.06,14.07 79.92,13.92 79.92,13.03 80.79,12.16 80.79,10.82 80.29,10.31 78.18,10.31 77.75,9.88 77.66,9.88 77.65,9.89 77.36,9.89 77.35,9.88 75.39,9.88 75.11,9.6 73.94,9.6 73.43,10.11 v6(72.34,10.11)
  BOTTOM w0.356: RE33.1 83.29,17.21 v4(83.06,17.44)
+5V_TOBII: length 1.9
  TOP w0.081: v5(79.17,72.56) v10(79.17,73.14)
  TOP w0.508: UE12.1 v8(81.79,23.36) 81.79,23.13 v8(81.57,22.91)
  vias: v3(68.14,117.95) v3(68.14,117.38) v3(80.2,119.15) v3(80.2,118.59) v5(76.9,54.38) v5(76.9,53.75) v6(80.2,120.11) v6(80.2,119.73) v7(142.68,141.51) v7(143.07,141.51)
+5VALW: length 472.5
  TOP w0.254: PUZ7.3 132.81,130.22 v5(133.02,130) PRZ115.1 ; PUZ6.2 103.85,132.82 PRZ107.1 104.09,133.19 104.08,133.2 v5(104.08,133.78) ; v5(97.16,129.95) 96.95,130.15 PUZ2.15 ; PUZ6.15 105.62,130.19 v5(105.79,130.01) ; PUG01.15 141.55,86 141.36,86.18 PCG8.1 v8(141.03,85.38) ; v8(99.02,136.55) 99.97,136.55 100.34,136.92 PRZ97.1 ; PUZ10.3 v5(135.76,120.55) ; PUZ3.2 87.74,132.77 PRZ84.1 v5(87.96,133.63) ; PUZ2.2 95.22,132.89 PRZ83.1 95.44,133.11 v5(95.44,133.75) ; v5(89.59,129.77) 89.59,129.78 89.33,130.04 PUZ3.15 ; U20.3 85.34,111.02 v8(85.28,111.08) ; PUZ5.2 112.17,132.89 PRZ106.1 112.41,133.19 112.39,133.2 v5(112.39,133.78) ; v5(114.17,130.01) 114,130.19 PUZ5.15
  TOP w0.305: v5(141.68,101.27) 141.72,101.24 v8(142.68,101.24) ; PUZ9.2 130.06,118.79 v5(130.07,118.78) ; v8(84.1,112.02) 84.1,108.27 85.16,107.21 U19.3 ; U16.3 90.44,17.35 89.85,17.93 ; PUZ8.2 128.33,128.89 v5(128.49,128.73) ; PCZ117.1 127.69,116.72 PUZ9.15 ; PUZ8.15 126.1,127.24 125.68,126.82 v5(125.02,126.82)
  TOP w0.381: v5(58.88,136.78) 58.45,136.78 57.91,137.31 57.91,139.49 57.53,139.87 54.92,139.87 53.63,141.15 50.62,141.15 50.29,141.48 RM91.1 RM92.1 49.43,141.76 48.92,141.25 45.08,141.25 44.45,141.88 RM93.1 RM94.1 ; v4(101.35,137.95) 101.35,137.42 100.85,136.92 PRZ97.1
  TOP w0.508: PCZ117.1 v5(127.39,115.24) 130.82,115.24 132.21,116.63 PRZ130.1 v5(133.18,117.38) 133.18,118.76 133.44,119.01 PRZ131.2 PRZ135.1 134.81,117.88 135.17,117.52 136.1,117.52 136.46,117.88 PRZ139.1 137.29,119.01 137.74,119.47 v5(137.74,120.23) PRZ143.1 PRZ37.1 ; v5(7.86,22.32) 8.06,22.32 8.57,22.82 PR8.1 ; v1(82.59,5.16) 81.64,5.16 RE28.1 ; RG511.1 7.61,2.01 7.81,1.81 9.39,1.81 v1(9.39,2.75) ; v6(89.36,18.25) 89.53,18.25 89.85,17.93 ; RG1604.1 RG1606.1 75.07,63.1 77.69,60.48 77.69,58.91 ; PCZ118.1 124.21,126.01 v5(125.02,126.82) ; 89.28,56.16 90.81,57.69 PR2506.1 ; v5(124.52,41.11) 123.77,41.11 123.34,41.54 123.34,43.6 JWDB.1
  IN1 w0.203: v8(141.03,85.38) 142.52,83.9 143.56,83.9 143.76,84.1 v8(143.76,84.3)
  IN1 w0.254: v8(2.59,43.87) 4.32,45.59 4.32,49.68 5.84,51.21 10.68,51.21 v3(10.81,51.34) v8(10.81,52.86) 12.05,54.1 v8(12.05,54.89) ; v3(71.96,24.77) 70.08,26.65 70.08,29.34 69.65,29.77 69.65,30 69.32,30.33 65.99,30.33 65.56,30.76 59.92,30.76 57.33,28.17 54.41,28.17 53.85,27.61 v11(53.59,27.61) ; v6(76,12.19) 76,11.38 76.17,11.2 76.17,9.22 76.43,8.97 v11(77.9,8.97) ; v5(141.68,101.27) 141.68,100.03 140.36,98.71 140.36,91.29 139.73,90.66 139.73,86.69 v8(141.03,85.38) ; v8(84.1,112.02) 85.04,111.08 v8(85.28,111.08)
  IN1 w0.381: v5(87.96,133.63) 87.96,131.27 89.46,129.77 v5(89.59,129.77)
  IN1 w0.508: v5(135.76,120.55) 137.43,120.55 v5(137.74,120.23) ; v11(62.92,113.06) 62.92,118.04 61.65,119.31 60.71,119.31 59.56,120.45 v11(59.56,120.5) ; v5(125.02,126.82) 125.02,127.46 125.55,127.99 126.73,127.99 127.47,128.73 v5(128.49,128.73) ; v8(85.28,111.08) 85.86,111.08 86.07,110.87 88.69,110.87 90.27,109.29 v4(90.27,109.24)
  GND2 w0.254: v11(77.9,8.97) 78.14,9.21 v4(78.18,9.21) ; v11(53.59,27.61) 53.47,27.61 v3(53.3,27.78)
  GND2 w0.508: v12(63.08,112.51) 63.08,112.89 v11(62.92,113.06) ; v1(82.59,5.16) 82.4,5.16 v3(81.9,5.65) ; v12(9.39,3.2) v1(9.39,2.75) ; v12(59.35,120.72) v11(59.56,120.5)
  IN2 w0.254: v6(69.85,14.15) v3(68.43,14.15)
  IN2 w0.508: v5(141.68,101.27) 140.97,101.98 140.97,105.25 142.19,106.47 142.19,111.31 136.12,117.38 v5(133.18,117.38) ; v12(9.39,3.2) 9.39,4.03 10.13,4.78 10.13,7.98 11.3,9.15 11.3,11.4 v4(10.66,12.04) 8.41,14.29 v5(7.68,14.29) ; v6(74.14,108.26) 69.75,108.26 67.01,111 64.59,111 v12(63.08,112.51) ; v12(59.35,120.72) 58.17,121.9 58.17,124.87 59.51,126.22 59.51,136.15 v5(58.88,136.78)
  IN3 w0.152: v5(114.17,130.01) 114.64,130.01 115.27,129.39 115.27,125.81 115.57,125.5 122.19,125.5 123.52,126.82 v5(125.02,126.82)
  IN3 w0.254: v5(89.59,129.77) 89.76,129.77 91.11,131.12 95.99,131.12 v5(97.16,129.95) 97.49,129.95 99.14,131.6 104.2,131.6 v5(105.79,130.01) 106.08,130.01 107.34,131.27 112.8,131.27 114.06,130.01 v5(114.17,130.01)
  IN3 w0.508: v5(135.76,120.55) 133.86,122.45 133.86,126.24 133.1,127 v5(133.1,127.56) ; v9(70.54,99.21) 70.54,97.34 67.82,94.62 67.82,87.2 v3(67.06,86.44) ; v3(81.9,5.65) 81.9,5.69 85.36,9.15 v9(85.36,9.55) ; v9(91.77,18.19) 91.31,18.65 v9(91.31,19.23)
  GND4 w0.254: v4(52.83,27.61) 53.14,27.61 v3(53.3,27.78) ; v6(91.44,19.71) 91.44,19.36 v9(91.31,19.23)
  GND4 w0.508: v6(85.54,9.74) v9(85.36,9.55) ; v6(91.95,17.6) 91.82,17.73 91.82,18.14 v9(91.77,18.19) ; v9(70.54,99.21) v4(70.54,99.6)
  IN4 w0.203: v7(68.01,13.91) 67.42,14.49 v7(66.67,14.49)
  IN4 w0.254: v7(98.7,140.12) 98.2,140.62 98.2,141.35 97.81,141.74 v4(97.81,142.12) ; v6(76,12.19) 75.01,12.19 74.13,13.07 70.93,13.07 v6(69.85,14.15)
  IN4 w0.508: v4(70.54,99.6) 70.54,99.77 74.14,103.38 v6(74.14,108.26) ; v5(124.52,41.11) 124.52,39.23 128.91,34.85 133.13,34.85 134.42,33.56 134.42,32.79 ; v5(130.07,118.78) 129.6,118.78 127.39,116.58 v5(127.39,115.24) ; v6(85.54,9.74) 85.54,9.74 86.47,9.74 88.03,11.29 88.03,12.21 88.72,12.89 89.63,12.89 90.48,13.75 90.48,16.79 91.3,17.6 v6(91.95,17.6) 95.42,17.6 95.87,17.15 101.51,17.15 v7(102.23,17.88)
  BOTTOM w0.203: U17.4 v7(68.01,13.91)
  BOTTOM w0.254: v4(52.83,27.61) 52.46,27.98 51.6,27.98 50.94,28.64 50.94,31.23 51.42,31.71 v4(51.74,31.71) ; v5(104.08,133.78) PCZ88.1 ; UZ45.4 v4(78.18,9.21) ; UT4.H10 v4(97.81,142.12)
  BOTTOM w0.381: PCZ56.1 88.01,133.58 v5(87.96,133.63) 87.96,133.76 88.6,134.39 94.79,134.39 v5(95.44,133.75) 96.67,134.97 96.67,135.54 v10(96.95,135.83) 96.95,136.88 97.66,137.59 98.58,137.59 ; 99.26,137.47 99.26,136.93 100.03,136.17 PRZ96.1 ; v5(101.98,137.95) 102.08,137.85 102.08,135.82 101.61,135.35 PRZ91.1 PRZ85.2 101.5,134.38 103.48,134.38 v5(104.08,133.78) 104.7,133.78 105.23,134.32 111.86,134.32 v5(112.39,133.78)
  BOTTOM w0.508: PRZ3.1 133.05,128.22 PRZ120.1 133.05,129.98 v5(133.02,130) ; PRZ3.1 132.19,128.17 PRZ113.1 130.89,128.41 PRZ108.2 129.86,128.34 PRZ129.1 129.24,128.73 v5(128.49,128.73) ; PRZ3.1 v5(133.1,127.56) ; C2521.1 v5(124.52,41.11) ; PCZ55.1 v5(95.44,133.75) ; PCA2.1 140.9,101.29 PRA3.1 v5(141.68,101.27) ; PCZ89.1 v5(112.39,133.78) ; v5(88.85,98.33) 88.85,98.78 90.5,100.43 v10(90.5,103.3) 90.5,109.01 v4(90.27,109.24) ; RE158.1 102.23,19.96 v7(102.23,17.88) 102.22,17.86 102.22,17.44 102.02,17.24 RE156.1 102.02,15.99 102.18,15.83 102.18,13.35 RE154.1
  vias: v1(86.13,25.38) v3(6.22,18.44) v3(84.52,55.46) v3(84.52,54.98) v3(86.13,25.38) v3(91.11,24.03) v3(102.62,137.95) v3(103.12,137.95) v3(103.63,137.95) v3(104.14,137.95) v3(105.41,138.2) v3(106.05,138.2) v3(106.74,138.2) v3(141.1,41.94) v3(141.1,41.43) v4(6.22,18.44) v5(3.99,16.12) v5(3.99,15.55) v5(3.99,14.98) v5(3.99,14.4) v5(4.56,16.12) v5(4.56,15.55) v5(4.56,14.98) v5(4.56,14.4) v5(7.05,14.29) v5(59.94,15.33) v5(59.94,14.76) v5(59.94,14.19) v5(59.94,13.62) v5(59.94,13.05) v5(60.52,15.33) v5(60.52,14.76) v5(60.52,14.19) v5(60.52,13.62) v5(60.52,13.05) v5(61.09,15.33) v5(61.09,14.76) v5(61.09,14.19) v5(61.09,13.62) v5(61.09,13.05) v5(61.66,15.33) v5(61.66,14.76) v5(61.66,14.19) v5(61.66,13.62) v5(61.66,13.05) v5(62.23,15.33) v5(62.23,14.76) v5(62.23,14.19) v5(62.23,13.62) v5(62.23,13.05) v5(62.8,15.33) v5(62.8,14.76) v5(62.8,14.19) v5(62.8,13.62) v5(62.8,13.05) v5(88.21,84.64) v5(88.52,55.91) v5(88.62,85.07) v5(88.93,55.5) v5(105.79,137.7) v5(106.43,137.7) v5(107.06,137.7) v5(107.7,137.7) v5(134.63,30.64) v5(135.15,32.54) v5(135.21,30.64) v5(135.7,32.36) v5(136.25,32.53) v5(149.92,43.33) v5(149.92,42.76) v6(91.11,24.03) v7(144.72,27.84) v7(144.72,27.52) v7(144.91,27.26) v7(145.1,27.84) v7(145.1,27.52) v8(77.62,58.38) v8(77.99,58.38) v10(2.18,15.43) v11(84.52,55.46) v11(84.52,54.98) v11(141.1,41.94) v11(141.1,41.43)
+5VALW_LED: length 78.6
  TOP w0.081: v5(146.37,23.97) v2(145.73,23.97)
  TOP w0.254: QE8.1 85.08,6.12 v8(85.5,5.7)
  IN1 w0.254: v5(146.37,23.97) 145.22,22.82 139.7,22.82 138.69,21.81 138.69,12.4 136.47,10.19 119.65,10.19 118.91,10.93 111.61,10.93 110.74,10.06 98.35,10.06 97.76,9.48 95.22,9.48 94.31,10.39 91.28,10.39 88.04,7.14 88.04,6.84 87.38,6.17 86.33,6.17 85.86,5.7 v8(85.5,5.7)
  BOTTOM w0.254: v5(146.37,23.97) 147.14,24.74 JIO2.H9
+5VALWP: length 11.7
  TOP w0.254: PU501.8 51.88,23.26 PR511.1
  TOP w0.508: PR511.1 51.75,22.37 v14(51.7,22.32) 51.5,22.11 v2(51.5,21.28) 51.5,15.27 52.51,14.25 53.02,14.25
  vias: v5(53.28,15.52) v5(53.85,15.52) v5(54.42,15.52) v5(55.05,15.52) v5(55.69,15.52) v5(56.26,15.52) v5(56.9,15.52) v5(56.9,14.89) v5(56.9,14.25) v5(57.53,15.52) v5(57.53,14.89) v5(57.53,14.25) v5(58.04,15.2) v5(58.04,14.57)
+5VS: length 391.7
  TOP w0.127: v5(78.59,125.99) v10(78.59,126.66)
  TOP w0.254: v5(53.15,44.2) 53.17,44.2 53.33,44.05 PUV9.15 ; v5(37.85,44.22) 38.02,44.05 PUV6.15 ; v5(10.91,42.19) 11.37,42.19 11.76,41.8 PRW47.1 12.41,41.82 PRW53.1 13.27,41.85 PCW31.1 14.35,42.07 PUW3.15 ; PUW2.15 6.65,62.6 5.75,63.5 5.65,63.5 5.37,63.78 4.67,63.78 4.15,64.3 3.73,64.3 v5(3.47,64.04) 3.25,64.04 2.83,63.62 PRW43.1 ; v5(45.47,44.22) 45.64,44.05 PUV7.15 ; PUV11.15 73.93,79.7 v5(74.1,79.88) ; v1(87.58,23.27) 87.58,24.18 86.93,24.84 86.57,24.84 85.8,24.07 RF3.2 ; v5(68.52,44.16) 68.63,44.05 PUV10.15
  IN1 w0.508: v5(69.19,78.49) 69.43,78.49 71.12,80.18 72.52,80.18 72.82,79.88 v5(74.1,79.88)
  IN1 w1.016: 40.39,151.16 46.48,151.16 48.09,149.55 56.66,149.55 61.88,144.33 66.87,144.33 67.04,144.15 68.23,144.15 71.65,147.58 75.02,147.58 75.63,146.97 82.56,146.97 82.94,146.59 82.98,146.59 84.02,145.54 86.02,145.54 87.01,146.54 88.74,146.54 88.86,146.42 90.19,146.42 90.45,146.67 95.97,146.67 96.75,145.9 98.79,145.9 99.14,146.24 102.93,146.24 107.04,142.14 108.66,142.14 109.51,142.99
  GND2 w0.254: v1(23.47,44.05) 23.7,44.05 23.72,44.07 v3(23.93,44.07) ; v1(31.03,44.05) v3(30.61,44.05) ; v12(87.5,22.76) 87.5,23.19 v1(87.58,23.27) ; v3(61.18,44.3) 61.43,44.05 v1(61.63,44.05)
  IN2 w0.254: v12(87.5,22.76) 87.5,22.58 86.13,21.21 86.13,16.69 v3(86.69,16.13)
  IN2 w1.016: 43.43,140.62 42.19,141.86 40.26,141.86 38.48,143.64 38.48,147.68 40.13,149.33 40.13,151.41 ; 68.01,77.75 65.53,77.75 63.5,75.72 63.25,75.72
  IN3 w0.254: v9(82.99,2.44) 82.93,2.5 v9(79.41,2.5)
  IN3 w0.381: 60.9,47.78 61.21,48.1 66.87,48.1 68.52,46.45 v5(68.52,44.16) ; 60.9,47.78 60.58,48.1 53.4,48.1 53.15,47.84 ; 60.9,47.78 60.9,44.58 v3(61.18,44.3) ; 37.85,47.59 38.42,48.16 45.09,48.16 45.47,47.78 ; 37.85,47.59 37.34,48.1 30.67,48.1 30.29,47.72 ; 37.85,47.59 v5(37.85,44.22) ; 30.29,47.72 29.97,48.03 22.52,48.03 22.03,47.55 ; 30.29,47.72 30.29,44.75 30.6,44.44 30.6,44.05 v3(30.61,44.05) ; 53.15,47.84 52.9,48.1 45.78,48.1 45.47,47.78 ; 53.15,47.84 v5(53.15,44.2) ; 45.47,47.78 v5(45.47,44.22)
  IN3 w0.508: v3(23.93,44.07) 23.43,44.57 23.43,44.86 22.03,46.26 22.03,47.55 21.53,48.06 11.91,48.06 ; 11.91,48.06 10.54,49.43 v3(5.71,49.43) ; 11.91,48.06 11.91,42.7 11.4,42.19 v5(10.91,42.19) ; v5(68.11,21.43) 68.52,21.43 69.02,20.92 69.02,14.06 70.21,12.88 v3(70.21,10.58)
  IN3 w1.016: 112.59,144.3 125.86,144.3 126.75,145.19 v5(126.75,149) v5(126.75,149.89) ; 61.21,122.9 61.21,122.91 61.21,137.51 58.45,140.27 57.84,140.27 57.73,140.38 51.79,140.38 51.24,140.93 45.66,140.93 45.11,140.38
  GND4 w0.254: v9(79.41,2.5) 79.35,2.57 v4(78.99,2.57) ; v3(30.61,44.05) 30.63,44.07 v4(31.2,44.07) ; v4(83.08,2.16) 82.99,2.25 v9(82.99,2.44) ; v6(66.36,92.99) 66.04,92.99 v9(66.01,93.02) ; v3(61.18,44.3) 61.42,44.54 v4(61.58,44.54)
  GND4 w0.381: v3(23.93,44.07) 23.72,44.27 v4(23.62,44.27)
  IN4 w0.254: v7(137.6,33.61) v7(137.6,32.5)
  IN4 w1.016: 62.04,74.7 62.04,64.86 64.07,62.83 66.48,62.83 68.52,60.8 68.52,51.65 69.79,50.38 69.79,44.77
  BOTTOM w0.203: UG45.4 66.48,93.14 66.36,93.02 v7(66.36,92.56)
  BOTTOM w0.254: v7(139.67,33.2) 138.7,32.22 137.88,32.22 v7(137.6,32.5) ; v5(3.47,64.04) 3.68,64.04 6.03,61.69 6.59,61.69 6.9,61.38 6.9,60.05 7.11,59.83 PCW15.1 ; CE86.1 89.09,5.81 88.57,5.29 85.85,5.29 84.23,3.66 84.23,3.3 v4(83.08,2.16)
  BOTTOM w0.381: v4(23.62,44.27) 23.98,43.92 23.98,43.72 24.15,43.55 24.16,43.55 PRV112.2 ; PRV156.1 54.32,43.5 54.32,43.82 PCV128.1 53.26,44.08 v5(53.15,44.2) ; v5(68.52,44.16) 68.76,44.4 PCV159.1 69.48,44.2 69.48,43.65 69.88,43.26 PRV178.1 ; v5(45.47,44.22) 45.63,44.39 PCV98.1 46.49,44.1 46.49,43.84 47,43.33 PRV134.1 ; PRV113.1 32.03,43.25 31.8,43.47 31.64,43.47 31.47,43.65 31.47,43.8 v4(31.2,44.07) ; v4(61.58,44.54) 61.89,44.24 61.89,44.05 62.04,43.9 62.04,43.71 62.41,43.34 PRV157.1 ; PRV135.1 39.38,43.32 38.84,43.87 38.84,44.2 PCV99.1 38.04,44.41 v5(37.85,44.22)
  BOTTOM w0.508: v5(74.1,79.88) 74.64,79.88 75.16,79.36 PCV161.1 ; 60.38,6.33 58.17,6.33 56.52,4.68 JPTRON.7 ; PRV179.1 v5(69.19,78.49) ; JPTRON.1 51.71,4.19 55.78,8.26 60.3,8.26 ; v5(68.11,21.43) PRV5.1
  vias: v3(75.13,5.54) v3(75.31,6) v3(75.67,5.51) v3(75.82,6) v4(75.13,5.54) v4(75.31,6) v4(75.67,5.51) v4(75.82,6) v5(40.39,153.43) v5(40.39,152.83) v5(40.39,152.25) v5(43.61,139.49) v5(44.07,140.07) v5(44.18,139.49) v5(60.58,7.52) v5(60.58,6.95) v5(61.15,7.52) v5(61.15,6.95) v5(61.33,117.08) v5(61.49,118.16) v5(61.54,117.6) v5(61.72,7.52) v5(61.72,6.95) v5(61.79,75.72) v5(62.29,7.52) v5(62.29,6.95) v5(62.37,75.72) v5(78.59,124.92) v5(111.21,143.08) v5(111.75,143.26) v5(111.91,142.69) v5(144.06,39.54) v5(144.06,38.97) v5(144.61,38.99)
