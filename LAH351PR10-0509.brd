# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_PTX_DRX_N5: length 72.5
  TOP w0.089: v5(99.14,53.72) 99.52,53.34 99.52,47.32 99.71,47.13 UH1.C15
  IN2 w0.076: v5(99.14,53.72) 99.33,53.91 99.33,54.23 99.25,54.31 98.28,54.31 97.99,54.02 97.99,53.68 98.66,53.01 101.97,53.01 104.06,55.1 115.42,55.1 116.5,56.17 120.35,56.17 121.18,55.35 135.34,55.35 138.4,52.28 138.4,50.6 143.09,45.91 143.09,35.81 143.33,35.57 143.33,35.25 v4(143.54,35.04)
USB3_PTX_DRX_N6: length 85
  TOP w0.089: 100.17,49.77 100.15,49.8 100.15,50.89 100.97,51.71 v5(100.97,53.77)
  TOP w0.107: UH1.C16 100.33,47.14 100.17,47.5 100.17,49.77
  IN2 w0.076: v4(147.14,26.06) 146.94,26.26 146.94,26.71 147.46,27.23 149.28,27.23 150.88,28.83 150.88,32.12 149.71,33.28 149.71,37.51 151,38.81 151,41.82 150.45,42.37 149.67,42.37 135.23,56.81 116.12,56.81 115.36,56.05 102.15,56.05 101.16,55.05 101.16,53.97 v5(100.97,53.77)
USB3_PTX_DRX_N7: length 152.5
  TOP w0.089: 101.09,49.54 v8(101.09,49.57)
  TOP w0.107: 101.09,49.54 100.93,49.38 100.93,48.49 100.97,48.45 100.98,48.45 101.11,48.33 101.11,48.24 100.98,48.11 UH1.A17
  IN1 w0.076: 100.97,49.77 100.85,49.89 100.85,50.01 100.66,50.21 91.17,50.21 88.71,52.67 87.79,52.67 85.68,54.78 85.68,55.61 83.96,57.33 83.13,57.33 82.13,58.33 82.13,59.25 81.47,59.91 33.91,59.91 33.13,60.68 19.41,60.68 11.54,52.82 11.54,47.77 12.13,47.19 12.13,41.91 10.28,40.07 10.28,33.51 11.02,32.77 11.02,29.11 9.46,27.54 9.46,23.33 8.34,22.21 8.34,20.66 5,17.32 5,13.19 5.27,12.92 5.27,8.87 7.33,6.81 7.33,6.03 7.16,5.87 7.16,5.54 v4(7.06,5.44)
  IN1 w0.089: 100.97,49.77 100.97,49.69 v8(101.09,49.57)
USB3_PTX_DRX_N8: length 150.8
  TOP w0.089: UH1.B18 101.41,47.37 101.45,47.34 101.6,47.34 101.69,47.42 101.69,47.58 101.54,47.73 101.54,47.9 102.54,48.9 102.54,49.61 102.55,49.62 102.55,49.81 102.58,49.84 102.58,50.56 102.55,50.59 102.55,50.77 101.79,51.53 101.79,51.94 v8(101.88,52.03) ; v8(37.4,148.03) 37.31,148.12 37.31,148.31 37.45,148.45 JCDRA.42
  IN1 w0.076: v8(101.88,52.03) 101.79,52.12 101.79,52.15 101.44,52.5 96.55,52.5 96.25,52.8 94.26,52.8 93.75,53.32 90.06,53.32 87.54,55.84 87.54,68.87 84.51,71.91 84.51,84.71 88.53,88.74 88.53,95.48 72.72,111.29 71.39,111.29 66.88,115.81 66.88,117.24 66.18,117.94 66.18,119.75 65.68,120.25 63.87,120.25 61.77,122.34 61.77,124.13 60.77,125.13 60.77,133.89 58.42,136.24 58.42,140.24 57.91,140.76 56.15,140.76 54.92,141.99 40.56,141.99 37.31,145.24 37.31,147.94 v8(37.4,148.03)
USB3_PTX_DRX_P5: length 72.5
  TOP w0.089: UH1.B15 99.78,47.4 99.69,47.49 99.69,49.66 99.72,49.69 v5(99.72,53.72)
  IN2 w0.076: v5(99.72,53.72) 99.53,53.91 99.53,54.32 99.33,54.51 98.2,54.51 97.79,54.1 97.79,53.6 98.58,52.81 102.06,52.81 104.14,54.89 115.51,54.89 116.59,55.97 120.27,55.97 121.09,55.15 135.25,55.15 138.2,52.2 138.2,50.52 142.89,45.83 142.89,35.73 143.13,35.49 143.13,35.23 v4(142.94,35.04)
USB3_PTX_DRX_P6: length 84.9
  TOP w0.089: 100.37,49.77 100.37,50.83 101.17,51.63 101.17,53.39 101.51,53.73 v5(101.76,53.73)
  TOP w0.107: UH1.C17 100.53,47.18 100.38,47.55 100.38,48.43 100.37,48.44 100.37,49.77
  IN2 w0.076: v5(101.76,53.73) 101.71,53.69 101.43,53.69 101.36,53.76 101.36,54.97 102.23,55.84 115.44,55.84 116.2,56.61 135.14,56.61 149.58,42.17 150.37,42.17 150.8,41.73 150.8,38.89 149.5,37.59 149.5,33.2 150.67,32.03 150.67,28.92 149.19,27.43 147.37,27.43 146.74,26.8 146.74,26.25 146.66,26.18 146.6,26.18 146.54,26.12 v4(146.54,26.06)
USB3_PTX_DRX_P7: length 152.5
  TOP w0.089: v8(100.71,49.57) 100.71,49.57 100.71,49.44
  TOP w0.107: UH1.B17 100.65,47.7 100.65,48.42 100.71,48.48 100.71,49.43 100.71,49.44
  IN1 w0.076: 100.65,49.77 100.65,49.93 100.57,50 91.09,50 88.63,52.47 87.71,52.47 85.48,54.7 85.48,55.53 83.88,57.13 83.05,57.13 81.93,58.24 81.93,59.16 81.39,59.71 33.83,59.71 33.05,60.48 19.49,60.48 11.75,52.73 11.75,47.86 12.33,47.27 12.33,41.83 10.49,39.99 10.49,33.59 11.23,32.85 11.23,29.02 9.66,27.46 9.66,23.24 8.55,22.13 8.55,20.58 5.21,17.24 5.21,13.27 5.47,13 5.47,8.96 7.53,6.9 7.53,5.95 7.37,5.78 7.37,5.39 7.44,5.31 7.58,5.31 7.66,5.39 v4(7.66,5.44)
  IN1 w0.089: 100.65,49.77 100.65,49.63 v8(100.71,49.57)
USB3_PTX_DRX_P8: length 150.8
  TOP w0.089: v8(37.02,148.03) 37.11,148.12 37.11,148.31 37.05,148.37 JCDRA.43 ; v8(101.5,52.03) 101.59,51.94 101.59,51.44 102.35,50.68 v13(102.35,50.29) 102.35,49.8 102.36,49.78 102.36,48.97 101.12,47.73 101.12,47.28 UH1.C18
  IN1 w0.076: v8(101.5,52.03) 101.5,52.04 101.5,52.14 101.35,52.3 96.47,52.3 96.17,52.6 94.18,52.6 93.66,53.11 89.98,53.11 87.34,55.76 87.34,68.79 84.3,71.82 84.3,84.8 88.33,88.82 88.33,95.39 72.63,111.09 71.31,111.09 66.67,115.72 66.67,117.15 65.98,117.85 65.98,119.66 65.6,120.04 63.79,120.04 61.57,122.26 61.57,124.04 60.57,125.05 60.57,133.8 58.22,136.15 58.22,140.16 57.82,140.55 56.07,140.55 54.84,141.79 40.48,141.79 37.11,145.16 37.11,147.94 v8(37.02,148.03)
USB20_N1: length 117.1
  TOP w0.089: UH1.J3 93.95,44.08
  TOP w0.107: 93.95,44.08 93.89,44.14 93.53,44.14 93.42,44.03 93.03,44.03 92.72,43.73 91.75,43.73 91.69,43.78 91.23,43.78 91.12,43.89 91.12,44.39 v8(91.15,44.42)
  IN1 w0.076: 89.47,39.2 89.45,39.19 89.45,39.17 88.96,38.68 88.96,36.86 88.14,36.03 85.81,36.03 85.13,35.35 85.13,26.59 84.59,26.06 84.59,21.81 81.86,19.08 73.47,19.08 69.48,15.09 69.48,12.63 66.66,9.81 12.37,9.81 10.73,8.17 10.73,5.17 10.34,4.78 9.28,4.78 9.08,4.97 9.08,5.22 v4(8.86,5.44)
  IN1 w0.089: 89.47,39.2 89.81,39.55 89.81,42.85 90.55,43.59 90.78,43.59 91.05,43.85 91.05,44.32 v8(91.15,44.42)
USB20_N2: length 56
  IN1 w0.076: 117.24,44.91 117.38,44.77 117.4,44.77 117.81,44.36 122.53,44.36 124.52,42.37 129.14,42.37 131.17,40.34 131.39,40.34 135.7,36.03 137.16,36.03 139.19,34 144.95,34 145.63,34.69 145.63,35.37 145.54,35.46 145.54,35.75 145.34,35.96 v4(145.34,35.96)
  IN1 w0.089: 117.24,44.91 116.79,45.37 113.03,45.37 112.75,45.65 112.05,45.65 111.76,45.94 111.76,46.25 110.95,47.06 110.04,47.06 109.02,46.05 107.77,46.05 107.58,46.24 106.48,46.24 104.83,44.59 102.8,44.59 102.35,44.15 101.78,44.15 101.46,43.83 100.76,43.83 99.47,42.53 99.47,42.39 99.32,42.24 v8(99.12,42.24)
USB20_N3: length 152.5
  TOP w0.089: UH1.K4 94.55,43.31 93.35,43.31 93.19,43.16 89.78,43.16 87.71,45.23 86.23,45.23 84.63,46.82 84.63,50.98 86.02,52.36 v13(87.11,52.36) 90.38,52.36 90.72,52.7 v8(90.72,53.88)
  IN1 w0.076: v8(38.1,145.58) 38.1,145 39.03,144.07 45.44,144.07 45.75,143.77 55.62,143.77 56.56,142.83 57.48,142.83 59.99,140.31 59.99,135.26 61.18,134.08 61.18,126.4 62.15,125.42 62.15,122.72 64,120.88 65.61,120.88 67.93,118.56 67.93,115.35 71.56,111.72 72.82,111.72 88.95,95.6 88.95,88.95 88.93,88.93 88.93,88.57 84.89,84.53 84.89,72.09 87.92,69.05 87.92,57.55 90.72,54.76 v8(90.72,53.88)
USB20_N3_R: length 3.2
  TOP w0.089: JCDRA.40 38.25,148.37 38.28,148.34 v13(38.28,147.03) 38.28,146.36 LM1.2
USB20_N4: length 67
  IN1 w0.076: v5(119.63,21.54) 119.93,21.84 120.01,21.84 120.07,21.78 120.07,20.62 117.39,17.95 114.29,17.95 113.97,18.27 112.01,18.27 111.69,17.95 107.29,17.95 106.88,17.53 105.47,17.53 105.34,17.66 103.2,17.66 102.93,17.92 100.41,17.92 99.65,18.69 94.55,18.69 93.33,19.92 92.21,19.92 92.03,20.09 89.19,20.09 88.51,20.78 88.51,22.15 88.98,22.62 88.98,24.15 90.27,25.45 90.31,25.45 90.32,25.46
  IN1 w0.089: 90.32,25.46 90.41,25.55 90.41,25.59 92.38,27.56 92.38,28.08 94.26,29.96 94.26,32.38 93.96,32.68 93.96,36.65 94.68,37.37 96.52,37.37 97.08,37.93 97.08,38.71 96.44,39.34 96.44,40.66 96.6,40.81 96.6,40.92 96.71,41.03 96.71,41.11 96.77,41.18 96.77,41.94 96.66,42.05 96.66,42.56 97.11,43 97.36,43 97.47,42.89 97.7,42.89 97.8,42.79 97.8,42.66 97.71,42.57 v8(97.62,42.57)
  BOTTOM w0.089: UE1.32 118.86,21.58 119.01,21.73 119.44,21.73 v5(119.63,21.54)
USB20_N7: length 111.9
  TOP w0.107: v5(92.01,41.29) 92.21,41.49 92.51,41.49 93.2,42.17 93.2,42.45 93.38,42.63 94.29,42.63 94.49,42.83 UH1.L4
  IN4 w0.076: 88.5,42.33 85.5,42.33 82.02,45.82 82.02,62.58 81.79,62.81 81.79,70.3 81.44,70.65 81.44,85.18 78.99,87.62 78.99,92.54 75.95,95.59 75.95,111.83 68.59,119.19 68.59,122.4 68.16,122.83 68.16,124.4 68.37,124.61 68.57,124.61 v7(68.65,124.68)
  IN4 w0.089: v5(92.01,41.29) 89.99,41.29 88.95,42.33 88.5,42.33
  BOTTOM w0.089: LV2.1 66,134.53 65.91,134.44 65.91,126.9 68.19,124.62 68.59,124.62 v7(68.65,124.68)
USB20_N7_R: length 33.3
  IN4 w0.076: v5(47.76,152.91) 47.57,152.72 47.57,152.32 48.61,151.28 51.49,151.28 57.84,144.93 57.84,141.32 58.96,140.19 60.75,140.19 60.84,140.27 60.84,140.41 v7(60.81,140.44)
  BOTTOM w0.089: v5(47.76,152.91) 47.59,152.73 47.59,152.34 47.59,152.34 47.59,152.07 47.75,151.91 JEDP.17 ; LV2.2 65.85,135.55 65.85,136.8 66.07,137.02 66.07,138.63 65.67,139.03 65.18,139.03 64.95,139.26 64.95,139.75 DV4.3 64.69,139.82 63.93,139.05 63.52,139.05 62.38,140.2 61.05,140.2 v7(60.81,140.44)
USB20_N8: length 73.8
  TOP w0.089: UH1.G4 94.68,45.45 v8(94.68,45.69)
  IN1 w0.076: 102.74,49.77 102.88,49.9 102.88,52.2 103.55,52.87 108.83,52.87 110.73,50.97 112.16,50.97 112.3,50.83 117.37,50.83 118.03,51.5 120.35,51.5 121.17,50.67 121.17,50.4 123.09,48.48 130.94,48.48 138.19,41.23 140.35,41.23 140.8,40.77 143.7,40.77 145.37,39.09 146.8,39.09 149.25,36.64 149.25,34.12 149.06,33.92 148.86,33.92 v5(148.67,33.73)
  IN1 w0.089: v8(94.68,45.69) 94.85,45.74 95.07,46.18 95.12,46.23 95.12,46.7 97.28,48.86 98.3,48.86 98.62,48.54 101.51,48.54 102.74,49.77
  BOTTOM w0.089: v5(148.67,33.73) 147.16,33.73 146.54,34.35 JIO2.B8
USB20_N9: length 191.7
  TOP w0.107: UH1.M6 95.52,42.46 95.64,42.58 95.64,43.03 v5(95.69,43.07)
  IN4 w0.076: v7(139.26,140.68) 139.22,140.68 138.94,140.4 138.94,139.32 140.03,138.23 141.91,138.23 142.6,137.55 142.6,136.65 141.53,135.59 141.53,135 140.29,133.77 137.52,133.77 136.06,135.23 129.36,135.23 129,135.6 121.51,135.6 120.98,136.13 101.71,136.13 100.63,135.05 100.39,135.05 100.18,135.26 99.43,135.26 99.26,135.08 93.93,135.08 93.47,135.54 89.63,135.54 89.25,135.16 85.72,135.16 84.52,136.36 78.37,136.36 76.02,138.71 75.15,138.71 74.85,138.42 74.85,137.6 73.33,136.08 73.33,134.37 74.52,133.18 74.52,117.08 77.77,113.83 77.77,104.58 83.82,98.54 83.82,73.21 84.57,72.46 84.57,46.84 85.34,46.07 88.5,46.07
  IN4 w0.089: v5(95.69,43.07) 95.69,44.3 95.05,44.94 91.36,44.94 90.23,46.07 88.5,46.07
  BOTTOM w0.089: v7(139.26,140.68) 139.34,140.59 139.66,140.59 RE647.1 140.16,140.78 LE3.4
USB20_N9_R: length 2.6
  BOTTOM w0.089: LE3.3 140.76,140.77 RE647.2 141.26,140.59 141.78,140.59 141.97,140.41 142.13,140.41 142.42,140.71 JTOBII.3
USB20_N10: length 41.4
  TOP w0.089: UH1.H3 94.12,44.57 94.12,44.45 94.02,44.35 93.65,44.35 93.64,44.34 ; v8(88.2,14.5) 88.24,14.5 88.42,14.33 88.42,13.99 89.22,13.19 89.22,12.93 89.2,12.92 89.2,12.31 89.6,11.92 89.6,11.35 LE7.4 89.43,11.18 RE200.1
  TOP w0.107: v8(92.61,44) 92.58,44.02 92.58,44.17 92.7,44.29 93.4,44.29 93.45,44.34 93.64,44.34
  IN1 w0.076: v8(88.2,14.5) 88.22,14.52 88.33,14.52 88.43,14.41 88.43,14.26 88.35,14.18 87.46,14.18 86.92,14.72 86.92,16.26 85.93,17.26 85.93,20.52 86.33,20.92 86.33,24.2 86.63,24.49 86.63,34.42 87.41,35.2 88.39,35.2 90.32,37.13
  IN1 w0.089: v8(92.61,44) 92.61,43.99 92.43,43.81 92.43,43.37 90.6,41.54 90.6,38.36 90.35,38.1 90.35,37.16 90.32,37.13
USB20_N10_R: length 26.6
  TOP w0.089: v8(88.97,6.79) 89.05,6.87 89.05,7.89 88.96,7.98 88.67,7.98 DK1.2 88.65,8.22 89,8.22 89.09,8.31 89.09,8.88 89.6,9.38 89.6,10.43 LE7.3 89.31,10.59 RE200.2
  IN1 w0.076: v11(71.88,6.7) 71.79,6.6 71.79,6.33 71.87,6.25 72.36,6.25 73.32,7.21 75.29,7.21 76.25,6.25 77.82,6.25 78.37,5.7 79.6,5.7 80.01,6.11 82.33,6.11 82.52,5.92 84.15,5.92 84.84,5.23 88.52,5.23 89.07,5.79 89.07,6.68 v8(88.97,6.79)
  GND2 w0.089: v11(71.88,6.7) 71.79,6.79 71.79,6.92 v3(71.95,7.08)
  GND4 w0.089: v4(71.95,7.42) 71.8,7.28 71.8,7.22 v3(71.95,7.08)
USB20_N11: length 150.4
  TOP w0.107: v5(97.62,42) UH1.R10
  IN2 w0.076: v5(91.17,136.68) 91.3,136.8 91.3,137.13 91.64,137.47 95.4,137.47 96.09,138.15 96.09,139.32 96.9,140.13 96.9,140.69 96.62,140.97 95.86,140.97 95.25,141.59 95.25,141.86 94.41,142.69 94.41,146.1 95.62,147.31 95.62,147.56 95.5,147.68 v4(95.06,147.68)
  IN4 w0.076: v5(91.17,136.68) 90.61,136.12 89.33,136.12 88.52,136.93 85.22,136.93 84.58,137.57 78.16,137.57 76.54,139.19 74.9,139.19 74.27,138.57 74.27,138.03 72.72,136.48 72.72,133.9 73.84,132.79 73.84,116.94 77.19,113.59 77.19,104.34 83.23,98.3 83.23,72.7 83.95,71.99 83.95,46.5 85.15,45.3 88.5,45.3
  IN4 w0.089: v5(97.62,42) 97.62,41.96 97.35,41.69 95.82,41.69 93.27,44.24 91.17,44.24 90.11,45.3 88.5,45.3
USB20_N11_R: length 4
  BOTTOM w0.089: UT4.K5 95.45,143.37 95.45,144.66 95.55,144.76 95.55,145.47 RT112.2 RT114.2
USB20_N14: length 81.5
  TOP w0.089: UH1.E5 95.4,46.05 v8(95.61,46.26)
  IN1 w0.076: v4(144.14,25.14) 144.03,25.25 144.03,25.36 144.16,25.49 144.3,25.49 144.58,25.22 144.58,24.8 144.91,24.46 146.86,24.46 149.71,27.31 149.71,31.17 148.22,32.65 148.22,36.78 146.5,38.51 143.41,38.51 141.88,40.03 140.69,40.03 140.14,40.58 138.01,40.58 130.79,47.81 122.39,47.81 120.02,50.17 114.91,50.17 114.89,50.14 113.73,50.14 113.7,50.17 113.36,50.17 113.28,50.09 112.17,50.09 ; 111.03,50.26 111.01,50.26 111,50.27 110.29,50.27 110.05,50.51 107.16,50.51 105.38,52.29 103.89,52.29 103.49,51.89 103.49,50.03 103.5,50.01 103.5,50
  IN1 w0.089: v8(95.61,46.26) 96.15,46.7 96.15,47.03 96.77,47.65 97.98,47.65 98.35,48.02 101.78,48.02 103.5,49.75 103.5,50 ; 112.17,50.09 112.09,50.09 111.93,50.26 111.03,50.26
USB20_P1: length 117.1
  TOP w0.107: UH1.J2 93.7,43.82 93.59,43.71 93.4,43.71 93.27,43.84 93.11,43.84 92.8,43.53 91.66,43.53 91.61,43.59 91.15,43.59 90.93,43.81 90.93,44.26 90.77,44.41 v8(90.55,44.41)
  IN1 w0.076: 89.34,39.33 89.33,39.31 89.31,39.31 88.76,38.77 88.76,36.94 88.05,36.24 85.73,36.24 84.92,35.43 84.92,26.67 84.39,26.14 84.39,21.9 81.78,19.28 73.39,19.28 69.28,15.17 69.28,12.72 66.57,10.01 12.28,10.01 10.53,8.26 10.53,5.26 10.25,4.98 9.36,4.98 9.29,5.06 9.29,5.27 v4(9.46,5.44)
  IN1 w0.089: 89.34,39.33 89.64,39.62 89.64,42.93 90.48,43.77 90.71,43.77 90.87,43.92 90.87,44.48 90.81,44.54 90.61,44.54 90.55,44.48 v8(90.55,44.41)
USB20_P2: length 56
  IN1 w0.076: v4(145.94,35.96) 145.75,35.76 145.75,35.55 145.84,35.46 145.84,34.6 145.03,33.8 139.11,33.8 137.08,35.83 135.61,35.83 131.31,40.13 131.09,40.13 129.06,42.17 124.43,42.17 122.44,44.16 117.73,44.16 117.26,44.63 117.26,44.65 117.24,44.66
  IN1 w0.089: v8(99.88,42.24) 99.73,42.24 99.64,42.33 99.64,42.46 100.84,43.65 101.54,43.65 101.85,43.97 102.43,43.97 102.87,44.41 104.9,44.41 106.55,46.07 107.51,46.07 107.7,45.87 109.1,45.87 110.11,46.89 110.88,46.89 111.58,46.18 111.58,45.86 111.98,45.47 112.67,45.47 112.95,45.19 116.72,45.19 117.24,44.66
USB20_P3: length 152.4
  TOP w0.089: v8(91.1,53.88) 91.1,53.83 90.92,53.66 90.92,52.61 90.47,52.16 87.39,52.16 87.38,52.15 86.84,52.15 86.83,52.16 86.11,52.16 84.84,50.89 84.84,46.91 86.31,45.43 87.79,45.43 89.89,43.34 93.09,43.34 93.25,43.49 93.69,43.49 94.04,43.84 94.23,43.84 94.23,43.84 94.3,43.78 94.3,43.65 94.21,43.56 UH1.K3
  IN1 w0.076: v8(91.1,53.88) 91.1,53.91 90.92,54.09 90.92,54.84 88.13,57.64 88.13,69.14 85.09,72.17 85.09,84.45 89.13,88.49 89.13,88.84 89.15,88.87 89.15,95.68 72.91,111.93 71.64,111.93 68.14,115.43 68.14,118.65 65.7,121.08 64.08,121.08 62.36,122.81 62.36,125.5 61.38,126.48 61.38,134.17 60.2,135.35 60.2,140.39 57.56,143.03 56.64,143.03 55.7,143.97 45.83,143.97 45.52,144.27 39.12,144.27 38.31,145.08 38.31,145.33 38.42,145.44 38.47,145.44 v8(38.6,145.58)
USB20_P3_R: length 3.2
  TOP w0.089: JCDRA.39 38.65,148.28 38.48,148.11 38.48,147.31 38.5,147.3 38.5,146.76 38.48,146.75 38.48,146.3 LM1.3
USB20_P4: length 67
  IN1 w0.076: 90.32,25.75 90.16,25.59 90.13,25.59 88.77,24.24 88.77,22.71 88.3,22.24 88.3,20.69 89.1,19.89 91.95,19.89 92.13,19.71 93.24,19.71 94.47,18.49 99.56,18.49 100.33,17.72 102.84,17.72 103.11,17.45 105.26,17.45 105.38,17.33 106.96,17.33 107.38,17.74 111.77,17.74 112.09,18.06 113.89,18.06 114.2,17.74 117.47,17.74 120.27,20.54 120.27,21.86 120.09,22.04 119.85,22.04 119.84,22.03 119.73,22.03 v5(119.63,22.12)
  IN1 w0.089: v8(96.89,43.22) 96.89,43.03 96.49,42.63 96.49,41.97 96.6,41.86 96.6,41.25 96.53,41.19 96.53,41.1 96.53,41.1 96.42,40.99 96.42,40.89 96.27,40.73 96.27,39.27 96.9,38.64 96.9,38 96.44,37.54 94.6,37.54 93.78,36.72 93.78,32.61 94.08,32.31 94.08,30.03 92.2,28.16 92.2,27.63 90.32,25.75
  BOTTOM w0.089: v5(119.63,22.12) 119.44,21.93 119.01,21.93 118.86,22.08 UE1.33
USB20_P7: length 111.9
  TOP w0.107: v5(92.01,41.87) 92.01,41.79 92.12,41.68 92.43,41.68 93,42.25 93,42.53 93.23,42.76 93.23,42.77 93.29,42.83 94.16,42.83 94.22,42.88 94.22,43.03 94.16,43.1 UH1.L3
  IN4 w0.076: v7(68.64,124.26) 68.64,124.33 68.56,124.4 68.45,124.4 68.36,124.31 68.36,122.91 68.79,122.49 68.79,119.28 76.15,111.92 76.15,95.67 79.2,92.62 79.2,87.71 81.64,85.26 81.64,70.73 81.99,70.39 81.99,62.89 82.22,62.66 82.22,45.9 85.59,42.53 88.43,42.53 88.46,42.51 88.5,42.51
  IN4 w0.089: 88.5,42.51 89.03,42.51 90.07,41.47 91.68,41.47 91.79,41.58 91.79,41.66 v5(92.01,41.87)
  BOTTOM w0.089: v7(68.64,124.26) 68.48,124.41 68.11,124.41 65.71,126.81 65.71,134.38 65.5,134.59 LV2.4
USB20_P7_R: length 33.3
  IN4 w0.076: v5(47.18,152.91) 47.37,152.72 47.37,152.24 48.53,151.08 51.4,151.08 57.63,144.85 57.63,141.23 58.88,139.99 60.69,139.99 v7(60.81,139.87)
  BOTTOM w0.089: JEDP.18 47.25,151.94 47.38,152.07 47.38,152.25 47.38,152.25 47.38,152.7 v5(47.18,152.91) ; v7(60.81,139.87) 60.93,139.99 62.29,139.99 64.4,137.89 DV4.2 64.88,138.51 65.2,138.83 65.59,138.83 65.87,138.54 65.87,137.11 65.65,136.88 65.65,135.55 LV2.3
USB20_P8: length 73.8
  TOP w0.089: v8(95.06,45.49) 95.06,45.11 UH1.G5
  IN1 w0.076: 103,49.77 103.08,49.86 103.08,52.12 103.63,52.67 108.74,52.67 110.65,50.76 112.08,50.76 112.22,50.62 117.45,50.62 118.12,51.29 120.26,51.29 120.97,50.59 120.97,50.31 123,48.28 130.86,48.28 138.11,41.02 140.26,41.02 140.72,40.57 143.61,40.57 145.29,38.89 146.72,38.89 149.05,36.56 149.05,34.2 148.97,34.13 148.73,34.13 148.6,34.25 148.6,34.65 v5(148.65,34.7)
  IN1 w0.089: 103,49.77 101.59,48.36 98.54,48.36 98.22,48.68 97.36,48.68 95.3,46.63 95.3,46.16 95.21,46.07 95,45.66 v8(95.06,45.49)
  BOTTOM w0.089: JIO2.B9 147.14,34.9 146.77,34.53 146.77,34.41 147.24,33.94 148.29,33.94 148.65,34.31 v5(148.65,34.7)
USB20_P9: length 191.7
  TOP w0.107: UH1.N8 96.2,42.36 96.2,42.64 96.33,42.77 v5(96.33,42.99)
  IN4 w0.076: 88.5,46.27 88.25,46.27 88.25,46.27 85.44,46.27 84.77,46.94 84.77,72.54 84.02,73.3 84.02,98.62 77.98,104.67 77.98,113.92 74.73,117.17 74.73,133.26 73.53,134.46 73.53,135.99 75.06,137.52 75.06,138.33 75.23,138.51 75.93,138.51 78.28,136.16 84.43,136.16 85.64,134.95 89.33,134.95 89.71,135.33 93.39,135.33 93.84,134.88 99.34,134.88 99.52,135.05 100.1,135.05 100.3,134.85 100.71,134.85 101.79,135.93 120.89,135.93 121.43,135.39 128.91,135.39 129.28,135.03 135.97,135.03 137.44,133.56 140.38,133.56 141.73,134.92 141.73,135.5 142.8,136.57 142.8,137.63 142,138.43 140.12,138.43 139.14,139.41 139.14,140.24 139.2,140.3 v7(139.26,140.3)
  IN4 w0.089: v5(96.33,42.99) 96.24,43 95.87,43.44 95.87,44.37 95.12,45.11 91.44,45.11 90.28,46.27 88.5,46.27
  BOTTOM w0.089: v7(139.26,140.3) 139.34,140.39 139.66,140.39 RE648.1 140.16,140.2 LE3.1
USB20_P9_R: length 2.6
  BOTTOM w0.089: LE3.2 140.76,140.21 RE648.2 141.26,140.39 141.7,140.39 141.88,140.2 142.13,140.2 142.42,139.9 JTOBII.4
USB20_P10: length 41.4
  TOP w0.089: v8(88.71,14.5) 88.63,14.42 88.62,14.33 88.62,14.07 89.42,13.27 v13(89.42,12.65) 89.42,12.38 89.8,12 89.8,11.32 LE7.1 90.06,11.19 RE202.1
  TOP w0.107: v8(92.25,44) 92.29,44.04 92.29,44.18 92.59,44.48 93.31,44.48 93.41,44.58 UH1.H2
  IN1 w0.076: v8(88.71,14.5) 88.63,14.43 88.63,14.17 88.43,13.97 87.38,13.97 86.72,14.63 86.72,16.18 85.72,17.17 85.72,20.6 86.13,21.01 86.13,24.28 86.42,24.57 86.42,34.51 87.32,35.41 88.31,35.41 90.14,37.25 90.14,38.15 90.32,38.33
  IN1 w0.089: v8(92.25,44) 92.25,43.44 90.42,41.62 90.42,38.43 90.32,38.33
USB20_P10_R: length 26.6
  TOP w0.089: RE202.2 90.06,10.59 LE7.2 89.8,10.45 89.8,9.3 89.29,8.79 89.29,8.35 DK1.3 89.26,7.82 89.26,6.88 v8(89.35,6.79)
  IN1 w0.076: v8(89.35,6.79) 89.28,6.71 89.28,5.7 88.6,5.03 84.75,5.03 84.07,5.72 82.44,5.72 82.25,5.91 80.09,5.91 79.69,5.5 78.28,5.5 77.74,6.05 76.16,6.05 75.2,7.01 73.4,7.01 72.44,6.05 71.78,6.05 71.59,6.24 71.59,6.61 v11(71.5,6.7)
  GND2 w0.089: v3(71.41,7.08) 71.58,6.9 71.58,6.78 v11(71.5,6.7)
  GND4 w0.089: v4(71.45,7.42) 71.54,7.33 71.54,7.21 v3(71.41,7.08)
USB20_P11: length 150.5
  TOP w0.107: UH1.P9 97.06,41.94 v5(97.06,42.28)
  IN2 w0.076: v5(91.76,136.68) 91.5,136.94 91.5,137.05 91.72,137.26 95.49,137.26 96.29,138.07 96.29,139.24 97.1,140.05 97.1,140.78 96.71,141.18 95.94,141.18 95.45,141.67 95.45,141.94 94.61,142.78 94.61,146.02 95.82,147.22 95.82,147.56 95.94,147.68 v4(96.2,147.68)
  IN4 w0.076: v5(91.76,136.68) 91.76,136.36 91.68,136.29 91.07,136.29 90.7,135.92 89.25,135.92 88.43,136.73 85.13,136.73 84.5,137.37 78.08,137.37 76.45,138.99 74.98,138.99 74.47,138.48 74.47,137.95 72.92,136.4 72.92,133.99 74.04,132.87 74.04,117.03 77.39,113.68 77.39,104.42 83.44,98.38 83.44,72.79 84.15,72.07 84.15,46.59 85.23,45.51 88.5,45.51
  IN4 w0.089: v5(97.06,42.28) 97.18,42.22 97.26,41.99 97.13,41.87 95.89,41.87 93.34,44.41 91.25,44.41 90.15,45.51 88.5,45.51
USB20_P11_R: length 4
  BOTTOM w0.089: RT115.2 RT113.2 95.75,145.51 95.75,144.68 95.65,144.58 95.65,144.33 95.74,144.24 95.99,144.24 96.08,144.15 96.08,144.01 95.99,143.92 95.77,143.92 95.69,143.83 95.69,143.63 UT4.L5
USB20_P14: length 81.5
  TOP w0.089: UH1.F6 95.71,45.78 v8(95.87,45.94)
  IN1 w0.076: 114.84,49.96 119.94,49.96 122.3,47.6 130.7,47.6 137.93,40.38 140.06,40.38 140.61,39.83 141.8,39.83 143.32,38.31 146.41,38.31 148.02,36.7 148.02,32.57 149.5,31.08 149.5,27.39 146.78,24.67 145,24.67 144.78,24.88 144.78,25.3 144.39,25.69 144.07,25.69 143.83,25.45 143.83,25.1 143.75,25.02 143.63,25.02 143.54,25.11 v4(143.54,25.14) ; 111.03,50.08 111.01,50.08 111,50.07 110.2,50.07 109.96,50.31 107.07,50.31 105.3,52.09 103.97,52.09 103.7,51.81 103.7,50.03 103.68,50.01 103.68,50
  IN1 w0.089: 103.68,50 103.68,49.67 101.85,47.84 98.42,47.84 98.06,47.48 96.85,47.48 96.33,46.96 96.33,46.61 95.87,46.24 95.87,45.94 v8(95.87,45.94) ; 114.84,49.96 113.71,49.96 113.7,49.96 113.63,49.96 113.63,49.95 113.45,49.95 113.37,49.87 113.32,49.87 113.28,49.91 112.02,49.91 111.85,50.08 111.03,50.08
USB_DVDD1: length 18.3
  TOP w0.081: v8(66.62,90.01) 66.62,89.92 RG1505.1
  IN1 w0.058: v1(51.95,92.95) 52.38,93.38 61.29,93.38 61.77,93.86 63.11,93.86 65.61,91.37 66.14,91.37 66.62,90.88 v8(66.62,90.01)
USB_DVDD2: length 16.4
  TOP w0.081: RG1506.1 66.22,90.09 66.22,90.61 66.19,90.64 v8(66.19,90.81)
  IN1 w0.058: v8(66.19,90.81) 66.19,90.99 65.99,91.19 65.56,91.19 63.05,93.7 61.84,93.7 61.35,93.22 53.14,93.22 52.87,92.95 v1(52.65,92.95)
USB_HVDD1: length 20.6
  TOP w0.081: v2(62.16,83.52) 62.36,83.71 v8(62.36,84.43) 62.66,84.74 62.74,84.74 ; RG1507.1 63.63,85.02
  TOP w0.089: 62.74,84.74 63.35,84.74 63.63,85.02
  IN1 w0.058: v8(62.36,84.43) 62.36,84.33 61.17,83.14 52.8,83.14 49.43,86.51 49.43,89.03 v8(49.85,89.45)
USB_HVDD2: length 20.5
  TOP w0.081: RG1508.1 63.63,85.65 ; v8(61.98,84.46) 61.98,84.64 v2(62.2,84.86) 62.71,85.37 62.74,85.37
  TOP w0.089: 62.74,85.37 63.35,85.37 63.63,85.65
  IN1 w0.058: v8(61.98,84.46) 60.82,83.3 52.87,83.3 49.59,86.58 49.59,88.93 49.86,89.19 49.96,89.19 50.11,89.34 50.11,89.89 v8(49.85,90.15)
USB_OC0#: length 150.7
  TOP w0.122: UH1.AH36 v5(110.37,34.24)
  IN2 w0.058: v3(70.15,8.14) 70.08,8.07 70.08,6.09 71.02,5.15 71.02,2.51 v3(71.46,2.07)
  IN3 w0.058: v3(70.15,8.14) 70.33,8.32 73.14,8.32 74.64,9.82 74.64,14.68 74.79,14.83 75.11,15.15 75.11,15.43 74.79,15.75 74.79,16.18 75.06,16.45 75.06,16.73 74.66,17.12 74.45,17.12 73.9,17.67 73.9,18.43 75.64,20.17 77.65,20.17 77.79,20.03 80.09,20.03 80.23,20.17 83.99,20.17 88.36,24.54 90.32,24.54 ; v3(71.46,2.07) 71.28,2.25 70.63,2.25 70.51,2.13 65.75,2.13 65.18,1.56 48.68,1.56 47.8,2.44 46.35,2.44 44.16,4.64 43.75,4.91 43.71,4.94 43.2,5.15 42.67,5.25 41.39,5.25 41.26,5.25 41.17,5.16 41.17,5.16 39.39,3.38 39.39,2.25 38.49,1.36 30.74,1.36 29.96,2.13 24.87,2.13 24.09,1.36 9.21,1.36 8.19,2.38 6.29,2.38 5.51,3.15 5.51,5.67 v9(5.84,6)
  IN3 w0.089: v5(110.37,34.24) 110.37,34.23 109.92,33.78 108.83,33.78 108.51,33.47 105,33.47 104.2,32.67 104.2,30.63 103.24,29.67 100.12,29.67 97.97,27.52 97.97,27.01 97.42,26.46 92.69,26.46 90.78,24.54 90.32,24.54
  GND4 w0.081: v9(5.84,6) 5.84,6.34 v4(5.86,6.36)
  BOTTOM w0.081: RH1019.1 118.82,33.46 118.34,33.94 117.24,33.94
  BOTTOM w0.089: v5(110.37,34.24) 110.39,34.24 110.87,33.76 111.39,33.76 v2(111.67,34.04) 112.02,34.39 112.45,34.39 112.46,34.38 113.41,34.38 113.86,33.94 117.24,33.94
USB_OC1#: length 40.2
  TOP w0.122: v5(112.24,34.02) 111.98,33.77 UH1.AL40
  IN3 w0.058: 117.24,34.52 125.93,34.52 126.4,34.99 138.67,34.99 140.56,33.1 141.9,33.1 v9(142.1,32.9)
  IN3 w0.089: v5(112.24,34.02) 112.42,34.02 112.87,34.48 113.06,34.48 113.62,35.04 115.17,35.04 115.69,34.52 117.24,34.52
  GND4 w0.081: v9(142.1,32.9) v4(142.34,32.66)
  BOTTOM w0.081: 117.24,33.71 118.32,33.71 118.43,33.6 118.43,32.98 118.71,32.7 RH1020.1
  BOTTOM w0.089: v5(112.24,34.02) 112.79,33.47 v2(113.3,33.47) 113.71,33.47 113.94,33.71 117.24,33.71
USB_PWR_EN1: length 76.9
  GND2 w0.076: v12(79.98,16.08) 79.98,16.03 80.15,15.86 v1(80.17,15.86)
  GND2 w0.081: v1(78.92,20.72) 79.06,20.72 v3(79.25,20.53)
  IN2 w0.058: 79.98,18.44 79.98,19.79 v3(79.25,20.53)
  IN2 w0.076: v12(79.98,16.08) 80.36,16.46 80.36,17.02 79.98,17.4 79.98,18.44
  IN3 w0.058: v3(79.25,20.53) 79.28,20.49 83.84,20.49 88.72,25.38 90.32,25.38 ; v9(142.1,35.71) 141.53,35.15 126.33,35.15 125.88,34.7 117.24,34.7
  IN3 w0.089: 90.32,25.38 91.11,25.38 93.07,27.33 94.55,27.33 94.81,27.59 97.54,27.59 100.46,30.51 100.46,32.6 100.9,33.05 103.38,33.05 104.84,34.51 107.89,34.51 108.14,34.76 113.09,34.76 113.55,35.21 115.25,35.21 115.76,34.7 117.24,34.7
  GND4 w0.081: v9(142.1,35.71) v4(142.34,35.96)
USB_VDDP: length 16.4
  TOP w0.081: RG1509.1 65.84,90.38 v8(65.84,90.86) ; v8(53.28,91.62) UG1.BE12
  IN1 w0.058: v8(53.28,91.62) 53.28,92.15 53.75,92.61 57.1,92.61 57.55,93.06 61.42,93.06 61.9,93.54 62.98,93.54 65.57,90.96 65.74,90.96 v8(65.84,90.86)
USBCHG_DET#: length 102.1
  IN1 w0.058: v5(83.76,5.04) 83.5,4.79 81.88,4.79 81.69,4.6 78.27,4.6 78.11,4.75 66.4,4.75 65.34,5.81 61.23,5.81 57.99,2.57 54.79,2.57 54.18,3.17 49.84,3.17 49.01,2.34 47.62,2.34 45.24,4.73 45.24,5.91 43.9,7.24 39.88,7.24 38.54,5.9 15.67,5.9 12.89,3.12 9.79,3.12 8.87,4.04 7.57,4.04 v5(7.11,4.5)
  IN3 w0.058: v9(7.37,6.38) 7.24,6.38 6.6,5.74 6.6,5.01 v5(7.11,4.5)
  GND4 w0.081: v9(7.37,6.38) 7.64,6.38 v4(7.66,6.36)
  BOTTOM w0.076: 84.2,11.01 83.26,11.01 83.19,10.94 83.19,10.57
  BOTTOM w0.081: 83.19,10.57 83.19,9.16 82.98,8.96 82.98,8.59 82.93,8.54 82.93,7.9 82.03,7 82.03,5.95 82.11,5.87 83.5,5.87 83.76,5.62 v5(83.76,5.04) v2(84.37,5.04) 84.71,5.04 85.27,5.61 DU6.2 86.61,6.44 CU27.2 ; CU28.1 RU4.2 84.77,11.27 84.52,11.01 84.2,11.01
USBCHG_DET_D: length 54.2
  TOP w0.081: v5(40.32,7.95) v2(40.32,8.58)
  IN3 w0.058: v9(78.16,7.01) 78.16,5.31 77.63,4.78 69.58,4.78 69.48,4.68 64.48,4.68 63.89,4.09 58.39,4.09 58.01,4.47 54.49,4.47 50.76,8.2 45.63,8.2 45.3,7.86 44.54,7.86 44.51,7.83 44.19,7.83 44.17,7.81 41.81,7.81 41.31,8.31 40.68,8.31 v5(40.32,7.95)
  GND4 w0.081: v6(78.39,7.24) v9(78.16,7.01)
  IN4 w0.058: v6(78.39,7.24) 78.84,7.7 80.37,7.7 82.7,10.04 83.21,10.04 v7(83.62,10.44)
  BOTTOM w0.076: 83.68,10.57 83.94,10.83 84.2,10.83
  BOTTOM w0.081: UU5.4 84.69,10.59 84.45,10.83 84.2,10.83 ; v7(83.62,10.44) 83.62,10.51 83.68,10.57
  BOTTOM w0.203: v5(40.32,7.95) 40.32,6.41 40.61,6.12 PD502.3
USBCHG_DET_EC#: length 13.1
  TOP w0.076: UE5.D8 79.02,14.86 79.41,14.47 79.41,14.16 v8(79.05,13.79)
  IN1 w0.058: v4(83.57,8.74) 82.91,9.4 81.32,9.4 80.16,10.57
  IN1 w0.076: 80.16,10.57 79.32,11.4 79.32,12.35 78.91,12.76 78.91,13.66 v8(79.05,13.79)
  BOTTOM w0.081: DU6.1 83.12,6.69 83.12,8.3 v4(83.57,8.74) 83.62,8.79 RU6.2
VCIN0_PH1: length 186.5
  TOP w0.076: v5(78.13,12.32) 78.16,12.28 UE5.C2
  IN3 w0.058: v9(78.11,98.45) 78.13,98.45 79.85,96.74 79.85,91.36 82.23,88.98 82.23,69.26 79.49,66.52 79.49,60.29 78.76,59.56 78.76,53.98 79.35,53.39 79.45,53.3 79.45,44.13 79.72,43.86 79.72,43.76 79.72,43.76 79.72,43.19 79.95,42.96 79.95,41.55 79.74,41.34 79.74,41.21 79.74,41.07 79.74,39.09 79.84,38.99 v9(79.84,38.63) ; 77.88,10.57 77.88,10.19 77.77,10.09 77.77,9.78 77.91,9.65 77.91,9.46 77.8,9.35 77.8,8.8 78.41,8.19 78.41,7.59 78.14,7.32 77.98,7.32 77.8,7.14 77.8,6.78 77.91,6.67 77.91,5.29 77.56,4.94 69.51,4.94 69.42,4.84 64.42,4.84 63.83,4.25 58.45,4.25 58.07,4.63 54.55,4.63 50.5,8.69 43.6,8.69 43.23,8.32 v5(43.23,8.17)
  IN3 w0.076: v5(78.13,12.32) 78.1,12.35 77.65,12.35 77.34,12.04 77.34,11.44 77.88,10.9 77.88,10.57
  GND4 w0.081: v4(77.9,98.68) 78.11,98.48 v9(78.11,98.45) ; v9(79.84,38.63) 79.66,38.45 v6(79.66,38.44)
  IN4 w0.058: v7(103.8,94.1) 103.8,94.88 102.84,95.84 102.84,105.34 101.55,106.63 100.8,106.63 100.33,107.11 100.33,108.69 98.02,111 93.04,111 86.55,104.51 84.58,104.51 84.48,104.41 83.92,104.41 v7(83.79,104.28) ; 78.13,18.44 80.42,20.73 80.42,24.96 80.08,25.3 80.08,34.55 79.54,35.09 79.54,38.32 v6(79.66,38.44)
  IN4 w0.076: v5(78.13,12.32) 78.49,12.68 78.49,13.26 77.33,14.41 77.33,17.44 78.13,18.24 78.13,18.44
  BOTTOM w0.081: v4(77.9,98.68) 78.19,98.68 81.9,102.39 v2(82.79,102.39) 83.79,103.39 v7(83.79,104.28)
  BOTTOM w0.254: PR25.1 43.75,7.51 PR24.1 43.37,7.52 43.18,7.71 43.18,8.09 43.23,8.15 v5(43.23,8.17)
VCIN1_AC_IN: length 101
  TOP w0.081: DH1.1 111.76,15.38 111.99,15.15 v10(111.99,14.68) 111.99,14.61 111.76,14.38 v6(111.76,14.27)
  TOP w0.254: PRB34.1 48.45,19.01 v5(48.32,18.89)
  IN1 w0.058: v1(75.07,13.81) 75.35,14.09 75.35,14.11 75.5,14.26 75.52,14.26 76.23,14.96 76.58,14.96 ; v6(111.76,14.27) 111.54,14.49 107.96,14.49 107.36,13.89 102.93,13.89 102.51,13.47 99.82,13.47 98.57,14.72 92.11,14.72 86.7,9.31 85.23,9.31 84.78,8.87 83.82,8.87 83.13,9.56 81.39,9.56 80.38,10.57
  IN1 w0.076: 76.58,14.96 78.34,14.96 78.46,14.85 78.47,14.85 78.61,14.7 78.61,14.69 79.67,13.64 v8(79.67,13.36) 79.67,13.34 79.42,13.09 79.42,12.54 79.51,12.45 79.51,11.44 80.38,10.57
  GND2 w0.081: v1(75.07,13.81) v3(75.07,14.18)
  GND4 w0.081: v3(75.07,14.18) v6(74.73,14.18)
  IN4 w0.058: v6(74.73,14.18) 74.71,14.18 74.7,14.19 71.98,14.19 71.09,15.08 69.48,15.08 68.96,14.56 68.96,13.94 67.67,12.65 63.86,12.65 63.08,11.86 57.81,11.86 55.88,13.79 50.5,13.79 49.58,14.71 49.58,17.63 v5(48.32,18.89) ; v6(111.76,14.27) 112.54,13.5 122.36,13.5 122.85,13.99 125.79,13.99 125.93,13.84 v7(126.95,13.84)
  BOTTOM w0.203: PUB1.2 48.11,18.67 v5(48.32,18.89) 48.45,19.01 PRB34.1
VCIN1_ADP_PROCHOT: length 32.9
  TOP w0.081: v2(49.21,14.3) PR26.2
  TOP w0.254: PR26.2 PC13.2 PR23.1 51.45,13.19 51.57,13.06 v5(51.63,13.06)
  GND2 w0.076: v1(78.67,11.86) 78.49,11.86 78.44,11.81 78.38,11.81 78.31,11.74 78.31,11.66 v3(78.29,11.66)
  GND4 w0.076: v3(78.29,11.66) 78.14,11.51 v6(77.92,11.51)
  IN4 w0.058: 76.58,11.74 75.04,11.74 74,12.78 69.77,12.78 67.97,10.98 56.31,10.98 54.23,13.06 v5(51.63,13.06)
  IN4 w0.076: 76.58,11.74 77.06,11.74 77.24,11.56 77.87,11.56 v6(77.92,11.51)
VCIN_ BATT_TEMP: length 70.4
  TOP w0.076: UE5.B13 77.66,17.77 77.8,17.91 v3(77.8,17.93) 77.8,17.96 77.66,18.1 77.66,18.44
  TOP w0.081: CE190.2 77.66,18.77 77.66,18.44
  TOP w0.254: PC14.1 25.76,4.8 PD3.2 25.76,3.66 26.14,3.28 PR16.1 v1(26.73,4.02)
  GND2 w0.081: v1(26.73,4.02) v12(26.75,4.02)
  IN2 w0.058: v12(26.75,4.02) 27.58,4.02 32.94,9.38 40.92,9.38 42.67,11.13 v4(43.18,11.13)
  GND4 w0.076: v3(77.8,17.93) v6(78.18,17.93)
  IN4 w0.058: v7(44.51,12.72) 44.55,12.68 54.15,12.68 56.11,10.72 67.97,10.72 68.68,11.43 76.58,11.43
  IN4 w0.076: v6(78.18,17.93) 77.64,17.39 77.64,14.34 78.83,13.14 78.83,11.83 78.18,11.18 77.77,11.18 77.57,11.38 76.73,11.38 76.68,11.43 76.58,11.43
  BOTTOM w0.081: v4(43.18,11.13) 43.29,11.01 v2(43.61,11.01) 44.42,11.01
  BOTTOM w0.203: v7(44.51,12.72) 44.5,12.7 PCB27.1 44.5,11.09 44.42,11.01
VCOUT0_MAIN_PWR_ON#: length 49.7
  TOP w0.076: UE5.E4 79.17,12.44 v3(79.01,12.28)
  GND4 w0.076: v3(79.01,12.28) 79.34,12.28 v6(79.35,12.3)
  IN4 w0.058: 76.58,10.99 76.54,10.99 76.2,10.65 71.3,10.65 70.14,9.49 68.86,9.49 68.64,9.71 44.81,9.71 v7(43.84,10.67)
  IN4 w0.076: v6(79.35,12.3) 79.35,11.89 78.32,10.86 77.64,10.86 77.44,11.06 76.66,11.06 76.58,10.99
  BOTTOM w0.081: PR504.1 38.87,4.84 38.49,5.22 38.49,9.25 39.54,10.29 v2(39.84,10.29) 40.22,10.67 v7(43.84,10.67)
VCOUT1_PROCHOT#: length 3.3
  TOP w0.076: UE5.E2 79.17,11.72 78.92,11.47 78.92,10.57
  TOP w0.081: RE85.2 RE84.2 79.12,10 78.92,10.2 78.92,10.57
VDOP_CHG: length 4.6
  TOP w0.081: v2(40.01,17.5) PRB9.2
  TOP w0.254: PRB9.2 41.22,17.3 v5(41.85,17.3)
  BOTTOM w0.203: PUB1.20 42.65,17.47 42.48,17.3 v5(41.85,17.3) 41.02,18.13 PCB23.1
VGA_EN: length 3.9
  TOP w0.081: UM8.26 66.35,145.24 66.04,145.54 65.83,145.54 65.43,145.95 65.43,146.32 RM87.1 RM14.2 v2(65.94,147.31)
VGA_SMB_CK2: length 15.3
  IN1 w0.058: v4(67.74,86.08) 67.74,86.05 67.39,85.69 66.03,85.69 65.63,86.09 63.84,86.09 63.48,85.74 60.5,85.74 59.08,87.16 57.34,87.16 57.03,87.47 57.03,87.87 v8(56.85,88.05)
  BOTTOM w0.081: RG17.1 67.54,86.29 v4(67.74,86.08) 67.79,86.03 69.19,86.03 QG6.4
VGA_SMB_DA2: length 17.3
  IN1 w0.058: v8(56.15,88.05) 56.65,87.55 56.69,87.55 57.27,86.97 59,86.97 60.43,85.55 63.56,85.55 63.91,85.91 65.55,85.91 65.95,85.5 67.7,85.5 v4(67.74,85.55)
  BOTTOM w0.081: QG6.1 70.94,84.67 69.93,85.68 v2(68.36,85.68) 67.87,85.68 v4(67.74,85.55) 67.69,85.6 67.34,85.6 RG18.1
VID_GPU: length 3.8
  TOP w0.203: PRV22.2 71.25,32.87 v2(71.62,32.87) 71.81,32.87 72.77,31.91 PUV1.39
VOUT1_FBVDDQ: length 12.6
  TOP w0.254: v5(16.83,58.96) 16.89,58.89 16.89,58.47 16.15,57.73 16.15,56.63 15.52,56 v2(15.09,56) 14.03,57.05 12.56,57.05 PRW8.2 11.77,56.54 PCW8.1 10.29,55.75 10.22,55.82 PCW4.2 9.7,55.67 9.91,55.46 PRW18.2
  BOTTOM w0.254: v5(16.83,58.96) 17.13,58.65 PRW39.2
VOUT1_FBVDDQ_R: length 8.9
  TOP w0.254: PLW01.3 v5(15.94,60.83)
  BOTTOM w0.254: PCW41.2 18.16,56.62 18.16,57.76 PRW39.1 18.05,58.38 16.97,59.46 16.26,59.46 15.94,59.78 v5(15.94,60.83)
VOUT2_FBVDDQ: length 8.6
  TOP w0.254: v5(16.31,52.85) v2(14.49,52.85) PCW2.2 PRW17.2 11.91,52.75 PCW9.1 10.86,51.94 10.81,51.99 PRW14.2
  BOTTOM w0.254: v5(16.31,52.85) 16.87,52.29 PRW50.2
VOUT2_FBVDDQ_R: length 4.7
  TOP w0.254: PLW02.3 19.99,53.67 v5(19.75,53.43)
  BOTTOM w0.254: v5(19.75,53.43) 20.51,53.43 20.93,53.01 PCW43.2 20.49,52.29 v2(19.93,52.29) PRW50.1
VOUT_ISL95338_1: length 1.8
  BOTTOM w0.203: PUV3.31 55.4,27.38 PRV97.1
VOUT_S: length 4.7
  TOP w0.254: PCV6.2 76.77,35.22 77.27,35.71 v2(78.03,35.71) 78.94,35.71 v4(79.12,35.54)
  BOTTOM w0.254: PRV40.1 PRV13.1 PRV34.1
VOUTS_ISL95338_1: length 2.2
  BOTTOM w0.203: PRV95.1 52.65,30.75 53.17,30.23 53.46,30.23 53.82,30.59 PUV3.3
VR_PWRGD: length 194.2
  TOP w0.081: v5(147.14,127.46) 147.88,127.46 148.56,128.15 149.22,128.15 149.69,127.68 PCZ251.2 PRZ40.2 150.75,126.89 v2(151.13,127.27) 151.26,127.4 v5(151.26,128.17)
  TOP w0.203: PUZ1.45 147.03,127.45 147.04,127.46 v5(147.14,127.46)
  IN1 w0.058: v5(132.96,13.91) 132.74,14.12 131.95,14.12 131.64,13.81 111.58,13.81 111.28,14.11 110.85,14.11 110.48,13.74 109.18,13.74 108.81,14.11 107.91,14.11 107.53,13.73 103,13.73 102.58,13.31 99.75,13.31 99.18,13.88 91.49,13.88 86.74,9.13 85.33,9.13 84.67,8.47 82.6,8.47 81.83,9.24 81.26,9.24 81.24,9.26 81.23,9.26 79.93,10.57
  IN1 w0.076: 79.93,10.57 79.13,11.36 v8(78.67,11.36)
  IN4 w0.254: v7(133.16,14.62) 134.11,15.57 134.11,21.74 v7(136.14,23.78) ; v7(139.45,27.97) 139.45,31.14 138.63,31.96 138.63,39.09 143.79,44.25 143.79,64.95 143.58,65.16 143.58,65.58 144.38,66.38 144.38,75.02 141.12,78.28 141.12,105.34 141.69,105.9 141.69,117.94 140.42,119.2 140.42,120.36 140,120.79 140,123.72 141.21,124.93 145.81,124.93 146.61,125.73 146.61,127.16 146.9,127.46 v5(147.14,127.46)
  BOTTOM w0.081: v5(132.96,13.91) 133.16,14.11 v7(133.16,14.62)
  BOTTOM w0.254: v7(139.45,27.97) 139.45,25.55 137.67,23.78 v7(136.14,23.78)
VR_SVID_ALERT#: length 26.3
  TOP w0.081: v4(148.5,125.3) 148.52,125.31 PRZ17.1 ; RH153.1 140.85,111.86 140,111.01 RH152.2 138.69,110.9 137.99,110.2 v8(137.79,110.2)
  IN1 w0.058: v4(148.5,125.3) 148.51,125.3 148.5,125.31 148.27,125.31 147.57,124.61 147.57,123.84 146.25,122.52 141.99,122.52 140.39,120.92 140.39,117.22 140.26,117.09 140.26,114.07 137.85,111.66 137.85,110.9 138.05,110.7 138.05,110.39 137.86,110.2 v8(137.79,110.2)
VR_SVID_CLK: length 30.8
  TOP w0.076: v5(132.25,107.88) 131.88,107.51 UC1.BH32
  TOP w0.081: PRZ10.2 148.52,126.08 v4(148.5,126.06)
  IN1 w0.058: 132.47,108.1 132.64,108.27 132.64,108.59 132.89,108.84 134.77,108.84 137.91,111.98 137.91,112.06 137.74,112.23 137.74,112.32 137.82,112.4 137.9,112.4 138.08,112.23 138.16,112.23 138.24,112.31 138.24,112.39 138.17,112.46 138.17,112.55 138.25,112.63 138.34,112.63 138.41,112.56 138.47,112.56 140.09,114.17 140.09,119.42 139.57,119.94 139.57,120.25 140.01,120.69 140.01,121.18 141.67,122.84 146.33,122.84 147.32,123.83 147.32,125.12 148.26,126.06 v4(148.5,126.06)
  IN1 w0.081: v5(132.25,107.88) 132.47,108.1
VR_SVID_DATA: length 33.5
  TOP w0.076: UC1.BH29 131.73,104.96 v8(131.74,104.96)
  TOP w0.081: PRZ5.2 v4(148.49,124.55) ; RH151.2 139.78,109.73 v8(137.8,109.73)
  IN1 w0.058: v8(137.8,109.73) 138.2,110.13 138.2,110.76 137.99,110.96 137.99,111.58 140.42,114.01 140.42,117.03 140.55,117.15 140.55,120.44 142.46,122.36 146.32,122.36 147.73,123.77 147.73,124.2 148.08,124.55 v4(148.49,124.55)
  IN1 w0.081: v8(131.74,104.96) 134.16,104.96 136.02,106.82 136.02,107.93 137.53,109.44 137.53,109.46 v8(137.8,109.73)
VREF_FBVDDQ: length 5.1
  TOP w0.254: PUW1.7 5.87,50.48 5.46,50.07 4.43,50.07 PCW6.1 3.57,49.68 PRW22.1 2.81,48.88 PRW32.1
VROM_SEL: length 0.9
  TOP w0.081: RH588.2 RH589.2
VSN_1PH: length 3.4
  TOP w0.203: PUZ1.51 146.78,129.85 147.2,130.27 v5(147.2,130.45) 147.88,130.45 PRZ27.2
  BOTTOM w0.081: v2(146.74,130.3) 146.88,130.45 v5(147.2,130.45)
  BOTTOM w0.254: v5(147.2,130.45) 147.26,130.39 PCZ31.2
VSN_2PH: length 4.7
  TOP w0.203: PUZ1.37 144.92,124.09 145.48,123.54 v5(145.98,123.54) 146.49,123.03 PCZ32.1
  BOTTOM w0.081: v5(145.98,123.54) 145.98,123.93 v2(146.39,124.34)
  BOTTOM w0.254: PRZ51.1 146.43,123.09 v5(145.98,123.54)
VSN_4PH: length 4.7
  TOP w0.203: PUZ1.2 145.32,131.31 v2(146.44,132.43) 147,133 v5(147.51,133) PCZ33.2
  BOTTOM w0.254: PRZ52.2 147.64,133.12 v5(147.51,133)
VSP_1PH: length 3
  TOP w0.203: PRZ148.2 147.9,131.28 147.55,131.28 147.31,131.04 v5(147.22,131.04) 147.18,131.04 PUZ1.52
  BOTTOM w0.254: v5(147.22,131.04) 147.46,131.28 PCZ28.2
VSP_2PH: length 5.8
  TOP w0.203: PCZ29.1 147.45,122.98 v5(146.63,123.79) 146.37,124.06 145.52,124.06 145.32,124.26 PUZ1.38
  BOTTOM w0.081: PRZ19.1 147.79,122.85 v2(148.35,122.29)
  BOTTOM w0.254: PRZ19.1 147.38,123.04 v5(146.63,123.79)
VSP_4PH: length 3.7
  TOP w0.203: PUZ1.1 145.72,131.21 146.53,132.02 147.42,132.02 v5(147.51,132.11) PCZ25.2
  BOTTOM w0.254: v5(147.51,132.11) 147.43,132.03 PRZ18.2
VTTREF_1.2V: length 2.7
  TOP w0.203: PCM16.1 143.77,46.74 v2(143.84,46.68) 144.11,46.68 144.32,46.88 PUM1.4
WAKE#: length 13.3
  TOP w0.081: RH453.1 113.45,18.88 113.45,19.75 RH4.2 113.03,20.4 113.26,20.63 113.38,20.63 v1(113.41,20.6)
  TOP w0.089: v5(116.9,27.83) 116.47,27.83 116.13,27.49 UH1.BB47
  GND2 w0.081: v12(113.69,20.83) 113.46,20.6 v1(113.41,20.6)
  IN2 w0.058: 116.27,22.69 116.27,21.99 115.44,21.16 114.02,21.16 v12(113.69,20.83)
  IN2 w0.089: 116.27,22.69 116.27,27.2 v5(116.9,27.83)
WAKE_PCH#: length 5.5
  TOP w0.122: UH1.BG44 114.2,25.33 114.86,24.66 114.86,23.74 113.67,22.56 112.69,22.56 RH545.1
WL_OFF#: length 55.5
  TOP w0.122: UH1.AP24 104.53,31.74 v5(104.68,31.59)
  IN3 w0.058: v9(141.38,32.28) 141.35,32.28 141.35,32.7 141.29,32.76 140.68,32.76 138.63,34.8 126.43,34.8 125.99,34.36 117.29,34.36 117.24,34.31
  IN3 w0.089: 117.24,34.31 114.04,34.31 113.33,33.61 108.9,33.61 108.58,33.29 105.91,33.29 105.35,32.73 105.35,32.25 v5(104.68,31.59)
  GND4 w0.081: v4(141.43,32.01) 141.43,32.23 v9(141.38,32.28)
  BOTTOM w0.081: JIO2.H1 141.26,25.14 139.95,26.44 v2(139.95,29.42) 139.95,29.86 141.02,30.93 141.02,31.6 v4(141.43,32.01)
  BOTTOM w0.089: RH520.2 102.97,26.99 102.97,29.52 104.69,31.24 104.69,31.58 v5(104.68,31.59)
XCLK_BIASREF: length 4.5
  TOP w0.152: UH1.T3 93.61,40.52
  TOP w0.305: 93.61,40.52 93.44,40.52 93.43,40.51 93.41,40.51 93.21,40.31
  TOP w0.381: 93.21,40.31 90.63,40.31 RH71.2 RH590.2
XDP_HOOK0: length 5.4
  TOP w0.081: JPCMC.27 145.63,139.98 144.97,139.98 142.68,142.27 RC355.1
XDP_ITP_PMODE: length 189.4
  TOP w0.081: JPCMC.26 144.41,139.59 142.43,141.57 141.75,141.57 141.65,141.47 v6(141.38,141.47) ; v6(77.77,64.52) v2(77.77,65.94) 77.77,68.84 78.61,69.67 78.61,73.64 81.75,76.77 81.75,97.98 82.18,98.41 v3(82.18,99.96)
  TOP w0.089: UH1.AL3 93.89,33.63 93.46,33.63 93.34,33.52 92.86,33.52 92.85,33.51 v1(92.77,33.51)
  GND2 w0.089: v1(92.77,33.51) v3(92.41,33.51)
  IN3 w0.058: v3(82.18,99.96) 83.25,101.04 v9(83.25,103.98)
  GND4 w0.081: v6(83.46,104.67) 83.25,104.47 v9(83.25,103.98)
  GND4 w0.089: v3(92.41,33.51) v6(92.01,33.51)
  IN4 w0.058: 90.32,34.86 89.18,36 89.18,36.93 88.18,37.93 86.57,37.93 79.27,45.23 79.27,49.33 79.61,49.67 79.61,54.82 78.25,56.17 78.25,64.04 v6(77.77,64.52) ; v6(141.38,141.47) 141.38,141.21 141.36,141.2 141.36,140.05 143.49,137.92 143.49,136.28 142.71,135.5 142.71,134.69 140.87,132.85 137.17,132.85 135.69,134.34 129.26,134.34 129.12,134.34 128.99,134.34 128.63,134.7 121.4,134.7 120.84,134.14 100.51,134.14 100.33,133.97 99.08,133.97 98.99,134.06 98.93,134.11 90.96,134.11 90.95,134.12 86.68,134.12 86.11,133.54 85,133.54 80.29,128.84 80.29,122.23 79.91,121.85 79.91,117.67 84.37,113.21 84.37,105.54 83.51,104.67 v6(83.46,104.67)
  IN4 w0.089: 90.32,34.86 91.67,33.51 v6(92.01,33.51)
XDP_PRDY#: length 211.3
  TOP w0.081: v5(135.23,104.24) 135.51,103.96 UC1.BP27
  TOP w0.089: v5(90.84,31.99) 91.29,31.54 94.07,31.54 94.12,31.49 94.77,31.49 95,31.72 95,32.4 94.94,32.45 UH1.AM5
  GND2 w0.081: v1(145.3,142.95) v3(144.88,142.95)
  IN2 w0.058: v5(135.23,104.24) 136.09,105.11 138.68,105.11 139.05,105.47 139.05,107.05 138.68,107.41 138.68,108.66 139.17,109.15 139.17,111.94 136.78,114.32 114.71,114.32 113.54,115.5 104.39,115.5 104.37,115.48 102.83,115.48 100.88,113.54 95.85,113.54 95.82,113.51 v3(85.43,113.51)
  IN3 w0.058: v3(85.43,113.51) 85.61,113.33 85.61,106.35 87.66,104.29 87.66,91.61 88.59,90.69 88.59,87.44 89.32,86.7 89.32,84.98 85.61,81.27 85.61,66.44 85.03,65.86 85.03,54.76 84.55,54.28 84.55,46.73 85.61,45.67 85.61,40.66 89.64,36.63 89.64,34.91 90.84,33.71 v5(90.84,31.99) ; v3(144.88,142.95) 144.73,142.8 144.73,139.72 147.32,137.13 148.24,137.13 151.11,134.26 151.11,130.24 150.27,129.4 150.27,121.09 146.13,116.95 146.13,116.67 145.35,115.89 145.35,112.37 137.22,104.24 v5(135.23,104.24)
XDP_PREQ#: length 206.9
  TOP w0.076: UC1.BL30 133.96,105.69 139.12,105.69 v1(139.31,105.5)
  TOP w0.122: v5(94.56,33.61) 94.56,33.42 94.26,33.13 93.89,33.13 UH1.AL2
  GND2 w0.081: v1(145.48,142.44) v3(145.11,142.44) ; v1(139.31,105.5) v3(139.64,105.5)
  IN2 w0.058: v3(139.64,105.5) 139.64,106.66 138.91,107.39 138.91,108.66 139.33,109.08 139.33,112.01 136.85,114.48 114.78,114.48 113.6,115.66 104.32,115.66 104.31,115.64 102.74,115.64 100.78,113.68 95.79,113.68 95.76,113.66 90,113.66 89.98,113.67 85.74,113.67 v3(85.35,114.06)
  IN3 w0.058: v3(145.11,142.44) 144.89,142.22 144.89,139.79 147.39,137.29 148.31,137.29 151.27,134.33 151.27,130.17 150.43,129.33 150.43,121.02 146.29,116.88 146.29,116.61 145.51,115.82 145.51,112.3 139.64,106.43 v3(139.64,105.5) ; v5(94.56,33.61) 94.23,33.94 90.84,33.94 89.8,34.98 89.8,36.7 85.77,40.73 85.77,45.74 84.71,46.8 84.71,54.22 85.19,54.69 85.19,65.8 85.77,66.38 85.77,81.2 89.48,84.91 89.48,86.77 88.75,87.51 88.75,90.76 87.82,91.68 87.82,104.36 85.77,106.41 85.77,113.64 v3(85.35,114.06)
XDP_SPI_IO2: length 7.5
  TOP w0.081: JPCMC.24 146.31,138.9 142.25,138.9 RC354.1 140.64,139.07 v2(139.57,139.07)
XDP_SPI_SI: length 223.8
  TOP w0.081: v3(141.36,140.68) 142.89,139.16 145.86,139.16 146.24,139.53 JPCMC.25 ; v8(121.05,55.65) 121.05,49.25 v2(122.54,47.75) 125.87,44.43 125.87,40.81 123.29,38.23 123.29,33.77 RH1.1
  IN1 w0.058: v11(93.66,97.63) 93.45,97.42 93.45,88.75 95.47,86.73 95.47,85.69 93.76,83.97 91,83.97 89.62,82.58 89.62,73.17 91.44,71.34 91.44,59.32 93.27,57.5 100.36,57.5 100.92,56.94 105.18,56.94 105.58,57.34 107.79,57.34 108.35,56.78 114.15,56.78 114.38,56.55 119.88,56.55 120.78,55.65 v8(121.05,55.65)
  GND2 w0.081: v11(93.66,97.63) v12(93.66,97.94)
  IN2 w0.058: v3(135.1,138.53) 133.02,136.46 99,136.46 97.27,134.73 94.3,134.73 94.13,134.55 86.28,134.55 84.76,133.03 84.76,132.96 82.01,130.21 82.01,123.68 82.47,123.22 82.47,116.41 83.36,115.53 83.36,114.09 82.6,113.34 80.87,113.34 80.58,113.63 78.32,113.63 77.98,113.29 77.98,111.75 78.3,111.42 85.37,111.42 86.03,110.76 92.18,110.76 93.45,109.49 93.45,98.16 v12(93.66,97.94)
  IN3 w0.058: v3(135.1,138.53) 140.72,138.53 141.36,139.18 v3(141.36,140.68)
XDP_TCK: length 190.7
  TOP w0.081: v8(141.82,143.93) 142.75,143.93 145.05,141.63 145.34,141.63 JPCMC.31
  TOP w0.122: v1(92.81,34.38) 92.92,34.49 93.25,34.49 93.25,34.49 94.12,34.49 UH1.AJ3
  IN1 w0.058: v3(145.95,137.09) 145.11,137.09 141.81,140.39 141.81,143.57 141.83,143.6 141.83,143.66 141.82,143.67 v8(141.82,143.93)
  GND2 w0.089: v3(92.99,34.67) 92.99,34.57 v1(92.81,34.38)
  IN3 w0.058: v3(92.99,34.67) 92.99,34.59 92.59,34.19 90.81,34.19 89.96,35.04 89.96,36.77 85.93,40.8 85.93,45.8 84.87,46.86 84.87,54.15 85.35,54.63 85.35,65.73 85.93,66.31 85.93,81.13 89.65,84.85 89.65,86.83 88.91,87.57 88.91,90.82 87.98,91.74 87.98,104.42 85.93,106.48 85.93,113.95 81.97,117.91 81.65,118.23 81.65,130 83.49,131.85 83.58,131.85 85.12,133.39 86.07,133.39 86.83,134.15 88.58,134.15 89.95,135.52 96.06,135.52 98.06,137.51 100.23,137.51 100.98,136.76 104.82,136.76 106.21,135.37 107.17,135.37 108.52,136.72 122.82,136.72 123.14,137.04 140.3,137.04 140.81,137.54 142.41,137.54 142.86,137.09 v3(145.95,137.09)
XDP_TDI: length 214.4
  TOP w0.076: v5(133.01,107.18) 133.34,107.51 UC1.BL32
  TOP w0.089: v5(91.57,35.65) 91.75,35.47 93.04,35.47 93.48,35.02 UH1.AH2
  GND2 w0.081: v1(139.31,102.83) v3(139.7,102.83) ; v1(145.47,140.87) v3(145.78,140.55)
  IN2 w0.058: v3(86.77,115.22) 86.77,114.65 86.91,114.51 90.54,114.51 91.19,115.16 99.97,115.16 101.01,116.2 101.01,116.2 101.11,116.3 113.87,116.3 115.02,115.14 125.58,115.14 126.22,115.78 127.68,115.78 128.34,115.12 137.12,115.12 139.97,112.27 139.97,108.7 139.5,108.23 139.5,107.77 140.46,106.81 140.46,103.6 v3(139.7,102.83)
  IN3 w0.058: 90.68,46.75 89.07,48.36 89.07,51.04 86.78,53.34 86.78,80.78 90.51,84.51 90.51,90.13 88.62,92.01 88.62,95.98 90.41,97.76 90.41,99.9 89.29,101.02 89.29,104.04 86.57,106.76 86.57,113.88 86.77,114.08 v3(86.77,115.22) ; v3(145.78,140.55) 145.78,139.57 147.59,137.77 148.51,137.77 151.8,134.47 151.8,121.72 146.77,116.69 146.77,116.41 145.99,115.62 145.99,112.11 141.45,107.57 141.45,106 140.56,105.11 140.56,103.69 v3(139.7,102.83) 135.67,102.83 134.39,104.12 134.39,105.8 v5(133.01,107.18)
  IN3 w0.089: 90.68,46.75 90.68,39.78 91.57,38.89 v5(91.57,35.65)
  BOTTOM w0.089: v10(92.2,37.44) 91.57,36.81 v5(91.57,35.65)
XDP_TDO: length 207.2
  TOP w0.076: v1(139.31,104.61) 138.87,105.05 137.24,105.05 UC1.BT28
  TOP w0.089: UH1.AH3 93.95,34.9 93.75,34.7 93.36,34.7 93.17,34.9 92.87,34.9
  TOP w0.122: v5(90.84,35.11) 91.22,34.72 91.99,34.72 92.16,34.9 92.87,34.9
  GND2 w0.081: v1(139.31,104.61) v3(139.64,104.61) ; v1(145.8,143.16) v3(145.8,143.56)
  IN2 w0.058: v3(139.64,104.61) 140.14,105.12 140.14,106.67 139.2,107.61 139.2,108.5 139.65,108.94 139.65,112.14 136.98,114.8 114.91,114.8 113.73,115.98 104.19,115.98 104.17,115.96 102.58,115.96 102.48,115.87 101.95,115.33 101.95,115.33 101.74,115.12 101.74,115.12 101.46,114.84 91.33,114.84 90.67,114.19 86.45,114.19 86.08,114.56 v3(86.08,115.08)
  IN3 w0.058: v3(86.08,115.08) 86.08,114.56 86.25,114.39 86.25,106.63 88.97,103.91 88.97,99.22 88.3,98.56 88.3,91.88 89.64,90.54 89.64,87.53 90.17,86.99 90.17,84.63 86.46,80.91 86.46,52.99 88.52,50.93 88.52,47.81 90.04,46.29 ; v3(139.64,104.61) 139.64,104.64 140.14,105.15 140.14,106.71 145.67,112.24 145.67,115.75 146.45,116.54 146.45,116.82 150.59,120.96 150.59,129.27 151.43,130.11 151.43,134.39 148.38,137.45 147.45,137.45 145.05,139.85 145.05,141.8 145.47,142.22 145.47,143.23 v3(145.8,143.56) ; 90.42,36.98 90.42,35.52 v5(90.84,35.11)
  IN3 w0.089: 90.42,36.98 90.43,36.98 90.43,39.01 90.04,39.4 90.04,46.29
  BOTTOM w0.089: v10(90.42,37.18) 90.42,35.52 v5(90.84,35.11)
XDP_TMS: length 209.5
  TOP w0.076: 137.42,104.48 137.23,104.28 137,104.28 136.56,104.28 136.46,104.38 136.46,104.75 136.26,104.96 135.85,104.96 UC1.BP28
  TOP w0.089: 137.42,104.48 137.55,104.48 138.3,103.72 v5(138.54,103.72) v1(139.31,103.72) ; UH1.AJ4 94.37,34.19 93.96,34.19 93.85,34.3 93.31,34.3 93.14,34.12 92.67,34.12 v1(92.37,34.43)
  GND2 w0.081: v1(139.31,103.72) v3(139.64,103.72) ; v1(145.04,141.21) v3(145.39,141.56)
  GND2 w0.089: v1(92.37,34.43) 92.37,34.56 92.49,34.68 v3(92.49,34.74)
  IN2 w0.058: v3(139.64,103.72) 139.22,104.14 139.22,104.88 139.4,105.06 139.65,105.06 139.98,105.39 139.98,106.53 139.05,107.45 139.05,108.58 139.49,109.01 139.49,112.07 136.92,114.64 114.84,114.64 113.67,115.82 104.25,115.82 104.24,115.8 102.64,115.8 101.52,114.68 91.39,114.68 90.74,114.03 86.33,114.03 85.74,114.62 v3(85.74,114.62)
  IN3 w0.058: v3(85.74,114.62) 86.09,114.27 86.09,106.57 88.14,104.51 88.14,91.81 89.07,90.89 89.07,87.64 89.82,86.88 89.82,84.78 86.09,81.04 86.09,66.25 85.51,65.66 85.51,54.56 85.03,54.08 85.03,46.93 86.09,45.87 86.09,40.86 90.12,36.83 90.12,35.11 90.86,34.37 92.19,34.37 92.37,34.55 92.37,34.56 92.49,34.68 v3(92.49,34.74) ; v3(139.64,103.72) 139.64,103.79 140.4,104.55 140.4,105.18 141.29,106.07 141.29,107.64 145.83,112.17 145.83,115.69 146.61,116.48 146.61,116.75 151.64,121.78 151.64,134.41 148.44,137.61 147.52,137.61 145.21,139.92 145.21,141.38 v3(145.39,141.56)
  BOTTOM w0.081: v10(138.54,104.38) v5(138.54,103.72)
XMP1: length 53.4
  TOP w0.081: PRM8.2 147.52,39.55 147.52,38.12 146.71,37.3 v2(145.27,37.3) 144.57,37.3 142.87,35.61 134.83,35.61 133.62,36.82 133.62,37.69 133.35,37.96 130.45,37.96 129.32,36.83 129.05,36.83 v8(128.88,36.65)
  TOP w0.089: v5(109.25,26.21) 109.36,26.32 UH1.BE34
  IN1 w0.058: 117.24,36.27 117.26,36.27 117.27,36.28 117.37,36.28 118.68,34.97 121.07,34.97 122.24,36.14 128.36,36.14 v8(128.88,36.65)
  IN1 w0.089: v5(109.25,26.21) 109.25,26.54 108.71,27.08 108.71,28.33 109.35,28.96 109.35,29.85 110.72,31.22 111.39,31.22 112.8,32.63 112.8,34.14 113.44,34.78 113.44,35.51 114.2,36.27 117.24,36.27
