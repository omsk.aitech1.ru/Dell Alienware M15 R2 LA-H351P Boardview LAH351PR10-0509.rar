# Allegro board LAH351PR10-0509.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PL13  BLM15AX601SN1D_2P  [MURAT_BLM15AX601SN1D_2P]  18.8 24.23 90 top
PL14  9A Z80 10M 1812_2P  [9A_Z80_1812_2P]  30.02 10.8 270 top
PL15  9A Z80 10M 1812_2P  [9A_Z80_1812_2P]  33.85 10.2 270 top
PL301  1.5UH_9A_20%_7X7X3_M  [L_7X7X3_M_2P]  65.04 20.7 270 top
PL311  -  [5A_Z80_0805_2P]  65.32 33.17 270 top
PL501  1.5UH_MMD-06CZ-1R5M-V1_9A_20%  [MAG_MMD-06CZ-1R5M-V1_2P]  53.21 17.68 0 top
PL511  -  [5A_Z80_0805_2P]  60.92 33.2 270 top
PL711  1UH_6.6A_20%_5X5X3_M  [L_5X5X3_M_2P]  15.49 22.08 270 top
PL1001  1UH_PCMB042T-1R0MS_4.5A_20%  [CYNTE_PCMB042T-1R0MS_2P]  69.15 109.05 90 bottom
PL1011  -  [5A_Z80_0805_2P]  76.39 98.49 90 bottom
PL1802  1UH_PCMB042T-1R0MS_4.5A_20%  [CYNTE_PCMB042T-1R0MS_2P]  52.04 6.19 0 top
PL1811  -  [5A_Z80_0805_2P]  43.31 7.31 90 top
PL6123  -  [5A_Z80_0805_2P]  132.31 45.57 90 top
PL6124  2.2UH_SLA-05AHN2R2MX2L_5A_20%  [MAG_SLA-05AHN2R2MX2L_2P]  139.37 38.2 180 top
PLB1  3.3UH_PCMB103T-3R3MS_9A_20%  [CYNTE_PCMB103T-3R3MS_2P]  32.69 23.72 270 top
PLG01  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  149.71 93.71 180 top
PLG02  0.68UH_MMD05BDR68MR1L_17A_20%  [MAG_MMD-05BD-R68M-R1L_4P]  148.56 107.98 180 top
PLH01  1UH_11A_20%_7X7X3_M  [L_7X7X3_M_2P]  131.55 28.73 180 top
PLH02  1UH_MLD-06CZH1R0M-N1L_11.3A_20%  [MAG_MLD-06CZH1R0M-N1L_2P]  130.57 51.87 180 top
PLH11  -  [5A_Z80_0805_2P]  137.54 23.99 270 top
PLM01  1UH_MLD-06CZH1R0M-N1L_11.3A_20%  [MAG_MLD-06CZH1R0M-N1L_2P]  148.34 66.21 270 top
PLM11  -  [5A_Z80_0805_2P]  139.44 49.83 90 bottom
PLV01  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  27.66 56.03 270 top
PLV02  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  35.22 55.98 270 top
PLV03  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  42.89 55.91 270 top
PLV04  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  50.6 55.97 270 top
PLV05  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  58.32 56.01 270 top
PLV06  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  66.11 55.98 270 top
PLV07  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  73.9 56.05 270 top
PLV08  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  73.24 84.04 0 top
PLV09  2.2UH_CMLE063T-2R2MS-70__9A_20%  [MAG_MMD-06CZ-1R5M-V1_2P]  43.09 28.12 180 top
PLV10  2.2UH_CMLE063T-2R2MS-70__9A_20%  [MAG_MMD-06CZ-1R5M-V1_2P]  42.28 34.91 180 top
PLW01  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  13.81 60.83 0 top
PLW02  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  19.99 49.04 90 top
PLW11  9A Z80 10M 1812_2P  [9A_Z80_1812_2P]  12.95 40.86 90 bottom
PLW12  9A Z80 10M 1812_2P  [9A_Z80_1812_2P]  54.82 36.86 180 bottom
PLW13  9A Z80 10M 1812_2P  [9A_Z80_1812_2P]  20.43 36.6 270 bottom
PLW14  9A Z80 10M 1812_2P  [9A_Z80_1812_2P]  24.45 36.47 270 bottom
PLZ01  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  86.3 124.15 270 top
PLZ02  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  93.98 124.18 270 top
PLZ03  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  101.71 124.21 270 top
PLZ04  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  109.47 124.21 270 top
PLZ05  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  118.24 132.72 270 top
PLZ06  0.15UH_TMPA0624SR15MN_25A_20%  [TAI-T_TMPA0624S-R15MNR8805D_4P]  121.52 120.83 180 top
PLZ11  9A Z80 10M 1812_2P  [9A_Z80_1812_2P]  145.8 71.51 90 top
PLZ12  9A Z80 10M 1812_2P  [9A_Z80_1812_2P]  149.61 71.51 90 top
PQ1  -  [LMBT3904WT1G_SC70-3]  13.92 29.12 270 top
PQ4  -  [FDV301N-G_SOT23-3]  12.28 25.94 90 top
PQ5  L2N7002WT1G_SC70-3  [2N7002KW_SOT323-3]  19.18 3.93 0 top
PQ6  -  [L2N7002DW1T1G_SC88-6]  15.98 2.87 0 top
PQB1  AON6354_N_DFN56-8-5  [Q_N_DFN56-8-5]  32.18 20.51 0 bottom
PQB2  -  [AONR36368_DFN3X3EP]  31.65 23.18 90 bottom
PQB11  EMP21N03HC_N_DFN56-8-5  [Q_N_DFN56-8-5]  29.08 25.11 180 bottom
PQB12  EMP21N03HC_N_DFN56-8-5  [Q_N_DFN56-8-5]  19.11 22.83 0 bottom
PQB13  EMP21N03HC_N_DFN56-8-5  [Q_N_DFN56-8-5]  22.92 25.11 180 bottom
PQB14  EMP21N03HC_N_DFN56-8-5  [Q_N_DFN56-8-5]  25.27 22.83 0 bottom
PQB15  EMP21N03HC_N_DFN56-8-5  [Q_N_DFN56-8-5]  25.49 14.9 90 top
PQB16  L2N7002WT1G_SC70-3  [2N7002KW_SOT323-3]  45.36 22.98 90 top
PQB17  -  [LMUN5113T1G_SOT323-3]  25.43 7.08 270 top
PQB18  LMUN5236T1G_SOT323-3  [LTC015EUBFS8TL_UMT3F]  20.51 8.12 180 top
PQH01  -  [AON7408L_DFN8-5]  129.88 32.64 0 bottom
PQH02  -  [AON7506_DFN3X3-8-5]  129.38 37.43 0 bottom
PQM01  -  [AON6380_DFN5X6-8-5]  146.88 58.76 0 bottom
PQM02  AON6354_N_DFN56-8-5  [Q_N_DFN56-8-5]  145.18 51.72 0 top
PQM11  -  [L2N7002DW1T1G_SC88-6]  145.17 38.81 90 top
PQV1  -  [LBSS139DW1T1G_SOT363-6]  71.28 16.84 90 top
PQV01  -  [AOE6930_DFN5X6E8-10]  50.5 31.35 90 top
PQV02  -  [AOE6930_DFN5X6E8-10]  51.14 25.8 90 top
PQV3  -  [AONX38168_DFN5X6E-8-10]  32.54 28.06 90 bottom
PQV4  -  [AONX38168_DFN5X6E-8-10]  32.54 33.78 90 bottom
PQW1  -  [LBSS139DW1T1G_SOT363-6]  5.37 24.1 0 top
PQW2  -  [LBSS139DW1T1G_SOT363-6]  2.97 24.1 0 top
PR2  1K_0402_1%  [R_0402]  18.29 11.34 270 top
PR3  2.2K_0402_1%  [R_0402]  11.93 22.62 90 top
PR4  33_0402_5%  [R_0402]  11.15 23.54 270 top
PR6  100K_0402_1%  [R_0402]  14.05 27.33 180 top
PR8  10K_0402_1%  [R_0402]  8.57 24.15 90 top
PR9  15K_0402_1%  [R_0402]  18.54 29.19 270 top
PR11  1K_0402_1%  [R_0402]  18.22 13.57 270 top
PR16  10K_0402_1%  [R_0402]  26.73 3.28 270 top
PR19  100_0402_1%  [R_0402]  31.78 2.58 180 top
PR21  100_0402_1%  [R_0402]  31.78 3.41 180 top
PR22  100_0402_1%  [R_0402]  26.73 4.93 270 top
PR23  110K_0402_1%  [R_0402]  50.99 13.19 270 top
PR24  14.7K_0402_1%  [R_0402]  43.74 7.52 0 bottom
PR25  12.1K_0402_1%  [R_0402]  43.75 6.64 0 bottom
PR26  100K_0402_1%  [R_0402]  49.21 12.27 90 top
PR28  100K_0402_1%  [R_0402]  20.07 7.01 180 top
PR29  1M_0402_1%  [R_0402]  16.69 5.63 0 top
PR31  1M_0402_1%  [R_0402]  15.93 6.57 270 top
PR32  10K_0402_1%  [R_0402]  18.38 2.9 270 top
PR33  100K_0402_1%  [R_0402]  14.91 1.93 0 top
PR34  0_0402_5%  [R_0402]  19.16 2.25 0 top
PR301  4.7_1206_5%  [R_1206]  63.8 23.76 90 bottom
PR302  0_0603_5%  [R_0603]  67.08 24.48 270 top
PR303  1K_0402_5%  [R_0402]  59.94 22.65 270 bottom
PR304  10K_0402_1%  [R_0402]  61.58 28.22 0 top
PR305  150K_0402_1%  [R_0402]  60.85 25.3 180 bottom
PR306  150K_0402_1%  [R_0402]  52.84 26.7 0 top
PR307  150K_0402_1%  [R_0402]  60.83 23.51 90 bottom
PR308  499K_0402_1%  [R_0402]  53 25.52 90 bottom
PR501  4.7_1206_5%  [R_1206]  55.49 18.06 180 bottom
PR502  0_0603_5%  [R_0603]  56.69 19.69 0 bottom
PR503  0_0402_5%  [R_0402]  43.56 8.78 90 bottom
PR504  0_0402_5%  [R_0402]  39.5 4.84 90 bottom
PR505  0_0402_5%  [R_0402]  44.39 8.78 90 bottom
PR506  1K_0402_5%  [R_0402]  50.79 22.32 0 top
PR507  1M_0402_5%  [R_0402]  42.74 9.69 270 bottom
PR508  2.2K_0402_5%  [R_0402]  40.96 8.78 90 bottom
PR509  10K_0402_1%  [R_0402]  61.58 28.22 0 bottom
PR510  150K_0402_1%  [R_0402]  49.97 24.04 270 top
PR511  150K_0402_1%  [R_0402]  51.75 23.13 90 top
PR1101  4.7_0805_5%  [R_0805]  70.03 109.58 180 top
PR1102  0_0603_5%  [R_0603]  72.96 109.76 270 top
PR1103  10K_0402_5%  [R_0402]  67.49 102.3 180 bottom
PR1104  10K_0402_5%  [R_0402]  67.49 103.13 180 bottom
PR1105  0_0402_5%  [R_0402]  68.26 101.84 270 bottom
PR1106  0_0402_5%  [R_0402]  70.87 101.84 270 bottom
PR1107  1K_0402_5%  [R_0402]  68.33 103.96 90 bottom
PR1108  10K_0402_1%  [R_0402]  71.69 100.93 90 bottom
PR1109  1M_0402_1%  [R_0402]  69.09 101.84 270 bottom
PR1110  21.5K_0402_1%  [R_0402]  66.6 104.87 0 bottom
PR1111  31.6K_0402_1%  [R_0402]  68.34 105.69 180 bottom
PR1807  4.7_0805_5%  [R_0805]  52.35 9.55 90 top
PR1808  0_0603_5%  [R_0603]  49.58 11.25 270 top
PR1809  10K_0402_5%  [R_0402]  48.45 3.53 270 top
PR1810  10K_0402_5%  [R_0402]  52.97 3.27 180 top
PR1811  0_0402_5%  [R_0402]  47.51 1.74 180 top
PR1812  1K_0402_5%  [R_0402]  50.18 3.46 180 top
PR1813  10K_0402_5%  [R_0402]  46.04 5.57 270 bottom
PR1814  10K_0402_1%  [R_0402]  49.35 1.74 180 top
PR1815  1M_0402_1%  [R_0402]  47.51 2.57 180 top
PR1816  20K_0402_1%  [R_0402]  50.18 2.63 180 top
PR2501  0_0402_5%  [R_0402]  85.92 58.36 90 top
PR2502  1M_0402_1%  [R_0402]  84.07 59.27 270 top
PR2503  100K_0402_1%  [R_0402]  83.28 58.37 90 top
PR2504  21.5K_0402_1%  [R_0402]  85.9 71.24 180 top
PR2505  10K_0402_1%  [R_0402]  84.9 70.22 270 top
PR2506  2.2_0402_1%  [R_0402]  90.81 59.72 180 top
PR2507  100K_0402_1%  [R_0402]  136.84 34.52 270 bottom
PR2508  40.2K_0402_1%  [R_0402]  137.6 33.61 90 bottom
PR2509  4.7_1206_5%  [R_1206]  134.15 40.01 270 bottom
PR2510  12K_0402_1%  [R_0402]  136.08 33.61 90 bottom
PR2511  105K_0402_1%  [R_0402]  134.29 33.56 0 bottom
PR2512  56K_0402_1%  [R_0402]  139.03 34.52 270 bottom
PRA1  4.7_0603_1%  [R_0603]  142.48 98.14 0 top
PRA2  2.2_1206_5%  [R_1206]  145.33 106.4 180 bottom
PRA3  2_0402_5%  [R_0402]  140.92 101.27 270 bottom
PRB1  3M_0402_5%  [R_0402]  41.49 22.05 0 top
PRB2  0.005_1206_1%  [R_1206_4P-D]  26.7 12.98 270 top
PRB3  4.7_0603_5%  [R_0603]  36.37 22.8 90 bottom
PRB4  10_1206_5%  [R_1206]  41.02 15.52 270 top
PRB5  2.2_0603_5%  [R_0603]  22.76 26.06 180 top
PRB6  1_0402_5%  [R_0402]  47.67 23.99 270 bottom
PRB7  2_0402_5%  [R_0402]  46.71 23.99 270 bottom
PRB8  2_0402_5%  [R_0402]  41.16 12.09 180 bottom
PRB9  4.7_0402_5%  [R_0402]  41.02 16.59 90 top
PRB10  0.005_1206_1%  [R_1206_4P-D]  16.76 19.38 90 bottom
PRB11  0_0603_5%  [R_0603]  23.71 10.89 270 top
PRB12  0_0603_5%  [R_0603]  22.48 9.49 90 top
PRB13  0_0603_5%  [R_0603]  38.99 19.9 180 bottom
PRB14  0_0603_5%  [R_0603]  40.39 20.73 90 bottom
PRB15  0_0603_5%  [R_0603]  41.85 22.24 90 bottom
PRB16  0_0402_5%  [R_0402]  50.18 17.36 180 bottom
PRB17  0_0402_5%  [R_0402]  50.18 17.36 180 top
PRB18  0_0402_5%  [R_0402]  39.51 15.08 180 bottom
PRB19  0_0402_5%  [R_0402]  46.16 12.72 90 top
PRB20  0_0402_5%  [R_0402]  50.18 18.19 180 bottom
PRB21  0_0402_5%  [R_0402]  41.16 11.27 180 bottom
PRB22  0_0402_5%  [R_0402]  50.18 15.71 180 bottom
PRB23  0_0402_5%  [R_0402]  50.18 14.06 180 bottom
PRB24  102K_0402_1%  [R_0402]  45.34 13.63 270 bottom
PRB25  100_0402_1%  [R_0402]  47.05 13.63 270 top
PRB26  100_0402_1%  [R_0402]  42.85 22.11 90 bottom
PRB27  1K_0402_1%  [R_0402]  50.18 16.54 180 bottom
PRB28  10K_0402_1%  [R_0402]  44.51 13.63 270 bottom
PRB30  100K_0402_1%  [R_0402]  41.22 15.08 180 bottom
PRB31  100K_0402_1%  [R_0402]  50.18 19.01 180 bottom
PRB32  1M_0402_1%  [R_0402]  41.4 22.94 0 top
PRB33  10.5K_0402_1%  [R_0402]  49.26 14.89 0 bottom
PRB34  200K_0402_1%  [R_0402]  49.26 19.01 0 top
PRB35  200K_0402_1%  [R_0402]  40.31 14.25 0 bottom
PRB36  110K_0402_1%  [R_0402]  41.22 13.43 180 bottom
PRB37  255K_0402_1%  [R_0402]  47.94 13.63 270 bottom
PRB38  365K_0402_1%  [R_0402]  46.16 13.63 270 bottom
PRB39  392K_0402_1%  [R_0402]  50.18 20.79 180 bottom
PRB40  4.02K_0402_1%  [R_0402]  44.7 23.06 270 bottom
PRB41  4.02K_0402_1%  [R_0402]  43.81 23.04 270 bottom
PRB42  53.6K_0402_1%  [R_0402]  49.26 19.9 0 top
PRG01  2_0402_5%  [R_0402]  141.03 85.38 270 top
PRG02  4.7_0603_1%  [R_0603]  141.63 85.42 90 bottom
PRG03  10_0402_1%  [R_0402]  145.28 94.35 90 bottom
PRG04  2.2_1206_5%  [R_1206]  144.89 89.21 90 bottom
PRH1  4.7_0603_5%  [R_0603]  130.62 28.16 270 bottom
PRH2  2.2_0603_5%  [R_0603]  134.3 28.58 90 top
PRH3  10K_0402_1%  [R_0402]  140.74 33.07 90 top
PRH4  100K_0402_1%  [R_0402]  139.7 27.07 180 top
PRH5  100K_0402_1%  [R_0402]  140.89 31.69 270 top
PRH6  470K_0402_1%  [R_0402]  138.82 33.1 180 top
PRH7  4.99K_0402_1%  [R_0402]  139.88 33.09 90 top
PRH8  105K_0402_1%  [R_0402]  140.93 27.16 90 top
PRH9  35.7K_0402_1%  [R_0402]  136.07 55.02 0 top
PRH10  4.7_0805_5%  [R_0805]  130.25 54.13 270 bottom
PRH11  0_0603_5%  [R_0603]  131.57 50.07 0 bottom
PRH12  0_0402_5%  [R_0402]  136.07 55.91 0 top
PRH13  0_0402_5%  [R_0402]  138.23 51.78 0 top
PRH14  10K_0402_5%  [R_0402]  138.23 54.45 0 top
PRH15  10K_0402_5%  [R_0402]  138.23 55.27 0 top
PRH16  100_0402_5%  [R_0402]  134.98 56.78 0 top
PRH17  1K_0402_5%  [R_0402]  134.43 55.86 270 top
PRH18  10K_0402_5%  [R_0402]  139.14 50.95 180 top
PRH19  1M_0402_1%  [R_0402]  138.23 52.61 0 top
PRH20  21K_0402_1%  [R_0402]  135.25 54.94 90 top
PRH21  0_0402_5%  [R_0402]  90.09 85.94 0 top
PRM1  4.7_0603_5%  [R_0603]  147.11 60.67 0 bottom
PRM2  2.2_0603_5%  [R_0603]  150.69 42.19 270 top
PRM3  2.2_0603_5%  [R_0603]  150.74 53.68 270 top
PRM4  5.1_0603_5%  [R_0603]  150.7 43.23 90 top
PRM5  0_0402_5%  [R_0402]  147.56 42.97 90 top
PRM6  0_0402_5%  [R_0402]  146.75 41.13 0 top
PRM7  0_0402_5%  [R_0402]  145.92 42.08 270 top
PRM8  1K_0402_1%  [R_0402]  146.01 40.15 0 top
PRM9  1K_0402_1%  [R_0402]  142.37 38.67 180 top
PRM10  100K_0402_1%  [R_0402]  149.21 42.97 90 top
PRM11  100K_0402_1%  [R_0402]  146.01 39.32 0 top
PRM12  100K_0402_1%  [R_0402]  142.39 39.52 180 top
PRM13  5K_0402_1%  [R_0402]  149.9 45.79 90 top
PRM14  12K_0402_1%  [R_0402]  144.15 44.62 90 top
PRM15  20K_0402_1%  [R_0402]  145.67 43.88 270 top
PRM16  60.4K_0402_1%  [R_0402]  144.91 43.88 270 top
PRM17  60.4K_0402_1%  [R_0402]  144.15 43.88 270 top
PRM18  887K_0402_1%  [R_0402]  148.39 42.97 90 top
PRV2  4.32K_0402_1%  [R_0402]  69.1 31.52 180 top
PRV3  3.6K_0402_1%  [R_0402]  79.17 28.54 0 bottom
PRV4  4.3K_0402_1%  [R_0402]  79.17 28.67 0 top
PRV5  2.2_0603_1%  [R_0603]  68.11 22.63 0 bottom
PRV6  309_0402_1%  [R_0402]  68.19 33.17 0 top
PRV7  1.8K_0402_5%  [R_0402]  72.71 22.71 270 top
PRV9  0_0402_5%  [R_0402]  80.09 31.59 180 top
PRV10  1.8K_0402_5%  [R_0402]  76.77 22.71 270 top
PRV11  1.8K_0402_5%  [R_0402]  71.69 22.71 270 top
PRV12  0_0402_5%  [R_0402]  81.22 31.6 270 bottom
PRV13  0_0402_5%  [R_0402]  79.11 36.35 0 bottom
PRV14  1.8K_0402_5%  [R_0402]  70.68 22.71 270 top
PRV15  1.8K_0402_5%  [R_0402]  73.72 22.71 270 top
PRV16  1.8K_0402_5%  [R_0402]  75.76 22.71 270 top
PRV18  0_0402_5%  [R_0402]  71.45 33.15 0 bottom
PRV20  0_0402_5%  [R_0402]  72.29 33.84 90 top
PRV22  0_0402_5%  [R_0402]  70.27 34.76 270 top
PRV23  1.8K_0402_5%  [R_0402]  77.79 22.71 270 top
PRV24  0_0402_5%  [R_0402]  81.28 32.72 90 top
PRV25  0_0402_5%  [R_0402]  80.9 28.62 270 top
PRV26  10K_0402_5%  [R_0402]  73.47 30.62 90 bottom
PRV27  1.8K_0402_5%  [R_0402]  74.74 22.71 270 top
PRV28  0_0402_5%  [R_0402]  77.86 33.87 90 top
PRV30  0_0402_5%  [R_0402]  72.26 18.96 270 top
PRV31  0_0402_5%  [R_0402]  75.18 32.3 270 bottom
PRV32  0_0402_5%  [R_0402]  80.01 30.63 180 bottom
PRV34  0_0402_5%  [R_0402]  79.11 35.52 0 bottom
PRV36  0_0402_5%  [R_0402]  79.17 33.68 0 top
PRV37  0_0402_5%  [R_0402]  74.36 32.3 270 bottom
PRV39  100_0402_1%  [R_0402]  76.96 33.81 0 bottom
PRV40  100_0402_1%  [R_0402]  79.11 37.18 0 bottom
PRV45  1K_0402_1%  [R_0402]  79.12 35.54 270 top
PRV50  10K_0402_1%  [R_0402]  69.28 14.87 90 top
PRV51  10K_0402_1%  [R_0402]  73.47 33.86 90 top
PRV52  2.2K_0402_1%  [R_0402]  74.49 34.84 270 top
PRV53  10K_0402_1%  [R_0402]  75.56 34.84 270 top
PRV54  10K_0402_1%  [R_0402]  79.17 29.49 0 top
PRV59  100K_0402_1%  [R_0402]  71.29 34.76 270 top
PRV61  100K_0402_1%  [R_0402]  69.1 24.09 180 top
PRV66  86.6K_0402_1%  [R_0402]  69.1 30.7 180 top
PRV67  21.5K_0402_1%  [R_0402]  80.09 27.78 180 top
PRV69  16.5K_0402_1%  [R_0402]  69.05 31.77 180 bottom
PRV70  174K_0402_1%  [R_0402]  69.1 24.92 180 top
PRV72  20.5K_0402_1%  [R_0402]  69.09 30.84 180 bottom
PRV73  4.75K_0402_1%  [R_0402]  80.15 32.67 180 bottom
PRV74  49.9K_0402_1%  [R_0402]  69.1 26.57 180 top
PRV75  34K_0402_1%  [R_0402]  80.09 26.95 180 top
PRV76  31.6K_0402_1%  [R_0402]  69.1 27.4 180 top
PRV77  76.8K_0402_1%  [R_0402]  69.1 25.75 180 top
PRV78  37.4K_0402_1%  [R_0402]  69.1 28.22 180 top
PRV79  38.3K_0402_1%  [R_0402]  79.17 26.89 0 bottom
PRV81  6.19K_0402_1%  [R_0402]  69.1 32.35 180 top
PRV82  91K_0402_1%  [R_0402]  80.09 29.56 180 bottom
PRV83  0_0402_5%  [R_0402]  54.61 27.35 270 bottom
PRV84  0_0402_5%  [R_0402]  52.67 28.26 90 top
PRV88  11.3K_0402_1%  [R_0402]  52.65 29.97 90 top
PRV89  4.7_1206_5%  [R_1206]  51.51 27.17 270 bottom
PRV90  10_1206_5%  [R_1206]  55.7 33.5 0 top
PRV91  4.7_0402_5%  [R_0402]  52.65 31.71 180 bottom
PRV92  0_0805_5%  [R_0805]  54.71 36.86 0 top
PRV93  2.2_0603_5%  [R_0603]  53.4 35.27 270 top
PRV94  0_0603_5%  [R_0603]  54.91 31.49 180 top
PRV95  0_0402_5%  [R_0402]  52.65 30.89 180 bottom
PRV96  0_0402_5%  [R_0402]  61.4 32.72 180 bottom
PRV97  0_0402_5%  [R_0402]  55.44 27.35 270 bottom
PRV98  100K_0402_1%  [R_0402]  60.48 33.49 0 bottom
PRV99  100K_0402_1%  [R_0402]  58.56 31.59 180 top
PRV101  18.2K_0402_1%  [R_0402]  52.65 31.63 90 top
PRV102  200K_0402_1%  [R_0402]  56.86 30.62 270 top
PRV103  200K_0402_1%  [R_0402]  62.22 33.17 0 bottom
PRV104  20.5K_0402_1%  [R_0402]  60.27 27.4 180 bottom
PRV105  698_0402_1%  [R_0402]  58.17 27.35 270 bottom
PRV106  0_0603_5%  [R_0603]  30.86 40.78 270 top
PRV107  0_0603_5%  [R_0603]  22.9 40.83 270 top
PRV108  0.005_2512_1%  [RL-3264-9W-R005-FNH_2512_2512]  12.71 37.98 270 bottom
PRV109  0.005_2512_1%  [RL-3264-9W-R005-FNH_2512_2512]  16.17 31.78 180 top
PRV110  4.7_0603_5%  [R_0603]  26.48 49.68 0 bottom
PRV111  4.7_0603_5%  [R_0603]  34.04 49.62 0 bottom
PRV112  2_0402_5%  [R_0402]  25.37 43.25 180 bottom
PRV113  2_0402_5%  [R_0402]  32.05 43.25 0 bottom
PRV117  0_0402_5%  [R_0402]  24.55 44.1 90 bottom
PRV121  0_0402_5%  [R_0402]  22.42 42.85 0 bottom
PRV123  0_0402_5%  [R_0402]  30.05 42.92 0 bottom
PRV126  0_0402_5%  [R_0402]  32.04 44.02 90 bottom
PRV130  0_0603_5%  [R_0603]  38.52 40.9 270 top
PRV131  0_0603_5%  [R_0603]  46.05 41.06 270 top
PRV132  4.7_0603_5%  [R_0603]  41.72 49.62 0 bottom
PRV133  4.7_0603_5%  [R_0603]  49.4 49.62 0 bottom
PRV134  2_0402_5%  [R_0402]  47.19 43.33 0 bottom
PRV135  2_0402_5%  [R_0402]  39.48 43.32 0 bottom
PRV138  0_0402_5%  [R_0402]  38.62 42.06 90 bottom
PRV139  0_0402_5%  [R_0402]  47.12 44.31 90 bottom
PRV149  0_0402_5%  [R_0402]  46.25 41.99 90 bottom
PRV151  0_0402_5%  [R_0402]  39.46 44.38 90 bottom
PRV152  0_0603_5%  [R_0603]  61.46 40.9 0 top
PRV153  0_0603_5%  [R_0603]  53.99 41.07 270 top
PRV154  4.7_0603_5%  [R_0603]  57.21 49.75 0 bottom
PRV155  4.7_0603_5%  [R_0603]  65.02 49.68 0 bottom
PRV156  2_0402_5%  [R_0402]  54.84 42.98 0 bottom
PRV157  2_0402_5%  [R_0402]  62.41 43.32 0 bottom
PRV160  0_0402_5%  [R_0402]  53.95 41.98 90 bottom
PRV170  0_0402_5%  [R_0402]  62.46 44.43 90 bottom
PRV171  0_0402_5%  [R_0402]  61.58 42.13 90 bottom
PRV172  0_0402_5%  [R_0402]  54.89 44.1 90 bottom
PRV174  0_0603_5%  [R_0603]  69.67 41.01 180 top
PRV175  0_0603_5%  [R_0603]  69.38 77.84 270 top
PRV176  4.7_0603_5%  [R_0603]  72.77 49.88 0 bottom
PRV177  4.7_0603_5%  [R_0603]  79.57 88.86 180 top
PRV178  2_0402_5%  [R_0402]  70.12 43.26 0 bottom
PRV179  2_0402_5%  [R_0402]  69.77 78.49 0 bottom
PRV182  0_0402_5%  [R_0402]  69.37 41.86 90 bottom
PRV183  0_0402_5%  [R_0402]  72.87 79.4 180 bottom
PRV187  0_0402_5%  [R_0402]  72.45 78.59 0 bottom
PRV193  0_0402_5%  [R_0402]  70.15 44.34 90 bottom
PRV196  0_0402_5%  [R_0402]  61.42 31.95 180 bottom
PRV197  0_0402_5%  [R_0402]  61.43 31.1 180 bottom
PRV198  0_0402_5%  [R_0402]  61.42 29.43 180 bottom
PRV199  0_0402_5%  [R_0402]  61.42 30.25 180 bottom
PRV200  100K_0402_1%  [R_0402]  69.1 29.05 180 top
PRV201  100K_0402_1%  [R_0402]  69.1 29.87 180 top
PRV202  10K_0402_1%  [R_0402]  77.79 21.8 90 bottom
PRV203  10K_0402_1%  [R_0402]  76.77 21.8 90 bottom
PRV204  10K_0402_1%  [R_0402]  75.76 21.8 90 bottom
PRV205  10K_0402_1%  [R_0402]  74.74 21.8 90 bottom
PRV206  10K_0402_1%  [R_0402]  73.72 21.8 90 bottom
PRV207  10K_0402_1%  [R_0402]  72.71 21.8 90 bottom
PRV208  10K_0402_1%  [R_0402]  71.69 21.8 90 bottom
PRV209  10K_0402_1%  [R_0402]  70.68 21.8 90 bottom
PRV210  1.82K_0402_1%  [R_0402]  79.17 26.13 0 top
PRV211  10K_0402_1%  [R_0402]  81.93 26 180 bottom
PRV212  15K_0402_1%  [R_0402]  79.17 26.06 0 bottom
PRV213  0_0402_5%  [R_0402]  79.17 27.71 0 bottom
PRV214  560_0402_5%  [R_0402]  78.68 24.49 270 top
PRV215  10_0402_5%  [R_0402]  77.79 24.49 270 bottom
PRV216  10_0402_5%  [R_0402]  76.77 24.49 270 bottom
PRV217  10_0402_5%  [R_0402]  75.76 24.49 270 bottom
PRV218  10_0402_5%  [R_0402]  74.74 24.49 270 bottom
PRV219  10_0402_5%  [R_0402]  73.72 24.49 270 bottom
PRV220  10_0402_5%  [R_0402]  72.71 24.49 270 bottom
PRV221  10_0402_5%  [R_0402]  71.69 24.49 270 bottom
PRV222  10_0402_5%  [R_0402]  70.68 24.49 270 bottom
PRV223  1K_0402_1%  [R_0402]  76.01 32.3 270 bottom
PRV224  4.7_0603_5%  [R_0603]  39.95 24.04 180 top
PRV225  0_0402_5%  [R_0402]  53.78 27.5 180 top
PRV226  10K_0402_5%  [R_0402]  64.01 30.91 90 bottom
PRV227  100K_0402_1%  [R_0402]  65.21 30.53 0 bottom
PRW1  2.05K_0402_1%  [R_0402]  12.97 55.72 180 top
PRW2  2.05K_0402_1%  [R_0402]  7.99 55.86 180 top
PRW3  5K_0402_1%  [R_0402]  2.81 53.3 180 top
PRW4  82.5K_0402_1%  [R_0402]  4.36 22.19 90 top
PRW5  2.2_0603_5%  [R_0603]  2.59 43.87 90 top
PRW6  10_0402_5%  [R_0402]  10.91 46.64 0 bottom
PRW7  10_0402_5%  [R_0402]  5.66 48.54 180 top
PRW8  0_0402_5%  [R_0402]  12.97 56.54 180 top
PRW9  0_0402_5%  [R_0402]  10.34 47.97 0 top
PRW10  0_0402_5%  [R_0402]  2.53 22.09 0 top
PRW11  0_0402_5%  [R_0402]  14.06 39.16 90 top
PRW12  0_0402_5%  [R_0402]  3.35 54.96 180 top
PRW13  0_0402_5%  [R_0402]  5.66 49.37 180 top
PRW14  0_0402_5%  [R_0402]  9.89 52.1 0 top
PRW15  0_0402_5%  [R_0402]  6.13 23.17 180 top
PRW16  0_0402_5%  [R_0402]  13.28 47.65 180 top
PRW17  1K_0402_1%  [R_0402]  11.81 53.76 270 top
PRW18  1K_0402_1%  [R_0402]  9.91 53.99 90 top
PRW19  1K_0402_1%  [R_0402]  8.46 48.67 180 top
PRW20  1K_0402_1%  [R_0402]  9.27 48.59 90 top
PRW21  10K_0402_1%  [R_0402]  3.86 26.94 180 top
PRW22  10K_0402_1%  [R_0402]  2.81 49.68 180 top
PRW23  5.1K_0402_1%  [R_0402]  4.72 26.94 0 top
PRW24  10K_0402_1%  [R_0402]  1.89 52.48 0 top
PRW25  10K_0402_1%  [R_0402]  10.81 52.86 180 top
PRW26  10K_0402_1%  [R_0402]  12.05 54.89 0 top
PRW27  100K_0402_1%  [R_0402]  1.89 54.13 0 top
PRW28  15K_0402_1%  [R_0402]  7.7 24.06 270 top
PRW29  21K_0402_1%  [R_0402]  2.81 50.57 180 top
PRW30  73.2K_0402_1%  [R_0402]  1.91 47.96 90 top
PRW31  30K_0402_1%  [R_0402]  10.35 49.76 0 top
PRW32  49.9K_0402_1%  [R_0402]  2.79 48.87 270 top
PRW33  91K_0402_1%  [R_0402]  7.7 25.73 270 top
PRW34  2.2_0603_1%  [R_0603]  3.72 60.68 180 top
PRW35  4.7_0603_5%  [R_0603]  13.16 65.28 90 top
PRW37  1_0402_5%  [R_0402]  2.82 61.71 0 top
PRW39  0_0402_5%  [R_0402]  18.05 57.88 180 bottom
PRW40  0_0402_5%  [R_0402]  15.42 57.88 0 bottom
PRW42  0_0402_5%  [R_0402]  2.83 62.58 0 top
PRW43  10K_0402_1%  [R_0402]  2.83 63.4 0 top
PRW44  2.2_0603_1%  [R_0603]  18.01 38.45 180 top
PRW45  4.7_0603_5%  [R_0603]  19.11 47.14 180 bottom
PRW47  1_0402_5%  [R_0402]  12.38 41.8 270 top
PRW50  0_0402_5%  [R_0402]  18.94 52.29 180 bottom
PRW51  0_0402_5%  [R_0402]  18.94 51.34 180 bottom
PRW52  0_0402_5%  [R_0402]  14.82 39.25 0 top
PRW53  10K_0402_1%  [R_0402]  13.25 41.82 270 top
PRW56  0_0402_5%  [R_0402]  13.46 49.51 270 top
PRW58  2.2_0402_1%  [R_0402]  15.18 56.42 0 bottom
PRW59  2.2_0402_1%  [R_0402]  20.45 51.02 0 bottom
PRW60  10K_0402_5%  [R_0402]  9.89 51.34 0 top
PRZ1  10K_0402_1%  [R_0402]  149.05 128.68 180 bottom
PRZ2  4.32K_0402_1%  [R_0402]  137.87 129.06 180 top
PRZ3  2_0402_5%  [R_0402]  133.1 128.17 0 bottom
PRZ4  10_0402_1%  [R_0402]  146.93 135.66 0 bottom
PRZ5  10_0402_1%  [R_0402]  147.62 124.55 0 top
PRZ6  45.3_0402_1%  [R_0402]  147.62 125.31 0 bottom
PRZ7  45.3_0402_1%  [R_0402]  147.62 126.08 0 bottom
PRZ8  49.9_0402_1%  [R_0402]  144.4 134.84 180 top
PRZ9  49.9_0402_1%  [R_0402]  144.65 122.85 270 top
PRZ10  49.9_0402_1%  [R_0402]  147.62 126.08 0 top
PRZ11  7.5K_0603_1%  [R_0603]  150.98 110.52 270 top
PRZ12  110K_0402_1%  [R_0402]  142.46 135 90 top
PRZ13  110K_0402_1%  [R_0402]  141.12 135 90 top
PRZ14  110K_0402_1%  [R_0402]  138.37 135 90 top
PRZ15  120K_0402_1%  [R_0402]  141.03 120.09 90 bottom
PRZ16  110K_0402_1%  [R_0402]  139.7 135 90 top
PRZ17  0_0402_5%  [R_0402]  148.54 125.31 180 top
PRZ18  0_0402_5%  [R_0402]  146.88 132.95 270 bottom
PRZ19  0_0402_5%  [R_0402]  147.38 122.85 270 bottom
PRZ20  0_0402_5%  [R_0402]  148.13 126.84 0 top
PRZ21  0_0402_5%  [R_0402]  139 122.57 90 top
PRZ22  0_0402_5%  [R_0402]  146.49 120.56 270 top
PRZ23  0_0402_5%  [R_0402]  137.87 131.47 180 top
PRZ24  0_0402_5%  [R_0402]  150.62 131.9 270 top
PRZ25  0_0402_5%  [R_0402]  150.62 133.58 270 top
PRZ26  0_0402_5%  [R_0402]  151.21 129.82 180 bottom
PRZ27  1K_0402_5%  [R_0402]  148.84 130.5 180 top
PRZ28  100_0402_1%  [R_0402]  147.62 123.73 0 top
PRZ29  100_0402_1%  [R_0402]  146.75 134.85 270 top
PRZ30  100_0402_1%  [R_0402]  150.62 131.71 90 bottom
PRZ31  100_0402_1%  [R_0402]  147.45 120.56 270 top
PRZ32  100_0402_1%  [R_0402]  145.54 119.65 90 top
PRZ33  100_0402_1%  [R_0402]  150.62 135.23 270 top
PRZ34  100_0402_1%  [R_0402]  150.29 128.81 0 bottom
PRZ35  100_0402_1%  [R_0402]  148.54 124.55 180 bottom
PRZ36  1K_0402_1%  [R_0402]  144.46 121.94 90 bottom
PRZ37  1K_0402_1%  [R_0402]  139.26 120.92 90 top
PRZ38  1K_0402_1%  [R_0402]  144.97 133.58 270 top
PRZ39  1K_0402_1%  [R_0402]  127.95 134.39 90 top
PRZ40  10K_0402_1%  [R_0402]  150.13 125.97 90 top
PRZ41  100K_0402_1%  [R_0402]  139.32 133.58 270 bottom
PRZ42  100K_0402_1%  [R_0402]  140.14 133.58 270 bottom
PRZ44  100K_0402_1%  [R_0402]  142.56 121.07 270 top
PRZ45  100K_0402_1%  [R_0402]  140.97 133.58 270 bottom
PRZ48  110K_0402_1%  [R_0402]  137.87 129.82 180 top
PRZ49  12K_0402_1%  [R_0402]  147.57 134.85 270 top
PRZ50  12.1K_0402_1%  [R_0402]  142.56 122.85 270 top
PRZ51  1.37K_0402_1%  [R_0402]  146.43 122.85 270 bottom
PRZ52  2.05K_0402_1%  [R_0402]  149.15 133.12 180 bottom
PRZ53  1.5K_0402_1%  [R_0402]  150.62 129.36 90 top
PRZ54  158K_0402_1%  [R_0402]  142.94 135.36 270 bottom
PRZ55  3.65K_0402_1%  [R_0402]  139.7 137.06 90 top
PRZ56  3.65K_0402_1%  [R_0402]  141.1 137.06 90 top
PRZ57  3.65K_0402_1%  [R_0402]  135.74 137.04 90 top
PRZ58  3.65K_0402_1%  [R_0402]  138.37 137.06 90 top
PRZ59  1.62K_0402_1%  [R_0402]  141.03 122.85 270 bottom
PRZ60  3.65K_0402_1%  [R_0402]  142.3 137.18 90 top
PRZ61  3.65K_0402_1%  [R_0402]  137.07 137.04 90 top
PRZ62  24.9K_0402_1%  [R_0402]  137.87 126.01 180 bottom
PRZ63  37.4K_0402_1%  [R_0402]  137.87 128.3 180 top
PRZ64  249K_0402_1%  [R_0402]  141.55 120.11 180 top
PRZ65  25.5K_0402_1%  [R_0402]  137.87 126.01 180 top
PRZ66  24K_0402_1%  [R_0402]  144.78 130.19 90 bottom
PRZ67  23.2K_0402_1%  [R_0402]  146.43 128.48 90 bottom
PRZ68  28.7K_0402_1%  [R_0402]  145.54 122.85 270 top
PRZ69  30.1K_0402_1%  [R_0402]  143.32 133.58 270 top
PRZ70  34.8K_0402_1%  [R_0402]  146.38 127.22 180 bottom
PRZ71  3.65K_0402_1%  [R_0402]  144.09 120.68 180 bottom
PRZ72  3.65K_0402_1%  [R_0402]  144.15 132.67 90 top
PRZ73  499_0402_1%  [R_0402]  147.62 123.79 0 bottom
PRZ74  61.9K_0402_1%  [R_0402]  139.89 124.61 0 bottom
PRZ75  61.9K_0402_1%  [R_0402]  136.08 131.4 90 top
PRZ76  75K_0402_1%  [R_0402]  142.05 134.44 90 bottom
PRZ77  97.6K_0402_1%  [R_0402]  137.87 126.77 180 top
PRZ78  97.6K_0402_1%  [R_0402]  137.87 127.54 180 top
PRZ79  4.7_0603_1%  [R_0603]  83.95 133.25 180 top
PRZ80  4.7_0603_1%  [R_0603]  91.5 133.44 180 top
PRZ81  2.2_1206_5%  [R_1206]  90.27 124.25 180 bottom
PRZ82  2.2_1206_5%  [R_1206]  94.96 124.28 180 bottom
PRZ83  2_0402_5%  [R_0402]  95.39 133.06 180 top
PRZ84  2_0402_5%  [R_0402]  87.96 133 180 top
PRZ85  2.2_0402_1%  [R_0402]  100.51 134.46 0 bottom
PRZ86  10_0402_1%  [R_0402]  139.13 135.36 270 bottom
PRZ87  10_0402_1%  [R_0402]  138.18 135.36 270 bottom
PRZ90  0_0402_5%  [R_0402]  101.49 136.11 180 top
PRZ91  0_0402_5%  [R_0402]  101.42 135.35 180 bottom
PRZ96  0_0402_5%  [R_0402]  100.51 136.17 0 bottom
PRZ97  10K_0402_5%  [R_0402]  100.71 136.92 90 top
PRZ98  100K_0402_5%  [R_0402]  93.98 136.62 90 top
PRZ99  100K_0402_5%  [R_0402]  93.28 135.02 90 bottom
PRZ100  1.18K_0402_1%  [R_0402]  93.98 135.55 270 top
PRZ101  1.18K_0402_1%  [R_0402]  91.36 134.97 0 bottom
PRZ102  4.7_0603_1%  [R_0603]  108.39 133.44 180 top
PRZ103  4.7_0603_1%  [R_0603]  100.08 133.25 180 top
PRZ104  2.2_1206_5%  [R_1206]  110.74 123.92 180 bottom
PRZ105  2.2_1206_5%  [R_1206]  102.96 124.26 180 bottom
PRZ106  2_0402_5%  [R_0402]  112.41 133.12 180 top
PRZ107  2_0402_5%  [R_0402]  104.09 133.06 180 top
PRZ108  2.2_0402_1%  [R_0402]  130.81 129.25 270 bottom
PRZ109  10_0402_1%  [R_0402]  140.08 135.36 270 bottom
PRZ110  10_0402_1%  [R_0402]  141.1 135.36 270 bottom
PRZ113  0_0402_5%  [R_0402]  131.95 128.41 90 bottom
PRZ115  0_0402_5%  [R_0402]  133.02 129.31 0 top
PRZ116  0_0402_5%  [R_0402]  131.83 128.41 90 top
PRZ120  10K_0402_5%  [R_0402]  133.05 129.31 0 bottom
PRZ121  100K_0402_5%  [R_0402]  129.78 135.6 0 top
PRZ122  100K_0402_5%  [R_0402]  134.29 135.59 180 bottom
PRZ123  1.18K_0402_1%  [R_0402]  129.67 133.49 90 top
PRZ124  1.18K_0402_1%  [R_0402]  131.56 135.6 0 top
PRZ125  4.7_0603_1%  [R_0603]  130.81 119.73 0 top
PRZ126  4.7_0603_1%  [R_0603]  129.35 132.36 270 top
PRZ127  2.2_1206_5%  [R_1206]  121.28 121.76 90 bottom
PRZ128  2.2_1206_5%  [R_1206]  122.87 128.04 180 bottom
PRZ129  2_0402_5%  [R_0402]  129.35 128.84 90 bottom
PRZ130  2_0402_5%  [R_0402]  132.21 117.38 180 top
PRZ131  2.2_0402_1%  [R_0402]  133.99 119.93 270 top
PRZ132  10_0402_1%  [R_0402]  136.27 135.36 270 bottom
PRZ133  10_0402_1%  [R_0402]  137.22 135.33 270 bottom
PRZ135  0_0402_5%  [R_0402]  134.81 119.01 90 top
PRZ138  0_0402_5%  [R_0402]  135.64 119.01 90 top
PRZ139  0_0402_5%  [R_0402]  136.46 119.01 90 top
PRZ143  10K_0402_5%  [R_0402]  138.43 120.92 90 top
PRZ144  100K_0402_5%  [R_0402]  134.86 127.54 0 top
PRZ145  100K_0402_5%  [R_0402]  132.28 124.61 180 top
PRZ146  1.18K_0402_1%  [R_0402]  134.86 126.71 0 top
PRZ147  1.18K_0402_1%  [R_0402]  131.37 125.5 0 top
PRZ148  1.2K_0402_1%  [R_0402]  148.84 131.26 180 top
PRZ153  110K_0402_1%  [R_0402]  135.7 135 90 top
PRZ154  110K_0402_1%  [R_0402]  137.1 135 90 top
PRZ155  1K_0402_1%  [R_0402]  149.39 42.08 180 top
PU301  -  [SY8388BRHC_QFN16_2P5X2P5]  65.52 24.67 180 top
PU501  -  [SY8270CTMC_QFN13_4X3]  57.1 23.96 180 top
PU1101  -  [SY8386RHC_QFN16_2P5X2P5]  72.67 105.48 180 bottom
PU1802  -  [SY8386RHC_QFN16_2P5X2P5]  48.68 7.68 270 top
PU2501  -  [RT9059GSP_SO8]  84.74 61.46 0 top
PU2502  -  [RT9297GQW_WDFN10_3X3]  137.89 35.76 180 bottom
PUA1  NCP302035MNTXG_PQFN33_5X5  [NCP302045MNTXG_PQFN33_5X5]  143.38 99.59 0 top
PUB1  -  [ISL88739AHRZ-T_QFN32_4X4]  47.36 19.07 180 bottom
PUG01  -  [NCP302045MNTXG_PQFN33_5X5]  143.26 84.35 0 top
PUH1  -  [TPS51212DSCR_SON10_3X3]  138.91 29.14 90 top
PUH2  -  [SY8386RHC_QFN16_2P5X2P5]  134.48 50.91 90 top
PUM1  -  [RT8207PGQW_WQFN20_3X3]  145.44 48.08 270 top
PUV1  -  [UP9512RQGJ_VQFN40_5X5]  71.62 30.7 0 top
PUV3  -  [ISL95338HRTZ-T_TQFN32_4X4]  54.35 29.79 0 bottom
PUV4  -  [AOZ5332QI_QFN31_5X5]  24.09 42.42 90 top
PUV5  -  [AOZ5332QI_QFN31_5X5]  31.65 42.42 90 top
PUV6  -  [AOZ5332QI_QFN31_5X5]  39.21 42.42 90 top
PUV7  -  [AOZ5332QI_QFN31_5X5]  46.83 42.42 90 top
PUV8  -  [AOZ5332QI_QFN31_5X5]  62.26 42.42 90 top
PUV9  -  [AOZ5332QI_QFN31_5X5]  54.51 42.42 90 top
PUV10  -  [AOZ5332QI_QFN31_5X5]  69.81 42.42 90 top
PUV11  -  [AOZ5332QI_QFN31_5X5]  72.3 78.61 0 top
PUW1  -  [UP9529PQKF_WQFN20_3X3]  4.72 53.47 0 top
PUW2  -  [AOZ5332QI_QFN31_5X5]  5.03 61.71 0 top
PUW3  -  [AOZ5332QI_QFN31_5X5]  16.06 40.44 90 top
PUZ1  -  [NCP81215DMNTXG_QFN52_6X6]  145.72 130.93 270 top
PUZ2  -  [NCP302045MNTXG_PQFN33_5X5]  95.72 131.8 180 top
PUZ3  -  [NCP302045MNTXG_PQFN33_5X5]  88.24 131.69 180 top
PUZ4  -  [NCP81162MNR2G_QFN16_3X3]  99.02 135.55 180 top
PUZ5  -  [NCP302045MNTXG_PQFN33_5X5]  112.67 131.84 180 top
PUZ6  -  [NCP302045MNTXG_PQFN33_5X5]  104.35 131.84 180 top
PUZ7  -  [NCP81162MNR2G_QFN16_3X3]  131.81 130.83 90 top
PUZ8  -  [NCP302045MNTXG_PQFN33_5X5]  127.75 128.39 90 top
PUZ9  -  [NCP302045MNTXG_PQFN33_5X5]  129.34 118.29 90 top
PUZ10  -  [NCP81162MNR2G_QFN16_3X3]  134.76 121.35 90 top
Q7  -  [DMN65D8LDW-7_SOT363-6]  82.62 34.14 270 top
Q8  -  [DMN65D8LDW-7_SOT363-6]  82.62 31.28 270 top
Q9  -  [DMN65D8LDW-7_SOT363-6]  82.62 37 270 top
Q2407  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  70.29 69.94 270 top
Q2408  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  119.13 67.38 0 bottom
Q2411  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  80.9 106.64 0 bottom
QE1  -  [DMN66D0LDW-7_SOT363-6]  129.92 14.81 90 bottom
QE2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  76.45 6.91 0 top
QE3  -  [DMN66D0LDW-7_SOT363-6]  128.85 14.49 270 bottom
QE4  -  [DMN66D0LDW-7_SOT363-6]  71.24 10.93 90 top
QE5  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  82.98 15.58 0 bottom
QE8  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  84.67 6.12 90 top
QE13  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  101.56 12 270 bottom
QE21  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  101.5 15.49 270 bottom
QE22  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  101.56 18.98 270 bottom
QE58  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  88.91 22.87 270 bottom
QE66  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  84.57 21.36 0 bottom
QG2  -  [MESS138W-G_SOT323-3]  61.84 124.12 180 top
QG3  -  [MESS138W-G_SOT323-3]  8.97 118.75 270 bottom
QG4  -  [MESS138W-G_SOT323-3]  10.22 83.93 270 bottom
QG6  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  70.94 84.58 180 bottom
QG7  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  62.82 92.16 180 top
QG8  -  [MESS138W-G_SOT323-3]  43.47 68.38 180 bottom
QG500  -  [DMN66D0LDW-7_SOT363-6]  119.95 140.22 90 top
QG502  DMN53D0LDW-7_SOT363-6  [2N7002DW-7-F_SOT363-6]  76.08 63.45 90 bottom
QG503  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  71.2 96.74 180 bottom
QG505  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  4.63 16.76 90 top
QG508  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  69.91 85.86 90 top
QG510  -  [MESS138W-G_SOT323-3]  65.66 98.2 270 top
QG511  -  [MESS138W-G_SOT323-3]  77.4 66.51 90 bottom
QG516  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  84.49 27.9 90 top
QG520  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  9.29 5.36 180 top
QG521  DMN53D0LDW-7_SOT363-6  [2N7002DW-7-F_SOT363-6]  80.15 58.64 180 bottom
QG522  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  71.39 63.9 270 top
QG523  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  71.41 66.45 270 top
QG524  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  76.43 65.24 90 top
QG525  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  9.39 22.75 180 top
QH5  DMN66D0LDW-7  [DMN66D0LDW-7_SOT363-6]  107.71 17.36 180 top
QH98  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  84.8 23.28 270 bottom
QH99  -  [DMN65D8LDW-7_SOT363-6]  84.37 39.18 0 bottom
QH100  -  [DMN65D8LDW-7_SOT363-6]  83.44 42.78 0 bottom
QM1  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  49.86 145.81 180 top
QM2  -  [DMN66D0LDW-7_SOT363-6]  47.13 145.25 180 top
QM3  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  43.13 145.94 180 top
QT2  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  95.44 16.25 90 bottom
QV1  -  [SI3457CDV-T1-GE3_TSOP6]  39 141.7 90 top
QV2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  34.12 146 90 top
QV3  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  110.15 142.01 270 bottom
QV96  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  138.55 139.97 90 top
QV97  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  127.33 139.34 180 top
QX1  LBSS138LT1G_SOT-23-3  [LBSS138LT1G_SOT23-3]  132.65 139.39 0 top
QX2  S TR MMST3904-7-F NPN SOT323-3  [MMST3904-7-F_SOT323-3]  124.52 141.12 90 top
QX3  S TR MMST3904-7-F NPN SOT323-3  [MMST3904-7-F_SOT323-3]  129.1 140.05 0 top
QX4  -  [MMBT3904WH_SOT323-3]  63.69 73.46 180 top
QX5  -  [MMBT3904WH_SOT323-3]  60.26 73.46 180 top
R174  10K_0402_5%  [R_0402]  68.39 15.41 270 bottom
R181  10K_0402_5%  [R_0402]  59.18 62.12 90 top
R182  0_0402_5%  [R_0402]  67.56 15.41 270 bottom
R184  0_0402_5%  [R0402_0OHM]  60.45 71.61 270 top
R185  0_0402_5%  [R0402_0OHM]  58.61 73.38 270 top
R307  100K_0402_1%  [R_0402]  85.47 31.16 270 top
R325  100K_0402_1%  [R_0402]  85.47 33.48 90 top
R363  10K_0201_5%  [R_0201]  94.3 12 270 bottom
R364  10K_0201_5%  [R_0201]  122.87 11.23 90 bottom
R367  10K_0402_5%  [R_0402]  98.06 18.57 180 top
R368  10K_0201_5%  [R_0201]  121.56 38.32 0 top
R369  100K_0402_1%  [R_0402]  83.72 34.88 90 bottom
R370  100K_0402_1%  [R_0402]  86.6 41.82 270 bottom
R371  1M_0402_5%~D  [R_0402]  85.83 40.91 90 bottom
R372  1M_0402_5%~D  [R_0402]  84.51 35.79 270 bottom
R373  0_0402_5%  [R_0402]  86.66 40.11 180 bottom
R374  0_0402_5%  [R_0402]  83.65 43.73 180 bottom
RC2  24.9_0402_1%  [R_0402]  98.22 81.12 0 top
RC9  1.5K_0402_1%  [R_0402]  140.45 140.68 0 top
RC30  24.9_0402_1%  [R_0402]  92.82 112.59 270 top
RC35  51_0402_1%  [R_0402]  142.1 144.72 90 top
RC62  49.9K_0402_1%  [R_0402]  124.44 45.21 0 bottom
RC63  49.9K_0402_1%  [R_0402]  124.44 44.32 0 bottom
RC66  20_0402_5%  [R_0402]  93.93 106.9 180 top
RC348  51_0402_1%  [R_0402]  141.82 143.93 180 top
RC353  1K_0402_5%  [R_0402]  140.46 141.47 0 top
RC354  1K_0402_1%  [R_0402]  141.36 139.79 180 top
RC355  1K_0402_1%  [R_0402]  141.38 142.27 180 top
RC693  51_0402_1%  [R_0402]  140.22 106.33 180 top
RD31  0_0402_5%  [R_0402]  141.17 56.86 180 bottom
RD35  470_0402_1%  [R_0402]  138.61 56.86 0 bottom
RD157  240_0402_1%  [R_0402]  131.5 67.07 270 bottom
RD158  240_0402_1%  [R_0402]  121.02 67.04 90 bottom
RD159  24.9_0402_1%  [R_0402]  140.97 90.78 270 top
RD160  1.8K_0402_1%  [R_0402]  141.97 70.45 0 bottom
RD161  2.7_0402_1%  [R_0402]  141.91 72.23 0 bottom
RD162  1.8K_0402_1%  [R_0402]  142.88 71.34 180 bottom
RD163  240_0402_1%  [R_0402]  131.51 67.29 270 top
RD164  240_0402_1%  [R_0402]  141.97 67.15 0 top
RD166  36_0201_1%  [R_0201]  141.95 60.16 0 top
RD167  36_0201_1%  [R_0201]  142.84 60.04 0 bottom
RD168  36_0201_1%  [R_0201]  142.84 59.46 0 bottom
RD169  36_0201_1%  [R_0201]  142.84 61.18 0 bottom
RD170  36_0201_1%  [R_0201]  142.84 61.75 0 bottom
RD171  36_0201_1%  [R_0201]  141.95 60.73 0 top
RD172  36_0201_1%  [R_0201]  142.84 60.61 0 bottom
RD173  36_0201_1%  [R_0201]  141.95 57.88 0 top
RD174  36_0201_1%  [R_0201]  141.95 59.02 0 top
RD175  36_0201_1%  [R_0201]  142.84 58.89 0 bottom
RD176  36_0201_1%  [R_0201]  141.95 62.45 0 top
RD177  36_0201_1%  [R_0201]  142.84 58.32 0 bottom
RD178  36_0201_1%  [R_0201]  142.84 62.32 0 bottom
RD179  36_0201_1%  [R_0201]  141.95 57.3 0 top
RD180  36_0201_1%  [R_0201]  141.95 63.59 0 top
RD181  36_0201_1%  [R_0201]  141.95 63.02 0 top
RD182  36_0201_1%  [R_0201]  141.95 64.16 0 top
RD183  36_0201_1%  [R_0201]  141.95 61.31 0 top
RD184  36_0201_1%  [R_0201]  141.95 61.88 0 top
RD185  36_0201_1%  [R_0201]  141.95 65.88 0 top
RD186  36_0201_1%  [R_0201]  141.95 65.31 0 top
RD187  36_0201_1%  [R_0201]  142.84 64.61 0 bottom
RD188  36_0201_1%  [R_0201]  142.84 63.46 0 bottom
RD189  36_0201_1%  [R_0201]  141.95 64.73 0 top
RD190  36_0201_1%  [R_0201]  142.84 64.04 0 bottom
RD191  36_0201_1%  [R_0201]  142.84 62.89 0 bottom
RD192  36_0201_1%  [R_0201]  141.95 58.45 0 top
RD193  49.9_0201_1%  [R_0201]  142.53 59.59 180 top
RD194  240_0402_1%  [R_0402]  95.05 68 90 bottom
RD195  240_0402_1%  [R_0402]  105.59 66.79 90 bottom
RD196  240_0402_1%  [R_0402]  116.07 67.11 90 top
RD197  240_0402_1%  [R_0402]  105.59 66.79 90 top
RD198  36_0201_1%  [R_0201]  94.41 59.84 180 bottom
RD199  36_0201_1%  [R_0201]  94.41 63.8 180 top
RD200  36_0201_1%  [R_0201]  94.4 63.22 180 top
RD201  36_0201_1%  [R_0201]  94.41 63.78 180 bottom
RD202  49.9_0201_1%  [R_0201]  116.78 60 90 top
RD203  36_0201_1%  [R_0201]  94.41 62.66 180 bottom
RD204  36_0201_1%  [R_0201]  94.42 60.96 180 bottom
RD205  36_0201_1%  [R_0201]  94.41 61.51 180 top
RD206  36_0201_1%  [R_0201]  94.41 60.4 180 bottom
RD207  36_0201_1%  [R_0201]  94.4 62.66 180 top
RD208  36_0201_1%  [R_0201]  94.41 58.72 180 bottom
RD209  36_0201_1%  [R_0201]  94.41 61.54 180 bottom
RD210  36_0201_1%  [R_0201]  94.41 62.07 180 top
RD211  36_0201_1%  [R_0201]  94.4 60.35 180 top
RD212  36_0201_1%  [R_0201]  93.26 61.43 90 bottom
RD213  36_0201_1%  [R_0201]  93.22 60.9 270 top
RD214  36_0201_1%  [R_0201]  94.41 59.09 180 top
RD215  36_0201_1%  [R_0201]  94.41 58.53 180 top
RD216  36_0201_1%  [R_0201]  93.26 58.73 90 bottom
RD217  36_0201_1%  [R_0201]  94.4 59.72 180 top
RD218  36_0201_1%  [R_0201]  94.41 60.96 180 top
RD219  36_0201_1%  [R_0201]  93.22 61.58 90 top
RD220  36_0201_1%  [R_0201]  94.42 64.37 180 top
RD221  36_0201_1%  [R_0201]  94.4 58.07 180 bottom
RD222  36_0201_1%  [R_0201]  93.22 62.73 90 bottom
RD223  36_0201_1%  [R_0201]  94.41 62.1 180 bottom
RD224  36_0201_1%  [R_0201]  94.41 59.28 180 bottom
RD225  36_0201_1%  [R_0201]  94.41 63.22 180 bottom
RD226  1.8K_0402_1%  [R_0402]  117.85 62.81 270 bottom
RD227  1.8K_0402_1%  [R_0402]  116.96 61.9 90 bottom
RD228  2.7_0402_1%  [R_0402]  139.18 89.94 0 top
RD229  24.9_0402_1%  [R_0402]  140.09 88.17 180 top
RD230  240_0402_1%  [R_0402]  131.51 68.81 270 bottom
RD231  240_0402_1%  [R_0402]  121.03 69.64 270 bottom
RD232  240_0402_1%  [R_0402]  142.89 67.97 180 top
RD233  240_0402_1%  [R_0402]  131.51 68.94 270 top
RD234  240_0402_1%  [R_0402]  105.6 69.45 270 bottom
RD235  240_0402_1%  [R_0402]  95.06 70.59 270 bottom
RD236  240_0402_1%  [R_0402]  116.08 69.7 270 top
RD237  240_0402_1%  [R_0402]  105.6 69.38 270 top
RD238  0_0201_5%  [R_0201]  142.53 66.45 180 top
RD239  0_0201_5%  [R_0201]  141.99 62.36 270 bottom
RD240  0_0201_5%  [R_0201]  121.03 62.6 90 bottom
RD241  0_0201_5%  [R_0201]  121.03 61.92 270 bottom
RD242  0_0201_5%  [R_0201]  131.51 65.01 90 top
RD243  0_0201_5%  [R_0201]  131.51 64.39 270 top
RD244  0_0201_5%  [R_0201]  120.97 66.28 90 top
RD245  0_0201_5%  [R_0201]  120.97 65.41 270 top
RD246  0_0201_5%  [R_0201]  105.6 64.07 270 bottom
RD247  0_0201_5%  [R_0201]  105.6 64.76 90 bottom
RD248  0_0201_5%  [R_0201]  95.19 63.11 90 bottom
RD249  0_0201_5%  [R_0201]  95.19 62.49 270 bottom
RD250  0_0201_5%  [R_0201]  116.04 61.94 0 top
RD251  0_0201_5%  [R_0201]  116.04 62.51 0 top
RD252  0_0201_5%  [R_0201]  95.19 65.22 270 top
RD253  0_0201_5%  [R_0201]  95.19 65.84 90 top
RD254  0_0201_5%  [R_0201]  36.58 146.17 90 top
RD255  36_0201_1%  [R_0201]  94.4 64.99 180 top
RE1  1K_0402_1%  [R_0402]  121.74 27.63 270 bottom
RE2  1K_0402_1%  [R_0402]  120.98 27.63 270 bottom
RE3  1M_0402_5%~D  [R_0402]  128.97 21.76 270 bottom
RE4  10K_0402_5%  [R_0402]  125.7 16.83 0 top
RE5  100K_0402_5%  [R_0402]  123.32 26.75 90 bottom
RE6  100K_0402_5%  [R_0402]  126.63 18.62 180 top
RE7  100K_0402_5%  [R_0402]  126.63 17.73 180 top
RE8  10K_0402_5%  [R_0402]  115.91 16.51 180 bottom
RE9  15_0402_5%  [R_0402]  122.7 13.51 90 bottom
RE10  15_0402_5%  [R_0402]  123.46 13.51 90 bottom
RE11  15_0402_5%  [R_0402]  124.22 13.51 90 bottom
RE12  10K_0402_5%~D  [R_0402]  136.83 16.86 0 bottom
RE13  10K_0402_5%~D  [R_0402]  136.65 27.97 270 bottom
RE14  10K_0402_5%~D  [R_0402]  136.09 16.86 180 bottom
RE15  100K_0402_5%  [R_0402]  129.12 17.27 180 bottom
RE16  100K_0402_5%  [R_0402]  129.12 18.03 180 bottom
RE17  100K_0402_5%  [R_0402]  129.04 15.59 180 bottom
RE18  0_0201_5%  [R_0201]  128.27 22.29 270 bottom
RE19  0_0201_5%  [R_0201]  128.27 20.5 90 bottom
RE20  10K_0402_5%  [R_0402]  138.19 12.54 180 bottom
RE21  100K_0402_5%  [R_0402]  126 13.51 90 bottom
RE23  100K_0402_5%  [R_0402]  121.93 13.51 90 bottom
RE28  100K_0402_5%  [R_0402]  80.89 5.91 90 top
RE33  10K_0201_5%  [R_0201]  84.11 17.21 0 bottom
RE64  100K_0402_1%  [R_0402]  75.2 16.86 180 top
RE66  20K_0402_1%  [R_0402]  72.58 16.14 90 top
RE70  10K_0402_5%  [R_0402]  81.41 8.59 90 top
RE71  0_0402_5%  [R_0402]  82.12 2.89 180 bottom
RE75  10K_0402_5%  [R_0402]  72.38 10.57 0 top
RE78  0_0603_5%  [R_0603]  86.51 7.01 0 top
RE83  10K_0402_5%  [R_0402]  84.86 17.97 180 bottom
RE84  10K_0402_5%  [R_0402]  79.12 8.59 90 top
RE85  53.6K_0402_5%  [R_0402]  78.36 8.59 90 top
RE90  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  72.84 13.5 180 top
RE100  4.7K_0402_5%  [R_0402]  74.09 12.35 0 top
RE101  4.7K_0402_5%  [R_0402]  74.09 11.52 0 top
RE154  10K_0402_5%  [R_0402]  101.96 13.12 180 bottom
RE155  1K_0402_1%  [R_0402]  100.24 16.62 180 bottom
RE156  10K_0402_5%  [R_0402]  102.02 16.62 180 bottom
RE157  1K_0402_1%  [R_0402]  100.31 20.11 180 bottom
RE158  10K_0402_5%  [R_0402]  102.09 20.11 180 bottom
RE160  1K_0402_1%  [R_0402]  100.18 13.12 180 bottom
RE161  10K_0402_5%  [R_0402]  80.95 25.11 0 top
RE162  4.7K_0402_1%  [R_0402]  110.68 15.49 0 bottom
RE163  4.7K_0402_1%  [R_0402]  109.42 18.27 90 bottom
RE164  4.7K_0402_1%  [R_0402]  108.54 18.27 90 bottom
RE165  4.7K_0402_1%  [R_0402]  111.6 16.38 180 bottom
RE166  4.7K_0402_1%  [R_0402]  102.87 17.25 270 bottom
RE167  10K_0402_5%~D  [R_0402]  107.65 18.27 90 bottom
RE200  0_0201_5%  [R_0201]  89.31 11.18 270 top
RE201  10K_0402_5%  [R_0402]  78.36 19.7 270 top
RE202  0_0201_5%  [R_0201]  90.07 11.18 270 top
RE530  47K_0402_5%  [R_0402]  89.55 19.86 90 bottom
RE642  4.7K_0402_5%  [R_0402]  92.93 17.27 180 bottom
RE643  4.7K_0402_5%  [R_0402]  92.93 15.49 180 bottom
RE645  10K_0402_5%  [R_0402]  78.92 20.72 180 top
RE647  0_0402_5%  [R_0402-NPM]  140 140.93 0 bottom
RE648  0_0402_5%  [R_0402-NPM]  140 140.05 0 bottom
RE650  10K_0402_5%  [R_0402]  84.86 16.51 180 bottom
RE651  0_0402_5%  [R_0402]  121.17 14.43 270 bottom
RE652  10K_0402_5%  [R_0402]  80.59 20.72 180 top
RE653  0_0402_5%  [R_0402]  82.12 2.12 180 bottom
RE654  0_0402_5%  [R_0402]  82.12 4.54 180 bottom
RE655  0_0402_5%  [R_0402]  82.12 3.71 180 bottom
RE656  10K_0402_5%  [R_0402]  79.24 10.19 0 bottom
RE657  10K_0402_5%  [R_0402]  122.51 27.63 270 bottom
RE661  10K_0201_5%  [R_0201]  94.31 17.35 180 bottom
RE662  10K_0402_5%  [R_0402]  87.77 19.86 90 bottom
RE678  0_0201_5%  [R_0201]  79.88 8.75 90 top
RE679  0_0201_5%  [R_0201]  83.29 8.89 90 top
RE680  0_0201_5%  [R_0201]  74.26 13.05 0 top
RE681  0_0201_5%  [R_0201]  84.59 14.32 0 top
RE684  10K_0402_5%  [R_0402]  74.28 15.33 0 top
RE685  10K_0402_5%  [R_0402]  75.2 16.09 180 top
RE688  10K_0402_5%  [R_0402]  79.88 19.7 270 top
RE689  10K_0402_5%  [R_0402]  79.12 19.7 270 top
RE693  10K_0402_5%  [R_0402]  86.88 19.86 90 bottom
RE694  0_0201_5%  [R_0201]  84.52 15.5 270 top
RE709  10K_0201_1%  [R_0201]  140.72 137.44 180 bottom
RE712  0_0201_5%  [R_0201]  82.68 8.88 90 top
RE713  43_0402_1%  [R_0402]  80.64 8.59 90 top
RE715  0_0603_5%  [R_0603]  85.13 10.01 270 top
RE716  0_0201_5%  [R_0201]  139.89 83.44 270 top
RE717  100K_0402_5%  [R_0402]  9.27 18.94 90 bottom
RE718  4.7_0603_1%  [R_0603]  81.79 18.82 180 bottom
RE719  4.7_0603_1%  [R_0603]  81.79 20.03 180 bottom
RE720  4.7_0603_1%  [R_0603]  81.79 16.41 180 bottom
RE721  4.7_0603_1%  [R_0603]  81.79 15.2 180 bottom
RE722  4.7_0603_1%  [R_0603]  81.79 17.62 180 bottom
RE723  0_0603_5%  [R_0603]  86.51 5.81 0 top
RE724  0_0201_5%  [R_0201]  85.53 22.21 0 bottom
RE1615  1K_0402_1%  [R_0402]  88.47 11.95 270 top
RE1616  1K_0402_1%  [R_0402]  102.84 13.16 90 bottom
RF1  10K_0402_5%  [R_0402]  85.72 17.93 0 top
RF2  10K_0402_5%  [R_0402]  85.76 16.22 0 top
RF3  10K_0402_5%  [R_0402]  84.89 23.27 0 top
RF4  10K_0402_5%  [R_0402]  85.76 17.05 0 top
RF5  10K_0402_5%  [R_0402]  85.76 15.42 0 top
RF6  10K_0402_5%  [R_0402]  86.66 23.27 0 top
RG1  0_0201_5%  [R_0201]  64.05 95.59 180 top
RG2  10K_0201_5%  [R_0201]  63.61 96.7 0 top
RG3  10K_0201_5%  [R_0201]  100.33 20.45 270 top
RG4  0_0201_5%  [R_0201]  61.98 100.88 180 top
RG7  2_0402_1%  [R_0402]  29.35 84.78 180 bottom
RG8  10K_0201_5%  [R_0201]  56.83 79.82 270 top
RG9  10K_0201_5%  [R_0201]  64.29 85.05 0 top
RG13  10K_0201_5%  [R_0201]  101.6 19.87 90 top
RG15  10K_0201_5%  [R_0201]  62.77 76.28 90 top
RG16  10K_0201_5%  [R_0201]  58.55 79.82 270 top
RG17  1.8K_0402_5%  [R_0402]  67.2 86.29 180 bottom
RG18  1.8K_0402_5%  [R_0402]  67.2 85.46 180 bottom
RG19  2.2K_0402_1%  [R_0402]  67.71 80.26 0 bottom
RG20  2.2K_0402_1%  [R_0402]  67.69 79.4 0 bottom
RG21  10K_0201_5%  [R_0201]  63.41 86.32 180 top
RG22  10K_0201_5%  [R_0201]  64.81 87.98 180 top
RG23  2.49K_0402_1%  [R_0402]  62.27 112.58 180 top
RG24  10K_0201_5%  [R_0201]  54.66 80.75 315 top
RG25  1M_0201_1%  [R_0201]  62.2 92.98 0 top
RG26  10K_0201_5%  [R_0201]  61.4 97.34 0 top
RG27  10K_0201_5%  [R_0201]  58.27 76.84 270 top
RG28  1.8K_0402_5%  [R_0402]  64 91.02 0 top
RG29  1.8K_0402_5%  [R_0402]  64 91.85 0 top
RG35  2_0402_1%  [R_0402]  22.61 122.19 90 top
RG59  49.9_0402_1%  [R_0402]  24.26 122.19 90 top
RG62  0_0402_5%  [R_0402]  1.7 39.84 0 top
RG64  100_0402_1%  [R_0402]  2.64 34.83 180 top
RG66  0_0402_5%  [R_0402]  1.73 35.65 0 top
RG67  40.2_0402_1%  [R_0402]  26.86 122.19 90 top
RG68  40.2_0402_1%  [R_0402]  23.43 122.19 90 top
RG69  40.2_0402_1%  [R_0402]  26.04 122.19 90 top
RG74  10K_0402_5%  [R_0402]  77.04 91.28 180 top
RG75  33_0402_5%  [R_0402]  77.04 90.45 180 top
RG76  0_0402_5%  [R_0402]  77.04 92.1 180 top
RG77  33_0402_5%  [R_0402]  67.83 95.72 180 top
RG78  100K_0402_1%  [R_0402]  67.4 73.41 270 top
RG79  100K_0402_1%  [R_0402]  67.71 84.32 0 bottom
RG80  100K_0402_1%  [R_0402]  68.42 73.41 270 top
RG81  100K_0402_1%  [R_0402]  69.44 73.41 270 top
RG82  100K_0402_1%  [R_0402]  67.71 83.31 0 bottom
RG83  100K_0402_1%  [R_0402]  67.71 81.28 0 bottom
RG84  100K_0402_1%  [R_0402]  66.39 73.41 270 top
RG85  100K_0402_1%  [R_0402]  67.71 82.29 0 bottom
RG86  100K_0402_1%  [R_0402]  58.98 76.98 270 top
RG87  100K_0402_1%  [R_0402]  66.39 75.13 270 top
RG88  10K_0402_1%  [R_0402]  66 82.29 0 bottom
RG89  100K_0402_1%  [R_0402]  65.37 75.13 270 top
RG90  100K_0402_1%  [R_0402]  67.4 75.13 270 top
RG91  100K_0402_1%  [R_0402]  66 84.32 0 bottom
RG92  100K_0402_1%  [R_0402]  68.42 75.13 270 top
RG93  100K_0402_1%  [R_0402]  69.44 75.13 270 top
RG94  100K_0402_1%  [R_0402]  66 83.31 0 bottom
RG95  100K_0402_1%  [R_0402]  66 81.28 0 bottom
RG98  100K_0402_5%  [R_0402]  66.91 80.26 180 bottom
RG99  10M_0402_5%  [R_0402]  58.77 88.4 270 bottom
RG100  33_0402_5%  [R_0402]  59.88 79.67 270 top
RG101  121_0402_1%  [R_0402]  42.13 132.5 270 top
