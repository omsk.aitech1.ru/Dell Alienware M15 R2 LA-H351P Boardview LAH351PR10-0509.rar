# Allegro board LAH351PR10-0509.brd (continued)
## Nets (continued)
+NVVDD: CG6897.1 CG6898.1 CG6899.1 CG6900.1 CG6901.1 CG6902.1 CG6903.1 CG6904.1 CG6905.1 CG6906.1 CG6907.1 CG6908.1 CG6909.1 CG6910.1 CG6911.1 CG6912.1 CG6913.1 CG6914.1 CG6915.1 CG6916.1 CG6917.1 CG6918.1 CG6919.1 CG6920.1 CG6921.1 CG6922.1 CG6923.1 CG6924.1 CG6925.1 CG6926.1 CG6927.1 CG6928.1 CG6929.1 CG6930.1 CG6931.1 CG6932.1 CG6933.1 CG6934.1 CG6935.1 CG6936.1 CG6937.1 CG6938.1 CG6939.1 CG6940.1 CG6941.1 CG6942.1 CG6943.1 CG6944.1 CG6945.1 CG6946.1 CG6947.1 CG6948.1 CG6949.1 CG6950.1 CG6951.1 CG6952.1 CG6953.1 CG6954.1 CG6955.1 CG6956.1 CG6957.1 CG6958.1 CG6959.1 CG6960.1 CG6961.1 CG6962.1 CG6963.1 CG6964.1 CG6965.1 CG6966.1 CG6967.1 CG6968.1 CG6969.1 CG6970.1 CG6971.1 CG6972.1 CG6973.1 CG6974.1 CG6975.1 CG6976.1 CG6977.1 CG6978.1 CG6979.1 CG6980.1 CG6981.1 CG6982.1 CG6983.1 CG6984.1 CG6985.1 CG6986.1 CG6987.1 CG6988.1 CG6989.1 CG6990.1 CG6991.1 CG6992.1 CG6993.1 CG6994.1 CG6995.1 CG6996.1 CG6997.1 CG6998.1 CG6999.1 CG7000.1 CG7001.1 CG7002.1 CG7003.1 CG7004.1 CG7005.1 CG7006.1 CG7007.1 CG7008.1 CG7009.1 CG7010.1 CG7011.1 CG7012.1 CG7013.1 CG7014.1 CG7015.1 CG7016.1 CG7017.1 CG7018.1 CG7019.1 CG7020.1 CG7021.1 CG7022.1 CG7023.1 CG7024.1 CG7025.1 CG7026.1 CG7027.1 CG7028.1 CG7029.1 CG7030.1 CG7031.1 CG7032.1 CG7033.1 CG7034.1 CG7035.1 CG7036.1 CG7037.1 CG7038.1 CG7039.1 CG7040.1 CG7041.1 CG7042.1 CG7043.1 CG7044.1 CG7045.1 CG7046.1 CG7047.1 CG7048.1 CG7049.1 CG7050.1 CG7051.1 CG7052.1 CG7053.1 CG7054.1 CG7055.1 CG7056.1 CG7057.1 CG7058.1 CG7059.1 CG7060.1 CG7061.1 CG7062.1 CG7063.1 CG7064.1 CG7065.1 CG7066.1 CG7067.1 CG7068.1 CG7069.1 CG7070.1 CG7071.1 CG7072.1 CG7073.1 CG7074.1 CG7075.1 CG7076.1 CG7077.1 CG7078.1 CG7079.1 CG7080.1 CG7081.1 PCV78.1 PCV79.1 PCV108.1 PCV109.1 PCV138.1 PCV139.1 PCV168.1 PCV169.1 PCV172.1 PCV173.1 PCV174.1 PCV175.1 PCV176.1 PCV177.1 PCV178.1 PCV179.1 PCV180.1 PCV181.1 PCV182.1 PCV183.1 PCV184.1 PCV185.1 PCV186.1 PCV187.1 PCV188.1 PCV189.1 PCV190.1 PCV191.1 PCV192.1 PCV193.1 PCV194.1 PCV195.1 PCV196.1 PCV197.1 PCV198.1 PCV199.1 PCV200.1 PCV201.1 PCV202.1 PCV203.1 PLV01.1 PLV02.1 PLV03.1 PLV04.1 PLV05.1 PLV06.1 PLV07.1 PLV08.1 PRV40.2 RG544.1 UG1.AA13 UG1.AA14 UG1.AA15 UG1.AA16 UG1.AA17 UG1.AA18 UG1.AA19 UG1.AA20 UG1.AA21 UG1.AA22 UG1.AA23 UG1.AA24 UG1.AA25 UG1.AA26 UG1.AA27 UG1.AA28 UG1.AA29 UG1.AA30 UG1.AA31 UG1.AA32 UG1.AA33 UG1.AA34 UG1.AA35 UG1.AA36 UG1.AA37 UG1.AA38 UG1.AA39 UG1.AA40 UG1.AB13 UG1.AB40 UG1.AC13 UG1.AC14 UG1.AC15 UG1.AC16 UG1.AC17 UG1.AC18 UG1.AC19 UG1.AC20 UG1.AC21 UG1.AC22 UG1.AC23 UG1.AC24 UG1.AC25 UG1.AC26 UG1.AC27 UG1.AC28 UG1.AC29 UG1.AC30 UG1.AC31 UG1.AC32 UG1.AC33 UG1.AC34 UG1.AC35 UG1.AC36 UG1.AC37 UG1.AC38 UG1.AC39 UG1.AC40 UG1.AD13 UG1.AD40 UG1.AE13 UG1.AE14 UG1.AE15 UG1.AE16 UG1.AE17 UG1.AE18 UG1.AE19 UG1.AE20 UG1.AE21 UG1.AE22 UG1.AE23 UG1.AE24 UG1.AE25 UG1.AE26 UG1.AE27 UG1.AE28 UG1.AE29 UG1.AE30 UG1.AE31 UG1.AE32 UG1.AE33 UG1.AE34 UG1.AE35 UG1.AE36 UG1.AE37 UG1.AE38 UG1.AE39 UG1.AE40 UG1.AF13 UG1.AF14 UG1.AF15 UG1.AF16 UG1.AF17 UG1.AF18 UG1.AF24 UG1.AF25 UG1.AF26 UG1.AF30 UG1.AF31 UG1.AF32 UG1.AF33 UG1.AF34 UG1.AF40 UG1.AG13 UG1.AG19 UG1.AG20 UG1.AG21 UG1.AG22 UG1.AG23 UG1.AG27 UG1.AG28 UG1.AG29 UG1.AG35 UG1.AG36 UG1.AG37 UG1.AG38 UG1.AG39 UG1.AG40 UG1.AH13 UG1.AH14 UG1.AH15 UG1.AH16 UG1.AH17 UG1.AH18 UG1.AH19 UG1.AH20 UG1.AH21 UG1.AH22 UG1.AH23 UG1.AH24 UG1.AH25 UG1.AH26 UG1.AH27 UG1.AH28 UG1.AH29 UG1.AH30 UG1.AH31 UG1.AH32 UG1.AH33 UG1.AH34 UG1.AH35 UG1.AH36 UG1.AH37 UG1.AH38 UG1.AH39 UG1.AH40 UG1.AJ13 UG1.AJ40 UG1.AK13 UG1.AK14 UG1.AK15 UG1.AK16 UG1.AK17 UG1.AK18 UG1.AK19 UG1.AK20 UG1.AK21 UG1.AK22 UG1.AK23 UG1.AK24 UG1.AK25 UG1.AK26 UG1.AK27 UG1.AK28 UG1.AK29 UG1.AK30 UG1.AK31 UG1.AK32 UG1.AK33 UG1.AK34 UG1.AK35 UG1.AK36 UG1.AK37 UG1.AK38 UG1.AK39 UG1.AK40 UG1.AL13 UG1.AL40 UG1.AM13 UG1.AM14 UG1.AM15 UG1.AM16 UG1.AM17 UG1.AM18 UG1.AM19 UG1.AM20 UG1.AM21 UG1.AM22 UG1.AM23 UG1.AM24 UG1.AM25 UG1.AM26 UG1.AM27 UG1.AM28 UG1.AM29 UG1.AM30 UG1.AM31 UG1.AM32 UG1.AM33 UG1.AM34 UG1.AM35 UG1.AM36 UG1.AM37 UG1.AM38 UG1.AM39 UG1.AM40 UG1.AN13 UG1.AN40 UG1.AP13 UG1.AP14 UG1.AP15 UG1.AP16 UG1.AP17 UG1.AP18 UG1.AP19 UG1.AP20 UG1.AP21 UG1.AP22 UG1.AP23 UG1.AP24 UG1.AP25 UG1.AP26 UG1.AP27 UG1.AP28 UG1.AP29 UG1.AP30 UG1.AP31 UG1.AP32 UG1.AP33 UG1.AP34 UG1.AP35 UG1.AP36 UG1.AP37 UG1.AP38 UG1.AP39 UG1.AP40 UG1.AR13 UG1.AR40 UG1.AT13 UG1.AT14 UG1.AT15 UG1.AT16 UG1.AT17 UG1.AT18 UG1.AT19 UG1.AT20 UG1.AT21 UG1.AT22 UG1.AT23 UG1.AT24 UG1.AT25 UG1.AT26 UG1.AT27 UG1.AT28 UG1.AT29 UG1.AT30 UG1.AT31 UG1.AT32 UG1.AT33 UG1.AT34 UG1.AT35 UG1.AT36 UG1.AT37 UG1.AT38 UG1.AT39 UG1.AT40 UG1.AT42 UG1.AU13 UG1.AU40 UG1.AU43 UG1.AV13 UG1.AV14 UG1.AV15 UG1.AV16 UG1.AV17 UG1.AV18 UG1.AV19 UG1.AV20 UG1.AV21 UG1.AV22 UG1.AV23 UG1.AV24 UG1.AV25 UG1.AV26 UG1.AV27 UG1.AV28 UG1.AV29 UG1.AV30 UG1.AV31 UG1.AV32 UG1.AV33 UG1.AV34 UG1.AV35 UG1.AV36 UG1.AV37 UG1.AV38 UG1.AV39 UG1.AV40 UG1.AV42 UG1.AV43 UG1.AV44 UG1.AW13 UG1.AW40 UG1.AW42 UG1.AW43 UG1.AW44 UG1.AW45 UG1.AY13 UG1.AY14 UG1.AY15 UG1.AY16 UG1.AY17 UG1.AY18 UG1.AY19 UG1.AY20 UG1.AY21 UG1.AY22 UG1.AY23 UG1.AY24 UG1.AY25 UG1.AY26 UG1.AY27 UG1.AY28 UG1.AY29 UG1.AY30 UG1.AY31 UG1.AY32 UG1.AY33 UG1.AY34 UG1.AY35 UG1.AY36 UG1.AY37 UG1.AY38 UG1.AY39 UG1.AY40 UG1.AY43 UG1.AY45 UG1.BA43 UG1.BA44 UG1.BA45 UG1.BA46 UG1.BA47 UG1.BB38 UG1.BB39 UG1.BB45 UG1.BB46 UG1.BB47 UG1.BB48 UG1.BC38 UG1.BC39 UG1.BC40 UG1.BC41 UG1.BC45 UG1.BC47 UG1.BC49 UG1.BD39 UG1.BD41 UG1.BD46 UG1.BD47 UG1.BD48 UG1.BD49 UG1.BD50 UG1.BD51 UG1.BE41 UG1.BE42 UG1.BE43 UG1.BE46 UG1.BE47 UG1.BE48 UG1.BE49 UG1.BE50 UG1.BE51 UG1.BE52 UG1.BF42 UG1.BF44 UG1.BF45 UG1.BF47 UG1.BF49 UG1.BF51 UG1.BG43 UG1.BG44 UG1.BG45 UG1.BG46 UG1.BG47 UG1.BG48 UG1.BG49 UG1.BG50 UG1.BG51 UG1.BG52 UG1.BH44 UG1.BH45 UG1.BH47 UG1.BH48 UG1.BH49 UG1.BH50 UG1.BH51 UG1.BH52 UG1.BJ44 UG1.BJ45 UG1.BJ46 UG1.BJ47 UG1.BJ48 UG1.BJ49 UG1.BJ50 UG1.BJ51 UG1.BJ52 UG1.BK47 UG1.BK48 UG1.BK49 UG1.BK50 UG1.BK51 UG1.BK52 UG1.BL46 UG1.BL47 UG1.BL48 UG1.BL49 UG1.BL50 UG1.BL51 UG1.BL52 UG1.BM47 UG1.BM48 UG1.BM49 UG1.BM50 UG1.BM51 UG1.N13 UG1.N14 UG1.N15 UG1.N16 UG1.N17 UG1.N18 UG1.N19 UG1.N20 UG1.N21 UG1.N22 UG1.N23 UG1.N24 UG1.N25 UG1.N26 UG1.N27 UG1.N28 UG1.N29 UG1.N30 UG1.N31 UG1.N32 UG1.N33 UG1.N34 UG1.N35 UG1.N36 UG1.N37 UG1.N38 UG1.N39 UG1.N40 UG1.P13 UG1.P40 UG1.R13 UG1.R14 UG1.R15 UG1.R16 UG1.R17 UG1.R18 UG1.R19 UG1.R20 UG1.R21 UG1.R22 UG1.R23 UG1.R24 UG1.R25 UG1.R26 UG1.R27 UG1.R28 UG1.R29 UG1.R30 UG1.R31 UG1.R32 UG1.R33 UG1.R34 UG1.R35 UG1.R36 UG1.R37 UG1.R38 UG1.R39 UG1.R40 UG1.T13 UG1.T40 UG1.U13 UG1.U14 UG1.U15 UG1.U16 UG1.U17 UG1.U18 UG1.U19 UG1.U20 UG1.U21 UG1.U22 UG1.U23 UG1.U24 UG1.U25 UG1.U26 UG1.U27 UG1.U28 UG1.U29 UG1.U30 UG1.U31 UG1.U32 UG1.U33 UG1.U34 UG1.U35 UG1.U36 UG1.U37 UG1.U38 UG1.U39 UG1.U40 UG1.V13 UG1.V40 UG1.W13 UG1.W14 UG1.W15 UG1.W16 UG1.W17 UG1.W18 UG1.W19 UG1.W20 UG1.W21 UG1.W22 UG1.W23 UG1.W24 UG1.W25 UG1.W26 UG1.W27 UG1.W28 UG1.W29 UG1.W30 UG1.W31 UG1.W32 UG1.W33 UG1.W34 UG1.W35 UG1.W36 UG1.W37 UG1.W38 UG1.W39 UG1.W40 UG1.Y13 UG1.Y40
+PEX_PLL_HVDD: CG30.1 LG1.1 UG1.BB30
+PEX_VDD: CG1.1 CG2.1 CG5.2 CG6.2 CG7.2 CG11.1 CG12.1 CG13.1 CG14.1 CG15.1 CG16.1 CG17.1 CG18.1 CG19.1 CG20.1 CG21.1 CG22.1 CG23.1 CG24.1 CG25.1 CG26.1 CG27.1 CG28.1 CG29.1 CG6502.1 CG6506.1 CG6508.1 CG7125.1 CG7126.1 CG7127.1 CG7133.1 CG7134.1 CG7135.1 CG7136.1 CG7137.1 CG7138.1 CG7139.1 CG7140.1 PJP1101.2 RG1527.2 RG1528.2 RG1585.2 RG1586.2 RG1587.2 RG1588.2 RG1589.2 RG1590.2 RG1591.2 RG1592.2 RG1593.2 RG1594.2 RG1607.1 UG1.BB17 UG1.BB18 UG1.BB20 UG1.BB21 UG1.BB23 UG1.BB33 UG1.BB35 UG1.BB36 UG1.BC17 UG1.BC21 UG1.BC23 UG1.BC33 UG1.BC35 UG1.BC36 UG1.BD33 UG1.BD36
+RTC_CELL: CH80.1 CH173.1 CH226.1 PD4.1 QE58.1 RH83.1 RH84.1 RH531.2 UH1.BC49 UH1.BD49
+TBTA_VBUS: CT94.2 CT95.2 CT96.1 CT97.1 CT106.1 DT1.1 DT15.2 DT15.3 JUSBC.A4 JUSBC.A9 JUSBC.B4 JUSBC.B9 UT4.A10 UT4.B10 UT4.H11 UT4.J10 UT4.J11 UT4.K11
AC_PRESENT: DH1.2 RH533.1 UH1.BG42
ACIN#: QE3.3 RE17.2 UE1.18
ACIN_CHG: PCB31.2 PRB39.2 PRB42.1 PUB1.1
ACIN_ISL95338_1: PRV96.2 PUV3.19
ACIN_R_1: PDV01.2 PRV96.1 PRV98.2 PRV103.1 PRV226.2
ACLIM_CHG: PRB35.2 PRB36.1 PUB1.16
AD0_2: RE164.1 UE8.31
AD1_2: RE163.1 UE8.32
AD2_2: RE165.2 UE8.1
AD3_2: RE162.1 UE8.2
AD_BID: CE28.1 RE64.1 RE66.2 UE5.A12
ADC_IN_N: RG1561.2 UG1.BJ11 UG37.19
ADC_IN_N_RC: CG7119.2 RG1561.1
ADC_IN_P: RG1560.2 UG1.BJ9 UG37.20
ADC_IN_P_RC: CG7118.2 RG1560.1
ADC_MUX_SEL: RG1537.1 UG37.29
ADDR/FSW_GPU: PRV3.1 PRV4.1 PUV1.26
ADP_I: PCB6.1 PR23.2 PRB27.1 UE5.B12
ADPS_ISL95338_1: PCV36.1 PRV92.2 PUV3.13 PUV3.16
ALIEN_LED_B_DRV#: JEDP.30 UE8.17
ALIEN_LED_G_DRV#: JEDP.29 UE8.16
ALIEN_LED_R_DRV#: JEDP.28 UE8.15
AMON_CHG: PRB27.2 PUB1.6
ASGATE_CHG: PRB40.2 PUB1.30
BA: PQB17.1 PRB11.2 PRB12.1
BA_PWR: PDB1.2 PRB12.2
BATGONE_CHG: PRB28.1 PUB1.13
BATLOW#: RT14.1 RT31.2 UT1.F2
BATT_CHG_LED: QE1.6 RE23.2 UE1.19
BATT_CHG_LED#: QE1.2 UE10.2
BATT_LOW_LED: QE3.6 RE21.2 UE1.13
BATT_LOW_LED#: QE3.2 UE10.5
BATT_PRS: PBATT1.5 PR22.1
BBS_BIT0: RH130.2 UH1.BA26
BEEP#: JIO1.B5 UE5.M8
BG_REF_OUT: CG7123.1 RG1566.2 RG1568.2 UG37.23
BGATE_CHG: PRB15.1 PUB1.25
BIA_PWM_PCH: RV681.1 UH1.AU48
BKOFF: DV1.2 UE5.L12
BMON_CHG: PRB22.2 PUB1.7
BOARD_ID: RH21.1 RH1601.1 UH1.BA20
BS2_1.0VS_VGAP: PC1109.1 PR1102.1
BS2_+1.8VGS: PC1817.1 PR1808.1
BS_1.0VS_VGAP: PR1102.2 PU1101.1
BS_+1.8VGS: PR1808.2 PU1802.1
BS_OK: RG1562.1 UG37.30
BS_REF: CG7122.1 RG1566.1 RG1567.2 UG37.24
BST1_ISL95338_1: PCV38.2 PUV3.12
BST1_NVVDD: PRV107.1 PUV4.5
BST1_NVVDD_R: PCV60.2 PRV107.2
BST1_R_ISL95338_1: PCV38.1 PRV93.2
BST2_ISL95338_1: PCV39.1 PUV3.4
BST2_ISL95338_1_R: PCV39.2 PRV94.1
BST2_NVVDD: PRV106.1 PUV5.5
BST2_NVVDD_R: PCV61.2 PRV106.2
BST3_NVVDD: PRV130.1 PUV6.5
BST3_NVVDD_R: PCV95.1 PRV130.2
BST4_NVVDD: PRV131.1 PUV7.5
BST4_NVVDD_R: PCV94.1 PRV131.2
BST5_NVVDD: PRV153.1 PUV9.5
BST5_NVVDD_R: PCV125.1 PRV153.2
BST6_NVVDD: PRV152.1 PUV8.5
BST6_NVVDD_R: PCV124.1 PRV152.2
BST7_NVVDD: PRV174.1 PUV10.5
BST7_NVVDD_R: PCV154.1 PRV174.2
BST8_NVVDD: PRV175.1 PUV11.5
BST8_NVVDD_R: PCV155.1 PRV175.2
BST_1.2V: PRM3.2 PUM1.18
BST_1.2V_R: PCM12.1 PRM3.1
BST_1.35PH1: PRW34.1 PUW2.5
BST_1.35PH1_R: PCW22.2 PUW2.7
BST_1.35PH2_R: PCW37.2 PRW44.2
BST_3V: PR302.1 PU301.1
BST_3V_R: PC315.1 PR302.2
BST_5V: PR502.1 PU501.13
BST_5V_R: PC518.1 PR502.2
BST_+1VALWP: PRH2.1 PUH1.10
BST_+1VALWP_R: PCH5.1 PRH2.2
BST_CHG: PRB14.1 PUB1.24
BST_CHG_R: PCB8.1 PRB14.2
BST_PH4: PRZ102.1 PUZ5.5
BST_PH4_R: PCZ92.1 PRZ102.2
BST_VCCGT: PRG02.1 PUG01.5
BST_VCCGT_R: PCG09.1 PRG02.2
BST_VCCIO: PRH11.2 PUH2.1
BST_VCCIO_R: PCH23.1 PRH11.1
BST_VCCSA: PRA1.1 PUA1.5
BST_VCCSA_R: PCA4.1 PRA1.2
BST_VCORE_PH1: PRZ79.1 PUZ3.5
BST_VCORE_PH1_R: PCZ59.1 PRZ79.2
BST_VCORE_PH2: PRZ80.1 PUZ2.5
BST_VCORE_PH2_R: PCZ60.1 PRZ80.2
BST_VCORE_PH3: PRZ103.1 PUZ6.5
BST_VCORE_PH3_R: PCZ93.1 PRZ103.2
BST_VCORE_PH5: PRZ126.1 PUZ8.5
BST_VCORE_PH5_R: PCZ122.1 PRZ126.2
BST_VCORE_PH6: PRZ125.1 PUZ9.5
BST_VCORE_PH6_R: PCZ121.1 PRZ125.2
BT_OFF#: JIO2.D1 RH517.2 UH1.BA24
BUSPOWER#: RT130.2 RT131.2 UT4.F10
CALDERA_ON: JCDRA.1 RM41.2 UE5.F13 UM7.2
CALDERA_PRSNT#: JCDRA.21 RM5.2 RM61.1 UE1.22 UE5.E12
CALDERA_PWRGD: JCDRA.2 RM42.1 UE5.H10
CALDERA_RST#: RM6.2 UE5.H9 UM3.1
CCLIM_CHG: PRB19.2 PRB38.1 PUB1.11
CDR_BTN#: JCDRA.26 RM17.2 UE5.K7
CDR_ON_ELC: UE1.21 UM7.4
CDR_TXRX_GOOD: UE5.J12 UM7.1
CDRA_CLK: JCDRA.45 RM1.1
CDRA_DAT: JCDRA.46 RM2.1
CDRA_LED_RED: JCDRA.28 QM3.1
CDRA_LED_RED_MOS: QM2.5 UE10.10
CDRA_LED_RED_R: QM3.3 RM93.2
CDRA_LED_WHITE: JCDRA.27 QM1.1
CDRA_LED_WHITE_MOS: QM2.2 UE5.M9
CDRA_LED_WHITE_R: QM1.3 RM91.2
CDRA_RST#: JCDRA.22 UM3.4
CFG0: JPCMC.1 UC1.BN25
CFG1: JPCMC.3 UC1.BN27
CFG2: JPCMC.5 RH184.1 UC1.BN26
CFG3: JPCMC.7 JPCMC.23 UC1.BN28
CFG4: JPCMC.9 RH185.1 UC1.BR20
CFG5: JPCMC.11 RH186.1 UC1.BM20
CFG6: JPCMC.13 RH187.1 UC1.BT20
CFG7: JPCMC.15 RH188.1 UC1.BP20
CFG8: JPCMC.2 UC1.BR23
CFG9: JPCMC.4 UC1.BR22
CFG10: JPCMC.6 UC1.BT23
CFG11: JPCMC.8 UC1.BT22
CFG12: JPCMC.10 UC1.BM19
CFG13: JPCMC.12 UC1.BR19
CFG14: JPCMC.14 UC1.BP19
CFG15: JPCMC.16 UC1.BT19
CFG16: JPCMC.21 UC1.BP23
CFG17: JPCMC.17 UC1.BN23
CFG18: JPCMC.20 UC1.BN22
CFG19: JPCMC.18 UC1.BP22
CFG_RCOMP: RH59.1 UC1.BT25
CH_OC_GPU: PRV66.1 PUV1.3
CLK_PCI_ESPI: CH246.1 RH89.1 TC20.1(TP-1) UE5.N5
CLK_PCIE_DGPU#_C: CM99.2 JCDRA.34
CLK_PCIE_DGPU_C: CM98.2 JCDRA.33
CLK_PCIE_N1: JSSD1.53 UH1.AH9
CLK_PCIE_N3: UH1.AE6 UT1.T19
CLK_PCIE_N4: JIO1.G6 UH1.AC2
CLK_PCIE_N5: JIO2.G6 UH1.AB2
CLK_PCIE_N7: JSSD3.53 UH1.W7
CLK_PCIE_P1: JSSD1.55 UH1.AH10
CLK_PCIE_P3: UH1.AE7 UT1.V19
CLK_PCIE_P4: JIO1.G5 UH1.AC3
CLK_PCIE_P5: JIO2.G5 UH1.AB3
CLK_PCIE_P7: JSSD3.55 UH1.W6
CLK_PEG_N0: UG1.BM27 UH1.AJ6
CLK_PEG_N6: UH1.W4 UM4.3
CLK_PEG_P0: UG1.BM26 UH1.AJ7
CLK_PEG_P6: UH1.W3 UM4.2
CLK_SMB: PBATT1.7 PR19.1
CLKDET#: RH558.1 UH1.BF35
CLKREQ_PCIE#1: JSSD1.52 RP3.6 UH1.BE31
CLKREQ_PCIE#3: RT2.2 UH1.BB30
CLKREQ_PCIE#3_R: RT2.1 RT20.2 UT1.AC5
CLKREQ_PCIE#4: JIO1.G8 RP3.8 UH1.BA30
CLKREQ_PCIE#5: JIO2.C4 RP5.6 UH1.AN29
CLKREQ_PCIE#7: JSSD3.52 R368.1 UH1.AC48
CLKREQ_PEG#0: QG510.1 RP3.5 UH1.BF31
CLKREQ_PEG#0_R: QG510.3 RG2.1 UG1.BL26
CLKREQ_PEG#6: RP5.5 UE5.G12 UH1.AE47 UM4.17
CLKRUN#: RH85.1 UH1.AV32
CM_REF_IN: CG7124.1 RG1568.1 RG1569.2 UG37.22
CMSRC_CHG: PRB41.2 PUB1.29
CNV_BRI_PRX_DTX: RH181.2 UH1.AY2
CNV_BRI_PTX_DRX: RH603.2 UH1.AV4
CNV_RGI_PRX_DTX: RH182.2 UH1.AV3
CNV_RGI_PTX_DRX: RH168.1 RH595.1 UH1.BA4
CNV_WT_RCOMP: RH213.1 UH1.BA1
COMP_1PH: PCZ14.2 PCZ38.1 PUZ1.50
COMP_2PH: PCZ18.2 PCZ36.2 PUZ1.33
COMP_4PH: PCZ17.1 PRZ72.1 PUZ1.6
COMP_CHG: PCB30.1 PRB25.1 PUB1.10
COMP_FBVDDQ: PCW10.1 PRW31.1 PUW1.11
COMP_GPU: PCV5.2 PRV73.2 PUV1.30
COMP_ISL95338_1: PCV42.1 PRV105.1 PUV3.28
CORE_V1N: PCZ58.1 PCZ73.2 PLZ01.3 PRZ87.1 PRZ98.2 PUZ4.9
CORE_V1P: PLZ01.2 PRZ13.2 PRZ56.1 PRZ101.2
CORE_V2N: PCZ57.2 PCZ252.1 PLZ02.3 PRZ86.1 PRZ99.2 PUZ4.11
CORE_V2P: PLZ02.2 PRZ12.2 PRZ60.1 PRZ100.1
CORE_V3N: PCZ90.1 PCZ106.2 PLZ03.3 PRZ110.1 PRZ122.2 PUZ7.9
CORE_V3P: PLZ03.2 PRZ16.2 PRZ55.1 PRZ124.2
CORE_V4N: PCZ91.2 PCZ253.1 PLZ04.3 PRZ109.1 PRZ121.2 PUZ7.11
CORE_V4P: PLZ04.2 PRZ14.2 PRZ58.1 PRZ123.1
CORE_V5N: PCZ119.1 PCZ135.2 PLZ05.3 PRZ132.1 PRZ144.2 PUZ10.9
CORE_V5P: PLZ05.2 PRZ57.1 PRZ146.2 PRZ153.2
CORE_V6N: PCZ120.2 PCZ134.1 PLZ06.3 PRZ133.1 PRZ145.2 PUZ10.11
CORE_V6P: PLZ06.2 PRZ61.1 PRZ147.1 PRZ154.2
CPU_24MHZ_N: UC1.D31 UH1.C6
CPU_24MHZ_P: UC1.E31 UH1.D7
CPU_DDC1CLK: RH604.2 UH1.AL13
CPU_DDC1CLK_T: RT127.1 UT1.Y5
CPU_DDC1DATA: RH605.2 UH1.AR8
CPU_DDC1DATA_T: RT126.1 UT1.R4
CPU_DDC2CLK: RH607.2 UH1.AN13
CPU_DDC2CLK_T: RT129.1 UT1.Y8
CPU_DDC2DATA: RH606.2 UH1.AL10
CPU_DDC2DATA_T: RT128.1 UT1.N4
CPU_DISPA_BCLK: RH38.1 UC1.G27
CPU_DISPA_BCLK_R: RH38.2 UH1.AM3
CPU_DISPA_SDI: RC66.2 UH1.AN3
CPU_DISPA_SDI_R: RC66.1 UC1.G29
CPU_DISPA_SDO: RH39.1 UC1.G25
CPU_DISPA_SDO_R: RH39.2 UH1.AM2
CPU_DP1_AUXN: CT26.1 UC1.E27
CPU_DP1_AUXN_C: CT26.2 RT76.1 UT1.W11
CPU_DP1_AUXP: CT25.1 UC1.D27
CPU_DP1_AUXP_C: CT25.2 RT78.1 UT1.Y11
CPU_DP1_HPD: RT38.1 UH1.AT6 UT1.AA2
CPU_DP1_N0: CT7.1 UC1.K37
CPU_DP1_N0_C: CT7.2 UT1.AC7
CPU_DP1_N1: CT9.1 UC1.J34
CPU_DP1_N1_C: CT9.2 UT1.AC9
CPU_DP1_N2: CT23.1 UC1.H36
CPU_DP1_N2_C: CT23.2 UT1.AC11
CPU_DP1_N3: CT24.1 UC1.J38
CPU_DP1_N3_C: CT24.2 UT1.AC13
CPU_DP1_P0: CT6.1 UC1.K36
CPU_DP1_P0_C: CT6.2 UT1.AB7
CPU_DP1_P1: CT8.1 UC1.J35
CPU_DP1_P1_C: CT8.2 UT1.AB9
CPU_DP1_P2: CT10.1 UC1.H37
CPU_DP1_P2_C: CT10.2 UT1.AB11
CPU_DP1_P3: CT11.1 UC1.J37
CPU_DP1_P3_C: CT11.2 UT1.AB13
CPU_DP2_AUXN: CT36.1 UC1.E26
CPU_DP2_AUXN_C: CT36.2 RT77.1 UT1.W12
CPU_DP2_AUXP: CT35.1 UC1.F26
CPU_DP2_AUXP_C: CT35.2 RT79.1 UT1.Y12
CPU_DP2_HPD: RT39.1 UH1.AN10 UT1.Y6
CPU_DP2_N0: CT28.1 UC1.H33
CPU_DP2_N0_C: CT28.2 UT1.AC15
CPU_DP2_N1: CT30.1 UC1.G38
CPU_DP2_N1_C: CT30.2 UT1.AC17
CPU_DP2_N2: CT32.1 UC1.F35
CPU_DP2_N2_C: CT32.2 UT1.AC19
CPU_DP2_N3: CT34.1 UC1.E36
CPU_DP2_N3_C: CT34.2 UT1.AC21
CPU_DP2_P0: CT27.1 UC1.H34
CPU_DP2_P0_C: CT27.2 UT1.AB15
CPU_DP2_P1: CT29.1 UC1.F37
CPU_DP2_P1_C: CT29.2 UT1.AB17
CPU_DP2_P2: CT31.1 UC1.F34
CPU_DP2_P2_C: CT31.2 UT1.AB19
CPU_DP2_P3: CT33.1 UC1.E37
CPU_DP2_P3_C: CT33.2 UT1.AB21
CPU_FAN_FB: DF1.2 RF1.1 UE5.M11
CPU_FAN_PWM: JFAN1.2 RF2.1 UE5.M10
CPU_TRIGGER: RH192.1 UH1.AK2
CPU_XDP_TRST#: JPCMC.28 RH497.2 UC1.BP30 UH1.AM4
CS_1.2V: PRM13.2 PUM1.13
CSCOMP_2PH: PCZ16.1 PCZ37.1 PHZ02.1 PRZ44.1 PRZ50.2 PUZ1.31
CSCOMP_4PH: PCZ15.1 PCZ27.1 PHZ05.1 PRZ69.1 PRZ76.1 PUZ1.8
CSIN_CHG: PCB2.2 PCB32.1 PRB7.2 PUB1.31
CSIP_CHG: PCB2.1 PCB20.1 PRB6.2 PUB1.32
CSN_1PH: PHZ01.1 PLG02.3 PRZ4.1
CSN_1PH_R: PCZ13.1 PCZ35.1 PCZ39.1 PRZ4.2 PUZ1.48
CSN_FBVDDQ: PRW8.1 PRW14.1 PUW1.13
CSNSUM_GPU: PRV214.1 PUV1.21
CSON_CHG: PCB4.2 PRB21.1 PUB1.14
CSOP_CHG: PCB4.1 PRB8.1 PUB1.15
CSP1_2PH: PCZ2.2 PRZ59.1 PUZ1.28
CSP1_4PH: PCZ7.2 PRZ45.2 PRZ56.2 PRZ60.2 PUZ1.11
CSP1_FBVDDQ: PCW4.1 PRW2.1 PRW18.1 PUW1.16
CSP1_GPU: PCV1.1 PRV23.1 PUV1.20
CSP2_4PH: PCZ6.2 PRZ42.2 PRZ55.2 PRZ58.2 PUZ1.12
CSP2_FBVDDQ: PCW2.1 PRW1.1 PRW17.1 PRW26.2 PUW1.15
CSP2_GPU: PCV14.1 PRV10.1 PUV1.19
CSP3_4PH: PCZ1.2 PRZ41.2 PRZ57.2 PRZ61.2 PUZ1.13
CSP3_FBVDDQ: PRW25.2 PUW1.14
CSP3_GPU: PCV7.1 PRV16.1 PUV1.18
CSP4_GPU: PCV3.1 PRV27.1 PUV1.17
CSP5_GPU: PCV16.1 PRV15.1 PUV1.16
CSP6_GPU: PCV11.1 PRV7.1 PUV1.15
CSP7_GPU: PCV15.1 PRV11.1 PUV1.14
CSP8_GPU: PCV9.1 PRV14.1 PUV1.13
CSP_1PH: PCZ13.2 PCZ35.2 PRZ11.1 PRZ49.2 PUZ1.47
CSPSUM_GPU: PCV209.1 PCV210.1 PRV202.2 PRV203.2 PRV204.2 PRV205.2 PRV206.2 PRV207.2 PRV208.2 PRV209.2 PRV210.1 PRV212.1 PUV1.22
CSREF_2PH: PCZ2.1 PCZ12.1 PRG03.2 PUZ1.29
CSREF_4PH: PCZ1.1 PCZ6.1 PCZ7.1 PCZ11.2 PRZ41.1 PRZ42.1 PRZ45.1 PRZ86.2 PRZ87.2 PRZ109.2 PRZ110.2 PRZ132.2 PRZ133.2 PUZ1.10
CSSN_B+: PRV109.3 RG62.1
CSSN_NVVDD: PRV108.3 RG66.1
CSSP_B+: PRV109.2 RG1501.2 RG1540.1
CSSP_NVVDD: PRV108.2 RG64.2 RG1541.1
CSSUM_2PH: PCZ16.2 PCZ37.2 PRZ15.1 PRZ64.2 PUZ1.30
CSSUM_4PH: PCZ15.2 PCZ27.2 PRZ12.1 PRZ13.1 PRZ14.1 PRZ16.1 PRZ54.2 PRZ153.1 PRZ154.1 PUZ1.9
CTL1: JIO1.C1 UE5.D12
CTL2: JIO1.C2 UE5.J13
DAC_GPU: PCV10.1 PCV13.2 PRV32.2 PUV1.28
DAT_SMB: PBATT1.6 PR21.1
DCIN_CHG: PCB21.1 PRB4.1 PUB1.18
DCIN_ISL95338_1: PCV37.1 PRV90.2 PUV3.17
DDR_A_ACT#: RD190.1 UC1.AU3 UD1.L3 UD2.L3 UD3.L3 UD4.L3
DDR_A_ALERT#: RD193.2 UC1.AU5 UD1.P9 UD2.P9 UD3.P9 UD4.P9
DDR_A_BA0: RD183.1 UC1.AH5 UD1.N2 UD2.N2 UD3.N2 UD4.N2
DDR_A_BA1: RD184.1 UC1.AH1 UD1.N8 UD2.N8 UD3.N8 UD4.N8
DDR_A_BG0: RD191.1 UC1.AU1 UD1.M2 UD2.M2 UD3.M2 UD4.M2
DDR_A_BG1: RD238.2 RD240.2 RD242.2 RD244.2 UC1.AU2
DDR_A_CKE0: RD187.1 UC1.AT1 UD1.K2 UD2.K2 UD3.K2 UD4.K2
DDR_A_CLK0: RD185.1 UC1.AG1 UD1.K7 UD2.K7 UD3.K7 UD4.K7
DDR_A_CLK#0: RD186.1 UC1.AG2 UD1.K8 UD2.K8 UD3.K8 UD4.K8
DDR_A_CS#0: RD188.1 UC1.AD5 UD1.L7 UD2.L7 UD3.L7 UD4.L7
DDR_A_D0: UC1.BR6 UD3.J7
DDR_A_D1: UC1.BT6 UD3.H8
DDR_A_D2: UC1.BP3 UD3.G2
DDR_A_D3: UC1.BR3 UD3.F7
DDR_A_D4: UC1.BN5 UD3.J3
DDR_A_D5: UC1.BP6 UD3.H7
DDR_A_D6: UC1.BP2 UD3.H3
DDR_A_D7: UC1.BN3 UD3.H2
DDR_A_D8: UC1.BL4 UD3.B8
DDR_A_D9: UC1.BL5 UD3.C8
DDR_A_D10: UC1.BL2 UD3.D7
DDR_A_D11: UC1.BM1 UD3.C7
DDR_A_D12: UC1.BK4 UD3.C2
DDR_A_D13: UC1.BK5 UD3.A3
DDR_A_D14: UC1.BK1 UD3.C3
DDR_A_D15: UC1.BK2 UD3.D3
DDR_A_D16: UC1.BT11 UD1.G2
DDR_A_D17: UC1.BR11 UD1.H3
DDR_A_D18: UC1.BT9 UD1.J7
DDR_A_D19: UC1.BR8 UD1.H7
DDR_A_D20: UC1.BP11 UD1.H2
DDR_A_D21: UC1.BN11 UD1.J3
DDR_A_D22: UC1.BP8 UD1.F7
DDR_A_D23: UC1.BN8 UD1.H8
DDR_A_D24: UC1.BL12 UD1.C2
DDR_A_D25: UC1.BL11 UD1.D3
DDR_A_D26: UC1.BL8 UD1.A3
DDR_A_D27: UC1.BJ8 UD1.B8
DDR_A_D28: UC1.BJ11 UD1.D7
DDR_A_D29: UC1.BJ10 UD1.C8
DDR_A_D30: UC1.BL7 UD1.C3
DDR_A_D31: UC1.BJ7 UD1.C7
DDR_A_D32: UC1.BG4 UD4.H7
DDR_A_D33: UC1.BG5 UD4.H8
DDR_A_D34: UC1.BF4 UD4.J3
DDR_A_D35: UC1.BF5 UD4.H2
DDR_A_D36: UC1.BG2 UD4.J7
DDR_A_D37: UC1.BG1 UD4.F7
DDR_A_D38: UC1.BF1 UD4.H3
DDR_A_D39: UC1.BF2 UD4.G2
DDR_A_D40: UC1.BD2 UD4.D7
DDR_A_D41: UC1.BD1 UD4.C7
DDR_A_D42: UC1.BC4 UD4.D3
DDR_A_D43: UC1.BC5 UD4.C2
DDR_A_D44: UC1.BD5 UD4.C8
DDR_A_D45: UC1.BD4 UD4.B8
DDR_A_D46: UC1.BC1 UD4.C3
DDR_A_D47: UC1.BC2 UD4.A3
DDR_A_D48: UC1.BG11 UD2.J3
DDR_A_D49: UC1.BG10 UD2.H2
DDR_A_D50: UC1.BG8 UD2.H3
DDR_A_D51: UC1.BF8 UD2.H7
DDR_A_D52: UC1.BF11 UD2.F7
DDR_A_D53: UC1.BF10 UD2.H8
DDR_A_D54: UC1.BG7 UD2.G2
DDR_A_D55: UC1.BF7 UD2.J7
DDR_A_D56: UC1.BB11 UD2.C8
DDR_A_D57: UC1.BC11 UD2.C2
DDR_A_D58: UC1.BB8 UD2.D7
DDR_A_D59: UC1.BC8 UD2.C3
DDR_A_D60: UC1.BC10 UD2.D3
DDR_A_D61: UC1.BB10 UD2.B8
DDR_A_D62: UC1.BC7 UD2.A3
DDR_A_D63: UC1.BB7 UD2.C7
DDR_A_DQS0: UC1.BP5 UD3.G3
DDR_A_DQS1: UC1.BK3 UD3.B7
DDR_A_DQS2: UC1.BP9 UD1.G3
DDR_A_DQS3: UC1.BJ9 UD1.B7
DDR_A_DQS4: UC1.BF3 UD4.G3
DDR_A_DQS5: UC1.BC3 UD4.B7
DDR_A_DQS6: UC1.BF9 UD2.G3
DDR_A_DQS7: UC1.BB9 UD2.B7
DDR_A_DQS#0: UC1.BR5 UD3.F3
DDR_A_DQS#1: UC1.BL3 UD3.A7
DDR_A_DQS#2: UC1.BN9 UD1.F3
DDR_A_DQS#3: UC1.BL9 UD1.A7
DDR_A_DQS#4: UC1.BG3 UD4.F3
DDR_A_DQS#5: UC1.BD3 UD4.A7
DDR_A_DQS#6: UC1.BG9 UD2.F3
DDR_A_DQS#7: UC1.BC9 UD2.A7
DDR_A_MA0: RD166.1 UC1.AH3 UD1.P3 UD2.P3 UD3.P3 UD4.P3
DDR_A_MA1: RD167.1 UC1.AP4 UD1.P7 UD2.P7 UD3.P7 UD4.P7
DDR_A_MA2: RD168.1 UC1.AN4 UD1.R3 UD2.R3 UD3.R3 UD4.R3
DDR_A_MA3: RD169.1 UC1.AP5 UD1.N7 UD2.N7 UD3.N7 UD4.N7
DDR_A_MA4: RD170.1 UC1.AP2 UD1.N3 UD2.N3 UD3.N3 UD4.N3
DDR_A_MA5: RD171.1 UC1.AP1 UD1.P8 UD2.P8 UD3.P8 UD4.P8
DDR_A_MA6: RD172.1 UC1.AP3 UD1.P2 UD2.P2 UD3.P2 UD4.P2
DDR_A_MA7: RD173.1 UC1.AN1 UD1.R8 UD2.R8 UD3.R8 UD4.R8
DDR_A_MA8: RD174.1 UC1.AN3 UD1.R2 UD2.R2 UD3.R2 UD4.R2
DDR_A_MA9: RD175.1 UC1.AT4 UD1.R7 UD2.R7 UD3.R7 UD4.R7
DDR_A_MA10: RD176.1 UC1.AH2 UD1.M3 UD2.M3 UD3.M3 UD4.M3
DDR_A_MA11: RD177.1 UC1.AN2 UD1.T2 UD2.T2 UD3.T2 UD4.T2
DDR_A_MA12: RD178.1 UC1.AU4 UD1.M7 UD2.M7 UD3.M7 UD4.M7
DDR_A_MA13: RD179.1 UC1.AE3 UD1.T8 UD2.T8 UD3.T8 UD4.T8
DDR_A_MA14: RD180.1 UC1.AG4 UD1.L2 UD2.L2 UD3.L2 UD4.L2
DDR_A_MA15: RD181.1 UC1.AD1 UD1.M8 UD2.M8 UD3.M8 UD4.M8
DDR_A_MA16: RD182.1 UC1.AH4 UD1.L8 UD2.L8 UD3.L8 UD4.L8
DDR_A_ODT0: RD189.1 UC1.AD3 UD1.K3 UD2.K3 UD3.K3 UD4.K3
DDR_A_PARITY: RD192.1 UC1.AG3 UD1.T3 UD2.T3 UD3.T3 UD4.T3
DDR_B_ACT#: RD200.1 UC1.AT9 UD5.L3 UD6.L3 UD7.L3 UD8.L3
DDR_B_ALERT#: RD202.2 UC1.AR8 UD5.P9 UD6.P9 UD7.P9 UD8.P9
DDR_B_BA0: RD218.1 UC1.AH8 UD5.N2 UD6.N2 UD7.N2 UD8.N2
DDR_B_BA1: RD212.1 UC1.AH9 UD5.N8 UD6.N8 UD7.N8 UD8.N8
DDR_B_BG0: RD210.1 UC1.AR9 UD5.M2 UD6.M2 UD7.M2 UD8.M2
DDR_B_BG1: RD246.2 RD248.2 RD250.2 RD252.2 RD255.1 UC1.AR7
DDR_B_CKE0: RD220.1 UC1.AT8 UD5.K2 UD6.K2 UD7.K2 UD8.K2
DDR_B_CLK0: RD201.1 UC1.AM9 UD5.K7 UD6.K7 UD7.K7 UD8.K7
DDR_B_CLK#0: RD225.1 UC1.AN9 UD5.K8 UD6.K8 UD7.K8 UD8.K8
DDR_B_CS#0: RD207.1 UC1.AF11 UD5.L7 UD6.L7 UD7.L7 UD8.L7
DDR_B_D0: UC1.AB1 UD7.B8
DDR_B_D1: UC1.AB2 UD7.C7
DDR_B_D2: UC1.AA4 UD7.A3
DDR_B_D3: UC1.AA5 UD7.C2
DDR_B_D4: UC1.AB5 UD7.D7
DDR_B_D5: UC1.AB4 UD7.C8
DDR_B_D6: UC1.AA2 UD7.C3
DDR_B_D7: UC1.AA1 UD7.D3
DDR_B_D8: UC1.V5 UD7.F7
DDR_B_D9: UC1.V2 UD7.H7
DDR_B_D10: UC1.U1 UD7.H3
DDR_B_D11: UC1.U2 UD7.G2
DDR_B_D12: UC1.V1 UD7.J7
DDR_B_D13: UC1.V4 UD7.H8
DDR_B_D14: UC1.U5 UD7.H2
DDR_B_D15: UC1.U4 UD7.J3
DDR_B_D16: UC1.AA11 UD5.D7
DDR_B_D17: UC1.AA10 UD5.C8
DDR_B_D18: UC1.AC11 UD5.C2
DDR_B_D19: UC1.AC10 UD5.D3
DDR_B_D20: UC1.AA7 UD5.B8
DDR_B_D21: UC1.AA8 UD5.C7
DDR_B_D22: UC1.AC8 UD5.A3
DDR_B_D23: UC1.AC7 UD5.C3
DDR_B_D24: UC1.W8 UD5.J3
DDR_B_D25: UC1.W7 UD5.H3
DDR_B_D26: UC1.V10 UD5.H8
DDR_B_D27: UC1.V11 UD5.J7
DDR_B_D28: UC1.W11 UD5.H2
DDR_B_D29: UC1.W10 UD5.G2
DDR_B_D30: UC1.V7 UD5.F7
DDR_B_D31: UC1.V8 UD5.H7
DDR_B_D32: UC1.R2 UD8.B8
DDR_B_D33: UC1.P5 UD8.C2
DDR_B_D34: UC1.R4 UD8.C8
DDR_B_D35: UC1.P4 UD8.A3
DDR_B_D36: UC1.R5 UD8.D7
DDR_B_D37: UC1.P2 UD8.C3
DDR_B_D38: UC1.R1 UD8.C7
DDR_B_D39: UC1.P1 UD8.D3
DDR_B_D40: UC1.M4 UD8.J7
DDR_B_D41: UC1.M1 UD8.H7
DDR_B_D42: UC1.L4 UD8.H2
DDR_B_D43: UC1.L2 UD8.H3
DDR_B_D44: UC1.M5 UD8.H8
DDR_B_D45: UC1.M2 UD8.F7
DDR_B_D46: UC1.L5 UD8.J3
DDR_B_D47: UC1.L1 UD8.G2
DDR_B_D48: UC1.R11 UD6.A3
DDR_B_D49: UC1.P11 UD6.C8
DDR_B_D50: UC1.P7 UD6.C7
DDR_B_D51: UC1.R8 UD6.C3
DDR_B_D52: UC1.R10 UD6.C2
DDR_B_D53: UC1.P10 UD6.D7
DDR_B_D54: UC1.R7 UD6.D3
DDR_B_D55: UC1.P8 UD6.B8
DDR_B_D56: UC1.L11 UD6.H8
DDR_B_D57: UC1.M11 UD6.H2
DDR_B_D58: UC1.L7 UD6.F7
DDR_B_D59: UC1.M8 UD6.H3
DDR_B_D60: UC1.L10 UD6.J7
DDR_B_D61: UC1.M10 UD6.G2
DDR_B_D62: UC1.M7 UD6.J3
DDR_B_D63: UC1.L8 UD6.H7
DDR_B_DQS0: UC1.AB3 UD7.B7
DDR_B_DQS1: UC1.V3 UD7.G3
DDR_B_DQS2: UC1.AA9 UD5.B7
DDR_B_DQS3: UC1.V9 UD5.G3
DDR_B_DQS4: UC1.R3 UD8.B7
DDR_B_DQS5: UC1.M3 UD8.G3
DDR_B_DQS6: UC1.P9 UD6.B7
DDR_B_DQS7: UC1.L9 UD6.G3
DDR_B_DQS#0: UC1.AA3 UD7.A7
DDR_B_DQS#1: UC1.U3 UD7.F3
DDR_B_DQS#2: UC1.AC9 UD5.A7
DDR_B_DQS#3: UC1.W9 UD5.F3
DDR_B_DQS#4: UC1.P3 UD8.A7
DDR_B_DQS#5: UC1.L3 UD8.F3
DDR_B_DQS#6: UC1.R9 UD6.A7
DDR_B_DQS#7: UC1.M9 UD6.F3
DDR_B_MA0: RD206.1 UC1.AJ9 UD5.P3 UD6.P3 UD7.P3 UD8.P3
DDR_B_MA1: RD198.1 UC1.AK6 UD5.P7 UD6.P7 UD7.P7 UD8.P7
DDR_B_MA2: RD217.1 UC1.AK5 UD5.R3 UD6.R3 UD7.R3 UD8.R3
DDR_B_MA3: RD213.1 UC1.AL5 UD5.N7 UD6.N7 UD7.N7 UD8.N7
DDR_B_MA4: RD205.1 UC1.AL6 UD5.N3 UD6.N3 UD7.N3 UD8.N3
DDR_B_MA5: RD204.1 UC1.AM6 UD5.P8 UD6.P8 UD7.P8 UD8.P8
DDR_B_MA6: RD211.1 UC1.AN7 UD5.P2 UD6.P2 UD7.P2 UD8.P2
DDR_B_MA7: RD216.1 UC1.AN10 UD5.R8 UD6.R8 UD7.R8 UD8.R8
DDR_B_MA8: RD214.1 UC1.AN8 UD5.R2 UD6.R2 UD7.R2 UD8.R2
DDR_B_MA9: RD224.1 UC1.AR11 UD5.R7 UD6.R7 UD7.R7 UD8.R7
DDR_B_MA10: RD209.1 UC1.AH7 UD5.M3 UD6.M3 UD7.M3 UD8.M3
DDR_B_MA11: RD215.1 UC1.AN11 UD5.T2 UD6.T2 UD7.T2 UD8.T2
DDR_B_MA12: RD219.1 UC1.AR10 UD5.M7 UD6.M7 UD7.M7 UD8.M7
DDR_B_MA13: RD221.1 UC1.AF9 UD5.T8 UD6.T8 UD7.T8 UD8.T8
DDR_B_MA14: RD203.1 UC1.AH11 UD5.L2 UD6.L2 UD7.L2 UD8.L2
DDR_B_MA15: RD223.1 UC1.AF8 UD5.M8 UD6.M8 UD7.M8 UD8.M8
DDR_B_MA16: RD222.1 UC1.AH10 UD5.L8 UD6.L8 UD7.L8 UD8.L8
DDR_B_ODT0: RD199.1 UC1.AF7 UD5.K3 UD6.K3 UD7.K3 UD8.K3
DDR_B_PARITY: RD208.1 UC1.AJ7 UD5.T3 UD6.T3 UD7.T3 UD8.T3
DDR_DRAMRST#_R: CD69.1 CD111.2 CD112.2 CD113.2 CD114.1 RD31.1 UD1.P1 UD2.P1 UD3.P1 UD4.P1 UD5.P1 UD6.P1 UD7.P1 UD8.P1
DDR_RCOMP0: RH148.2 UC1.G1
DDR_RCOMP1: RH149.2 UC1.H1
DDR_RCOMP2: RH150.2 UC1.J2
DDR_VTT_PG_CTRL: UC1.BT13 UC2.2
DDRID_0: RH1023.2 RH1024.2 UH1.AW13
DDRID_1: RH1025.2 RH1026.2 UH1.BE9
DDRID_2: RH1027.2 RH1028.2 UH1.BF8
DDRID_3: RH1029.2 RH1030.2 UH1.BF9
DDRID_4: RH1032.2 RH1033.2 UH1.BG8
DEBUG_CTL1: RT66.2 UT4.E4
DEBUG_CTL2: RT67.2 UT4.D5
DEMB0: RM75.2 RM79.2 UM8.53
DEMB1: RM62.2 RM86.2 UM8.54
DEPOP#_EC: JIO1.G9 RE688.2 UE5.E9
DEVSLP1: JSSD3.38 UH1.AH35
DEVSLP4: JSSD1.38 UH1.AR47
DGPU_EN_EC: PDV01.1 PRV227.1 UE5.D6
DGPU_HOLD_RST#: RG13.1 UH1.BB20
DGPU_PEX_RST#: QG6.2 QG6.5 QG7.2 QG7.5 QV96.2 QV96.5 RG4.1 RG25.1 RG537.2 RG568.1 UG22.1 UX1.2 UX2.2
DGPU_PEX_RST#_R: RG4.2 UG1.BK26
DGPU_PRSNT#: RH135.2 UH1.BD38
DGPU_PWR_EN: PRV198.1
DGPU_PWR_EN_12262494: RG1520.1 RH537.1 UE5.B1 UG26.1 UG46.2 UH1.AN18
DGPU_PWROK: RH516.2 UH1.BE14
DGPU_ROM_SCLK: CG895.1 RG86.1 RG89.2 RG100.2 UG34.6
DGPU_ROM_SI: RG77.1 UG34.5
DGPU_ROM_SO_R: RG76.2 UG34.2
DH_1.2V: PQM01.4 PUM1.17
DIFFOUT_2PH: PRZ9.1 PRZ36.2 PUZ1.35
DIFFOUT_4PH: PCZ20.2 PRZ38.2 PUZ1.4
DISP_CEC: JDP.6 RV18.2
DISP_CLK_AUXP_CONN: JDP.16 RV15.2 UV3.4
DISP_DAT_AUXN_CONN: JDP.18 RV16.2 UV3.7
DISP_OFF#: DV1.1 JEDP.21 RV1.1
DL_1.2V: PQM02.4 PUM1.15
DMI_CRX_PTX_N0: UC1.E8 UH1.C33
DMI_CRX_PTX_N1: UC1.F6 UH1.C32
DMI_CRX_PTX_N2: UC1.E5 UH1.C31
DMI_CRX_PTX_N3: UC1.J9 UH1.C29
DMI_CRX_PTX_P0: UC1.D8 UH1.B33
DMI_CRX_PTX_P1: UC1.E6 UH1.B32
DMI_CRX_PTX_P2: UC1.D5 UH1.B31
DMI_CRX_PTX_P3: UC1.J8 UH1.B29
DMI_CTX_PRX_N0: UC1.A8 UH1.K34
DMI_CTX_PRX_N1: UC1.B6 UH1.G33
DMI_CTX_PRX_N2: UC1.A5 UH1.K32
DMI_CTX_PRX_N3: UC1.B4 UH1.G30
DMI_CTX_PRX_P0: UC1.B8 UH1.J35
DMI_CTX_PRX_P1: UC1.C6 UH1.F34
DMI_CTX_PRX_P2: UC1.B5 UH1.J32
DMI_CTX_PRX_P3: UC1.D4 UH1.F30
DP_CBL_DET: JDP.4 QG500.2 RV17.1 UV3.1
DP_CBL_DET#: RG501.1 RG540.1 UG1.BD5
DP_HPD_PCH: QX2.3 RX4.1 UH1.AW24 UX1.1
DPSNK_RBIAS: RT19.1 UT1.Y18
DPSRC_RBIAS: RT5.1 UT1.N6
DRVON: PUA1.16 PUG01.16 PUZ1.17 PUZ2.16 PUZ3.16 PUZ4.6 PUZ5.16 PUZ6.16 PUZ7.6 PUZ8.16 PUZ9.16 PUZ10.6
EAP_GPU: PRV9.2 PUV1.29
EC_AC_BAT#: RG16.1 UE5.D10 UG1.BE6
EC_ESB_CLK: RE642.2 UE5.N7 UE10.1
EC_ESB_DAT: RE643.2 UE5.M7 UE10.4
EC_LCD_TEST: RD254.1 UE5.J10
EC_ON: PD502.2 UE5.G1
EC_PECI_R: RH1022.1 UE5.H2
EC_RSMRST#: CE193.2 DE2.2 RC355.2 RH88.2 RH1017.2 UE5.D4 UH1.BA47
EC_RST: CE195.2 RG1612.2 UE5.K13
EC_RTCRST: QE5.2 RE650.1 UE10.14
EC_SCI#: RE694.1 RH521.2 UH1.AU26
EC_SMB_CK1: PD2.2 PR19.2 PRB16.1 PRV197.1 RE90.4 RT60.1 UE5.A8
EC_SMB_CK2: DK2.2 JPK.16 QG6.3 QH5.1 RE90.2 U2407.10 UE5.B8 UM8.50
EC_SMB_DA1: PD2.3 PR21.2 PRB20.1 PRV196.1 RE90.3 RT59.1 UE5.A7
EC_SMB_DA2: DK2.3 JPK.17 QG6.6 QH5.4 RE90.1 U2407.9 UE5.A6 UM8.49
EC_SRTCRST: QE66.5 RE693.1 UE10.20
EC_SSD: JSSD1.8 JSSD3.8 UE5.D5
EC_TX: JWDB1.2 RV686.1 UE5.K10
ECAGND: CE172.2 CE190.1 LE5.2 PH01.2 UE5.A11
EDICLK: RE719.2 UE5.C12
EDICS: RE718.2 UE5.D13
EDIDI: RE720.2 UE5.C13
EDIDO: RE721.2 UE5.E10
EDP_AUXN_C: CV13.1 JEDP.14
EDP_AUXN_PCH: CV13.2 UC1.B26
EDP_AUXP_C: CV12.1 JEDP.13
EDP_AUXP_PCH: CV12.2 UC1.C26
EDP_HPD_CPU: JEDP.20 RH9.1 UH1.AN6
EDP_LCD_TEST: JEDP.23 RD254.2 RV682.2
EDP_PWM: JEDP.22 RV681.2
EDP_RCOMP: RC30.1 UC1.D37
EDP_TXN0_C: CV2.1 JEDP.2
EDP_TXN0_PCH: CV2.2 UC1.E29
EDP_TXN1_C: CV4.1 JEDP.5
EDP_TXN1_PCH: CV4.2 UC1.E28
EDP_TXN2_C: CV6.1 JEDP.8
EDP_TXN2_PCH: CV6.2 UC1.B29
EDP_TXN3_C: CV11.1 JEDP.11
EDP_TXN3_PCH: CV11.2 UC1.B28
EDP_TXP0_C: CV1.1 JEDP.1
EDP_TXP0_PCH: CV1.2 UC1.D29
EDP_TXP1_C: CV3.1 JEDP.4
EDP_TXP1_PCH: CV3.2 UC1.F28
EDP_TXP2_C: CV8.1 JEDP.7
EDP_TXP2_PCH: CV8.2 UC1.A29
EDP_TXP3_C: CV7.1 JEDP.10
EDP_TXP3_PCH: CV7.2 UC1.C28
ELC_BOOT_MODE: RE5.1 RE657.2 UE1.44 UH1.BD29
ELC_EC#: QE13.5 QE21.5 QE22.5 UE10.6
ELC_RESET: CE8.1 JELC2.10 RE4.2 UE1.7 UH1.BD30
EN1_NVVDD: PRV121.2 PUV4.17
EN2_NVVDD: PRV123.2 PUV5.17
EN3_NVVDD: PRV138.2 PUV6.17
EN4_NVVDD: PRV149.2 PUV7.17
EN5_NVVDD: PRV160.2 PUV9.17
EN6_NVVDD: PRV171.2 PUV8.17
EN7_NVVDD: PRV182.2 PUV10.17
EN8_NVVDD: PRV183.2 PUV11.17
EN_0.6VSP: PCM19.1 PRM6.1 PRM7.1 PUM1.7
EN_1.2V: PCM18.1 PRM5.2 PUM1.8
EN_3V: PR505.1 PU301.9
EN_5V: PR503.1 PU501.6
EN_+1VALWP: PCH9.1 PRH5.2 PUH1.3
EN_FBVDDQ: PQW1.3 PRW28.1 PRW33.2 PUW1.2
EN_INVPWR: QV2.2 UE5.G13
EN_VCCIO: PCH27.1 PRH13.1 PRH19.1 PUH2.9
EN_WOL#: JIO1.B2 UE10.7
ENBKL_PCH: UE5.F9 UH1.AV46
ENLDO_3V5V: PR306.1 PR308.1 PU301.8 PU501.5
ENVDD_PCH: RV683.2 UH1.AV44
EQA0: RM81.2 RM84.2 UM8.20
EQA1: RM70.2 RM76.2 UM8.19
EQB0: RM82.2 RM85.2 UM8.46
EQB1: RM23.2 RM26.2 UM8.47
ESPI_FRAME#: TC22.1(TP-1) UE5.K4 UH1.BE38
ESPI_IO0: TC23.1(TP-1) UE5.N4 UH1.BB39
ESPI_IO1: TC24.1(TP-1) UE5.K5 UH1.AW37
ESPI_IO2: TC25.1(TP-1) UE5.M4 UH1.AV37
ESPI_IO3: TC26.1(TP-1) UE5.N3 UH1.BA38
ESPI_KB_RST#: RE712.1 RH518.1 UH1.BE39
ESPI_RST#: UE5.N9 UH1.BF38
ESPI_SERIRQ: RH111.1 TC21.1(TP-1) UE5.M3 UH1.AW35
FB_1.0VS_VGAP: PR1107.2 PR1110.2 PR1111.1 PU1101.11
FB_1.2V: PRM14.1 PRM15.1 PRM16.1 PRM17.1 PUM1.6
FB_2PH: PCZ18.1 PCZ22.2 PRZ36.1 PRZ71.1 PUZ1.34
FB_4PH: PCZ17.2 PCZ34.2 PRZ8.1 PRZ38.1 PUZ1.5
FB_+1.8VGS: PR1812.2 PR1814.1 PR1816.2 PU1802.11
FB_+1VALWP: PRH3.1 PRH7.1 PUH1.4
FB_A_CLK0: UG1.AG45 UG11.J10
FB_A_CLK1: UG1.AK46 UG12.J10
FB_A_CLK#0: UG1.AG46 UG11.K10
FB_A_CLK#1: UG1.AK45 UG12.K10
FB_A_CMD0: UG1.Y51 UG11.H3
FB_A_CMD1: UG1.Y52 UG11.J3 UG11.K3
FB_A_CMD2: RG1482.2 UG1.Y49 UG11.J1
FB_A_CMD3: UG1.AA52 UG11.J4 UG11.K4
FB_A_CMD4: UG1.AA51 UG11.L3
FB_A_CMD5: UG1.AA50 UG11.M4
FB_A_CMD6: UG1.AC50 UG11.J5 UG11.K5
FB_A_CMD7: UG1.AC51 UG11.H5 UG11.L5
FB_A_CMD8: UG1.AC52 UG11.G4
FB_A_CMD9: UG1.AC49 UG11.G11
FB_A_CMD10: RG1479.2 UG1.AD52 UG11.G10 UG11.M10
FB_A_CMD11: UG1.AD51 UG11.H10 UG11.L10
FB_A_CMD12: UG1.AD50 UG11.M11
FB_A_CMD13: UG1.AF50 UG11.L12
FB_A_CMD14: UG1.AF51 UG11.J11 UG11.K11
FB_A_CMD15: UG1.AF52 UG11.J12 UG11.K12
FB_A_CMD16: UG1.AN50 UG12.L3
FB_A_CMD17: UG1.AN51 UG12.J3 UG12.K3
FB_A_CMD18: RG1481.2 UG1.AN52 UG12.J1
FB_A_CMD19: UG1.AM49 UG12.J4 UG12.K4
FB_A_CMD20: UG1.AM52 UG12.H3
FB_A_CMD21: UG1.AM51 UG12.G4
FB_A_CMD22: UG1.AM50 UG12.J5 UG12.K5
FB_A_CMD23: UG1.AK50 UG12.H5 UG12.L5
FB_A_CMD24: UG1.AK51 UG12.M4
FB_A_CMD25: UG1.AK52 UG12.M11
FB_A_CMD26: RG1480.2 UG1.AJ49 UG12.G10 UG12.M10
FB_A_CMD27: UG1.AJ52 UG12.H10 UG12.L10
FB_A_CMD28: UG1.AJ51 UG12.G11
FB_A_CMD29: UG1.AJ50 UG12.H12
FB_A_CMD30: UG1.AG50 UG12.J12 UG12.K12
FB_A_CMD31: UG1.AG51 UG12.J11 UG12.K11
FB_A_CMD32: UG1.AF49 UG11.H12
FB_A_CMD33: UG1.AG52 UG12.L12
FB_A_D0: UG1.U51 UG11.G2
FB_A_D1: UG1.U48 UG11.E2
FB_A_D2: UG1.U50 UG11.F2
FB_A_D3: UG1.U49 UG11.E3
FB_A_D4: UG1.R51 UG11.B4
FB_A_D5: UG1.R50 UG11.B3
FB_A_D6: UG1.R47 UG11.B2
FB_A_D7: UG1.U46 UG11.A3
FB_A_D8: UG1.V46 UG11.B13
FB_A_D9: UG1.Y45 UG11.E13
FB_A_D10: UG1.Y47 UG11.G13
FB_A_D11: UG1.Y46 UG11.F13
FB_A_D12: UG1.V50 UG11.B12
FB_A_D13: UG1.V47 UG11.E12
FB_A_D14: UG1.U52 UG11.B11
FB_A_D15: UG1.V51 UG11.A12
FB_A_D16: UG1.AJ44 UG11.N13
FB_A_D17: UG1.AG48 UG11.P13
FB_A_D18: UG1.AJ45 UG11.M13
FB_A_D19: UG1.AG49 UG11.P12
FB_A_D20: UG1.AF46 UG11.U11
FB_A_D21: UG1.AF47 UG11.U12
FB_A_D22: UG1.AF48 UG11.U13
FB_A_D23: UG1.AD47 UG11.V12
FB_A_D24: UG1.AD49 UG11.M2
FB_A_D25: UG1.AD48 UG11.N2
FB_A_D26: UG1.AC46 UG11.P2
FB_A_D27: UG1.AC47 UG11.P3
FB_A_D28: UG1.AA47 UG11.U4
FB_A_D29: UG1.AA46 UG11.U3
FB_A_D30: UG1.AA45 UG11.V3
FB_A_D31: UG1.Y44 UG11.U2
FB_A_D32: UG1.AW51 UG12.B4
FB_A_D33: UG1.BA52 UG12.B2
FB_A_D34: UG1.AW50 UG12.B3
FB_A_D35: UG1.BA51 UG12.A3
FB_A_D36: UG1.BA50 UG12.E3
FB_A_D37: UG1.BB50 UG12.E2
FB_A_D38: UG1.BA49 UG12.F2
FB_A_D39: UG1.AW49 UG12.G2
FB_A_D40: UG1.AV48 UG12.E12
FB_A_D41: UG1.AT49 UG12.B13
FB_A_D42: UG1.AT47 UG12.F13
FB_A_D43: UG1.AT48 UG12.E13
FB_A_D44: UG1.AT46 UG12.G13
FB_A_D45: UG1.AV51 UG12.B12
FB_A_D46: UG1.AV52 UG12.B11
FB_A_D47: UG1.AV49 UG12.A12
FB_A_D48: UG1.AJ48 UG12.U13
FB_A_D49: UG1.AJ46 UG12.U11
FB_A_D50: UG1.AJ47 UG12.V12
FB_A_D51: UG1.AK49 UG12.U12
FB_A_D52: UG1.AM47 UG12.P13
FB_A_D53: UG1.AM46 UG12.P12
FB_A_D54: UG1.AN48 UG12.M13
FB_A_D55: UG1.AN49 UG12.N13
FB_A_D56: UG1.AM44 UG12.N2
FB_A_D57: UG1.AM45 UG12.M2
FB_A_D58: UG1.AN45 UG12.P2
FB_A_D59: UG1.AN46 UG12.V3
FB_A_D60: UG1.AR48 UG12.U2
FB_A_D61: UG1.AN47 UG12.U3
FB_A_D62: UG1.AR47 UG12.U4
FB_A_D63: UG1.AR46 UG12.P3
FB_A_DBI0: UG1.U47 UG11.D2
FB_A_DBI1: UG1.Y48 UG11.D13
FB_A_DBI2: UG1.AG47 UG11.R13
FB_A_DBI3: UG1.AC48 UG11.R2
FB_A_DBI4: UG1.BB51 UG12.D2
FB_A_DBI5: UG1.AV50 UG12.D13
FB_A_DBI6: UG1.AM48 UG12.R13
FB_A_DBI7: UG1.AR49 UG12.R2
FB_A_DEBUG0: RG1478.1 UG1.Y50
FB_A_DEBUG1: RG1476.1 UG1.AR50
FB_A_EDC0: UG1.R48 UG11.C2
FB_A_EDC1: UG1.V48 UG11.C13
FB_A_EDC2: UG1.AF44 UG11.T13
FB_A_EDC3: UG1.AA48 UG11.T2
FB_A_EDC4: UG1.BB52 UG12.C2
FB_A_EDC5: UG1.AT50 UG12.C13
FB_A_EDC6: UG1.AK48 UG12.T13
FB_A_EDC7: UG1.AR51 UG12.T2
FB_A_WCK01: UG1.U45 UG11.D4
FB_A_WCK23: UG1.AC45 UG11.R11
FB_A_WCK45: UG1.AV47 UG12.D4
FB_A_WCK67: UG1.AR45 UG12.R11
FB_A_WCK#01: UG1.U44 UG11.D5
FB_A_WCK#23: UG1.AC44 UG11.R10
FB_A_WCK#45: UG1.AV46 UG12.D5
FB_A_WCK#67: UG1.AR44 UG12.R10
FB_A_WCKB01: UG1.V45 UG11.D11
FB_A_WCKB23: UG1.AD46 UG11.R4
FB_A_WCKB45: UG1.AW48 UG12.D11
FB_A_WCKB67: UG1.AT45 UG12.R4
FB_A_WCKB#01: UG1.V44 UG11.D10
FB_A_WCKB#23: UG1.AD45 UG11.R5
FB_A_WCKB#45: UG1.AW47 UG12.D10
FB_A_WCKB#67: UG1.AT44 UG12.R5
FB_B_CLK0: UG1.H42 UG13.J10
FB_B_CLK1: UG1.F47 UG14.J10
FB_B_CLK#0: UG1.G42 UG13.K10
FB_B_CLK#1: UG1.E47 UG14.K10
FB_B_CMD0: UG1.B35 UG13.H3
FB_B_CMD1: UG1.A35 UG13.J3 UG13.K3
FB_B_CMD2: RG1485.2 UG1.D35 UG13.J1
FB_B_CMD3: UG1.A36 UG13.J4 UG13.K4
FB_B_CMD4: UG1.B36 UG13.L3
FB_B_CMD5: UG1.C36 UG13.M4
FB_B_CMD6: UG1.C38 UG13.J5 UG13.K5
FB_B_CMD7: UG1.B38 UG13.H5 UG13.L5
FB_B_CMD8: UG1.A38 UG13.G4
FB_B_CMD9: UG1.D38 UG13.G11
FB_B_CMD10: RG1483.2 UG1.A39 UG13.G10 UG13.M10
FB_B_CMD11: UG1.B39 UG13.H10 UG13.L10
FB_B_CMD12: UG1.C39 UG13.M11
FB_B_CMD13: UG1.C41 UG13.L12
FB_B_CMD14: UG1.B41 UG13.J11 UG13.K11
FB_B_CMD15: UG1.A41 UG13.J12 UG13.K12
FB_B_CMD16: UG1.B49 UG14.L3
FB_B_CMD17: UG1.A49 UG14.J3 UG14.K3
FB_B_CMD18: RG1486.2 UG1.A48 UG14.J1
FB_B_CMD19: UG1.D47 UG14.J4 UG14.K4
FB_B_CMD20: UG1.A47 UG14.H3
FB_B_CMD21: UG1.B47 UG14.G4
FB_B_CMD22: UG1.C47 UG14.J5 UG14.K5
FB_B_CMD23: UG1.C45 UG14.H5 UG14.L5
FB_B_CMD24: UG1.B45 UG14.M4
FB_B_CMD25: UG1.A45 UG14.M11
FB_B_CMD26: RG1484.2 UG1.D44 UG14.G10 UG14.M10
FB_B_CMD27: UG1.A44 UG14.H10 UG14.L10
FB_B_CMD28: UG1.B44 UG14.G11
FB_B_CMD29: UG1.C44 UG14.H12
FB_B_CMD30: UG1.C42 UG14.J12 UG14.K12
FB_B_CMD31: UG1.B42 UG14.J11 UG14.K11
FB_B_CMD32: UG1.D41 UG13.H12
FB_B_CMD33: UG1.A42 UG14.L12
FB_B_D0: UG1.H32 UG13.E3
FB_B_D1: UG1.D32 UG13.B4
FB_B_D2: UG1.A33 UG13.B3
FB_B_D3: UG1.B32 UG13.B2
FB_B_D4: UG1.E32 UG13.F2
FB_B_D5: UG1.G32 UG13.E2
FB_B_D6: UG1.J30 UG13.A3
FB_B_D7: UG1.F32 UG13.G2
FB_B_D8: UG1.H36 UG13.E13
FB_B_D9: UG1.G36 UG13.F13
FB_B_D10: UG1.J36 UG13.G13
FB_B_D11: UG1.F36 UG13.E12
FB_B_D12: UG1.F33 UG13.B12
FB_B_D13: UG1.D33 UG13.B11
FB_B_D14: UG1.J32 UG13.A12
FB_B_D15: UG1.G33 UG13.B13
FB_B_D16: UG1.E45 UG13.V12
FB_B_D17: UG1.D45 UG13.U13
FB_B_D18: UG1.F45 UG13.P12
FB_B_D19: UG1.G45 UG13.M13
FB_B_D20: UG1.D42 UG13.U12
FB_B_D21: UG1.E42 UG13.U11
FB_B_D22: UG1.F42 UG13.P13
FB_B_D23: UG1.H41 UG13.N13
FB_B_D24: UG1.E41 UG13.M2
FB_B_D25: UG1.F39 UG13.N2
FB_B_D26: UG1.E39 UG13.P3
FB_B_D27: UG1.D39 UG13.P2
FB_B_D28: UG1.F38 UG13.U4
FB_B_D29: UG1.E38 UG13.U3
FB_B_D30: UG1.D36 UG13.U2
FB_B_D31: UG1.E36 UG13.V3
FB_B_D32: UG1.M50 UG14.B3
FB_B_D33: UG1.P48 UG14.E3
FB_B_D34: UG1.M51 UG14.A3
FB_B_D35: UG1.M49 UG14.B4
FB_B_D36: UG1.P47 UG14.E2
FB_B_D37: UG1.P52 UG14.B2
FB_B_D38: UG1.R46 UG14.G2
FB_B_D39: UG1.P46 UG14.F2
FB_B_D40: UG1.L50 UG14.B12
FB_B_D41: UG1.L51 UG14.E12
FB_B_D42: UG1.L52 UG14.B11
FB_B_D43: UG1.L49 UG14.A12
FB_B_D44: UG1.M46 UG14.G13
FB_B_D45: UG1.L47 UG14.B13
FB_B_D46: UG1.M48 UG14.E13
FB_B_D47: UG1.M47 UG14.F13
FB_B_D48: UG1.D48 UG14.U12
FB_B_D49: UG1.C50 UG14.N13
FB_B_D50: UG1.C48 UG14.U13
FB_B_D51: UG1.C49 UG14.P13
FB_B_D52: UG1.E49 UG14.V12
FB_B_D53: UG1.E50 UG14.P12
FB_B_D54: UG1.F49 UG14.M13
FB_B_D55: UG1.F48 UG14.U11
FB_B_D56: UG1.F50 UG14.U2
FB_B_D57: UG1.D52 UG14.V3
FB_B_D58: UG1.J50 UG14.M2
FB_B_D59: UG1.H48 UG14.U4
FB_B_D60: UG1.H51 UG14.P2
FB_B_D61: UG1.J51 UG14.N2
FB_B_D62: UG1.H49 UG14.U3
FB_B_D63: UG1.H52 UG14.P3
FB_B_DBI0: UG1.C32 UG13.D2
FB_B_DBI1: UG1.E33 UG13.D13
FB_B_DBI2: UG1.E44 UG13.R13
FB_B_DBI3: UG1.G39 UG13.R2
FB_B_DBI4: UG1.P49 UG14.D2
FB_B_DBI5: UG1.L48 UG14.D13
FB_B_DBI6: UG1.D50 UG14.R13
FB_B_DBI7: UG1.H50 UG14.R2
FB_B_DEBUG0: RG1446.1 UG1.C35
FB_B_DEBUG1: RG1451.1 UG1.B50
FB_B_EDC0: UG1.B33 UG13.C2
FB_B_EDC1: UG1.E35 UG13.C13
FB_B_EDC2: UG1.G44 UG13.T13
FB_B_EDC3: UG1.H38 UG13.T2
FB_B_EDC4: UG1.P50 UG14.C2
FB_B_EDC5: UG1.J48 UG14.C13
FB_B_EDC6: UG1.D51 UG14.T13
FB_B_EDC7: UG1.F51 UG14.T2
FB_B_WCK01: UG1.J33 UG13.D4
FB_B_WCK23: UG1.J39 UG13.R11
FB_B_WCK45: UG1.L46 UG14.D4
FB_B_WCK67: UG1.H47 UG14.R11
FB_B_WCK#01: UG1.H33 UG13.D5
FB_B_WCK#23: UG1.H39 UG13.R10
FB_B_WCK#45: UG1.L45 UG14.D5
FB_B_WCK#67: UG1.H46 UG14.R10
FB_B_WCKB01: UG1.G35 UG13.D11
FB_B_WCKB23: UG1.F41 UG13.R4
FB_B_WCKB45: UG1.M44 UG14.D11
FB_B_WCKB67: UG1.J47 UG14.R4
FB_B_WCKB#01: UG1.H35 UG13.D10
FB_B_WCKB#23: UG1.G41 UG13.R5
FB_B_WCKB#45: UG1.M45 UG14.D10
FB_B_WCKB#67: UG1.J46 UG14.R5
FB_C_CLK0: UG1.G15 UG15.J10
FB_C_CLK1: UG1.H21 UG16.J10
FB_C_CLK#0: UG1.F15 UG15.K10
FB_C_CLK#1: UG1.J21 UG16.K10
FB_C_CMD0: UG1.C11 UG15.H3
FB_C_CMD1: UG1.B11 UG15.J3 UG15.K3
FB_C_CMD2: RG1489.2 UG1.A11 UG15.J1
FB_C_CMD3: UG1.D11 UG15.J4 UG15.K4
FB_C_CMD4: UG1.A12 UG15.L3
FB_C_CMD5: UG1.B12 UG15.M4
FB_C_CMD6: UG1.C12 UG15.J5 UG15.K5
FB_C_CMD7: UG1.C14 UG15.H5 UG15.L5
FB_C_CMD8: UG1.B14 UG15.G4
FB_C_CMD9: UG1.A14 UG15.G11
FB_C_CMD10: RG1487.2 UG1.D14 UG15.G10 UG15.M10
FB_C_CMD11: UG1.A15 UG15.H10 UG15.L10
FB_C_CMD12: UG1.B15 UG15.M11
FB_C_CMD13: UG1.C15 UG15.L12
FB_C_CMD14: UG1.C17 UG15.J11 UG15.K11
FB_C_CMD15: UG1.B17 UG15.J12 UG15.K12
FB_C_CMD16: UG1.B24 UG16.L3
FB_C_CMD17: UG1.A24 UG16.J3 UG16.K3
FB_C_CMD18: RG1490.2 UG1.D23 UG16.J1
FB_C_CMD19: UG1.A23 UG16.J4 UG16.K4
FB_C_CMD20: UG1.B23 UG16.H3
FB_C_CMD21: UG1.C23 UG16.G4
FB_C_CMD22: UG1.C21 UG16.J5 UG16.K5
FB_C_CMD23: UG1.B21 UG16.H5 UG16.L5
FB_C_CMD24: UG1.A21 UG16.M4
FB_C_CMD25: UG1.D20 UG16.M11
FB_C_CMD26: RG1488.2 UG1.A20 UG16.G10 UG16.M10
FB_C_CMD27: UG1.B20 UG16.H10 UG16.L10
FB_C_CMD28: UG1.C20 UG16.G11
FB_C_CMD29: UG1.C18 UG16.H12
FB_C_CMD30: UG1.B18 UG16.J12 UG16.K12
FB_C_CMD31: UG1.A18 UG16.J11 UG16.K11
FB_C_CMD32: UG1.A17 UG15.H12
FB_C_CMD33: UG1.D17 UG16.L12
FB_C_D0: UG1.C6 UG15.F2
FB_C_D1: UG1.D6 UG15.B4
FB_C_D2: UG1.A6 UG15.G2
FB_C_D3: UG1.B6 UG15.E2
FB_C_D4: UG1.B4 UG15.B2
FB_C_D5: UG1.A4 UG15.B3
FB_C_D6: UG1.B3 UG15.E3
FB_C_D7: UG1.C4 UG15.A3
FB_C_D8: UG1.D9 UG15.B12
FB_C_D9: UG1.C9 UG15.E13
FB_C_D10: UG1.E9 UG15.G13
FB_C_D11: UG1.B9 UG15.F13
FB_C_D12: UG1.B8 UG15.B13
FB_C_D13: UG1.A8 UG15.E12
FB_C_D14: UG1.F6 UG15.B11
FB_C_D15: UG1.E6 UG15.A12
FB_C_D16: UG1.F18 UG15.N13
FB_C_D17: UG1.G18 UG15.P12
FB_C_D18: UG1.E18 UG15.P13
FB_C_D19: UG1.H18 UG15.M13
FB_C_D20: UG1.D15 UG15.U13
FB_C_D21: UG1.E15 UG15.V12
FB_C_D22: UG1.G17 UG15.U12
FB_C_D23: UG1.H17 UG15.U11
FB_C_D24: UG1.J15 UG15.P2
FB_C_D25: UG1.H15 UG15.P3
FB_C_D26: UG1.E14 UG15.M2
FB_C_D27: UG1.F14 UG15.N2
FB_C_D28: UG1.H11 UG15.U2
FB_C_D29: UG1.G11 UG15.V3
FB_C_D30: UG1.F11 UG15.U3
FB_C_D31: UG1.E11 UG15.U4
FB_C_D32: UG1.J29 UG16.B4
FB_C_D33: UG1.F30 UG16.G2
FB_C_D34: UG1.H29 UG16.A3
FB_C_D35: UG1.G30 UG16.E3
FB_C_D36: UG1.B30 UG16.B3
FB_C_D37: UG1.A30 UG16.E2
FB_C_D38: UG1.H30 UG16.B2
FB_C_D39: UG1.C30 UG16.F2
FB_C_D40: UG1.D27 UG16.B13
FB_C_D41: UG1.J26 UG16.G13
FB_C_D42: UG1.F27 UG16.E13
FB_C_D43: UG1.G27 UG16.E12
FB_C_D44: UG1.C27 UG16.A12
FB_C_D45: UG1.B27 UG16.B12
FB_C_D46: UG1.A27 UG16.B11
FB_C_D47: UG1.G29 UG16.F13
FB_C_D48: UG1.H20 UG16.V12
FB_C_D49: UG1.D18 UG16.U12
FB_C_D50: UG1.G20 UG16.U13
FB_C_D51: UG1.E20 UG16.U11
FB_C_D52: UG1.F23 UG16.M13
FB_C_D53: UG1.E21 UG16.P12
FB_C_D54: UG1.D21 UG16.P13
FB_C_D55: UG1.E23 UG16.N13
FB_C_D56: UG1.G24 UG16.U4
FB_C_D57: UG1.H26 UG16.V3
FB_C_D58: UG1.F24 UG16.U3
FB_C_D59: UG1.G26 UG16.U2
FB_C_D60: UG1.F26 UG16.P3
FB_C_D61: UG1.D26 UG16.P2
FB_C_D62: UG1.B26 UG16.N2
FB_C_D63: UG1.C26 UG16.M2
FB_C_DBI0: UG1.A5 UG15.D2
FB_C_DBI1: UG1.C8 UG15.D13
FB_C_DBI2: UG1.J18 UG15.R13
FB_C_DBI3: UG1.F12 UG15.R2
FB_C_DBI4: UG1.D29 UG16.D2
FB_C_DBI5: UG1.E27 UG16.D13
FB_C_DBI6: UG1.F20 UG16.R13
FB_C_DBI7: UG1.E26 UG16.R2
FB_C_DEBUG0: RG1410.1 UG1.A9
FB_C_DEBUG1: RG1411.1 UG1.C24
FB_C_EDC0: UG1.D5 UG15.C2
FB_C_EDC1: UG1.D8 UG15.C13
FB_C_EDC2: UG1.E17 UG15.T13
FB_C_EDC3: UG1.E12 UG15.T2
FB_C_EDC4: UG1.E30 UG16.C2
FB_C_EDC5: UG1.B29 UG16.C13
FB_C_EDC6: UG1.G21 UG16.T13
FB_C_EDC7: UG1.E24 UG16.T2
FB_C_WCK01: UG1.F8 UG15.D4
FB_C_WCK23: UG1.H12 UG15.R11
FB_C_WCK45: UG1.J27 UG16.D4
FB_C_WCK67: UG1.G23 UG16.R11
FB_C_WCK#01: UG1.G8 UG15.D5
FB_C_WCK#23: UG1.G12 UG15.R10
FB_C_WCK#45: UG1.H27 UG16.D5
FB_C_WCK#67: UG1.H23 UG16.R10
FB_C_WCKB01: UG1.G9 UG15.D11
FB_C_WCKB23: UG1.G14 UG15.R4
FB_C_WCKB45: UG1.E29 UG16.D11
FB_C_WCKB67: UG1.H24 UG16.R4
FB_C_WCKB#01: UG1.F9 UG15.D10
FB_C_WCKB#23: UG1.H14 UG15.R5
FB_C_WCKB#45: UG1.F29 UG16.D10
FB_C_WCKB#67: UG1.J24 UG16.R5
FB_D_CLK0: UG1.Y8 UG17.J10
FB_D_CLK1: UG1.R8 UG18.J10
FB_D_CLK#0: UG1.Y7 UG17.K10
FB_D_CLK#1: UG1.R7 UG18.K10
FB_D_CMD0: UG1.AD2 UG17.H3
FB_D_CMD1: UG1.AD1 UG17.J3 UG17.K3
FB_D_CMD2: RG1493.2 UG1.AD4 UG17.J1
FB_D_CMD3: UG1.AC1 UG17.J4 UG17.K4
FB_D_CMD4: UG1.AC2 UG17.L3
FB_D_CMD5: UG1.AC3 UG17.M4
FB_D_CMD6: UG1.AA3 UG17.J5 UG17.K5
FB_D_CMD7: UG1.AA2 UG17.H5 UG17.L5
FB_D_CMD8: UG1.AA1 UG17.G4
FB_D_CMD9: UG1.AA4 UG17.G11
FB_D_CMD10: RG1491.2 UG1.Y1 UG17.G10 UG17.M10
FB_D_CMD11: UG1.Y2 UG17.H10 UG17.L10
FB_D_CMD12: UG1.Y3 UG17.M11
FB_D_CMD13: UG1.V3 UG17.L12
FB_D_CMD14: UG1.V2 UG17.J11 UG17.K11
FB_D_CMD15: UG1.V1 UG17.J12 UG17.K12
FB_D_CMD16: UG1.L3 UG18.L3
FB_D_CMD17: UG1.L2 UG18.J3 UG18.K3
FB_D_CMD18: RG1494.2 UG1.L1 UG18.J1
FB_D_CMD19: UG1.M4 UG18.J4 UG18.K4
FB_D_CMD20: UG1.M1 UG18.H3
FB_D_CMD21: UG1.M2 UG18.G4
FB_D_CMD22: UG1.M3 UG18.J5 UG18.K5
FB_D_CMD23: UG1.P3 UG18.H5 UG18.L5
FB_D_CMD24: UG1.P2 UG18.M4
FB_D_CMD25: UG1.P1 UG18.M11
FB_D_CMD26: RG1492.2 UG1.R4 UG18.G10 UG18.M10
FB_D_CMD27: UG1.R1 UG18.H10 UG18.L10
FB_D_CMD28: UG1.R2 UG18.G11
FB_D_CMD29: UG1.R3 UG18.H12
FB_D_CMD30: UG1.U3 UG18.J12 UG18.K12
FB_D_CMD31: UG1.U2 UG18.J11 UG18.K11
FB_D_CMD32: UG1.V4 UG17.H12
FB_D_CMD33: UG1.U1 UG18.L12
FB_D_D0: UG1.AK8 UG17.B4
FB_D_D1: UG1.AK4 UG17.B3
FB_D_D2: UG1.AK2 UG17.F2
FB_D_D3: UG1.AK3 UG17.B2
FB_D_D4: UG1.AK5 UG17.G2
FB_D_D5: UG1.AK6 UG17.E2
FB_D_D6: UG1.AK9 UG17.E3
FB_D_D7: UG1.AK7 UG17.A3
FB_D_D8: UG1.AG4 UG17.B12
FB_D_D9: UG1.AF9 UG17.F13
FB_D_D10: UG1.AG6 UG17.E12
FB_D_D11: UG1.AG7 UG17.G13
FB_D_D12: UG1.AJ4 UG17.B13
FB_D_D13: UG1.AJ5 UG17.B11
FB_D_D14: UG1.AJ6 UG17.A12
FB_D_D15: UG1.AG5 UG17.E13
FB_D_D16: UG1.Y6 UG17.N13
FB_D_D17: UG1.Y5 UG17.P12
FB_D_D18: UG1.V5 UG17.M13
FB_D_D19: UG1.Y4 UG17.P13
FB_D_D20: UG1.AA6 UG17.V12
FB_D_D21: UG1.AA5 UG17.U13
FB_D_D22: UG1.AC5 UG17.U11
FB_D_D23: UG1.AC4 UG17.U12
FB_D_D24: UG1.AD7 UG17.N2
FB_D_D25: UG1.AC6 UG17.P2
FB_D_D26: UG1.AF6 UG17.V3
FB_D_D27: UG1.AD6 UG17.P3
FB_D_D28: UG1.AF7 UG17.U2
FB_D_D29: UG1.AF8 UG17.M2
FB_D_D30: UG1.AF2 UG17.U4
FB_D_D31: UG1.AF3 UG17.U3
FB_D_D32: UG1.F4 UG18.B3
FB_D_D33: UG1.E1 UG18.A3
FB_D_D34: UG1.F3 UG18.E3
FB_D_D35: UG1.F5 UG18.B4
FB_D_D36: UG1.D2 UG18.F2
FB_D_D37: UG1.D1 UG18.B2
FB_D_D38: UG1.C3 UG18.G2
FB_D_D39: UG1.C2 UG18.E2
FB_D_D40: UG1.J5 UG18.A12
FB_D_D41: UG1.J4 UG18.B12
FB_D_D42: UG1.L8 UG18.B13
FB_D_D43: UG1.J2 UG18.B11
FB_D_D44: UG1.F1 UG18.F13
FB_D_D45: UG1.F2 UG18.E12
FB_D_D46: UG1.H4 UG18.E13
FB_D_D47: UG1.H5 UG18.G13
FB_D_D48: UG1.V7 UG18.U12
FB_D_D49: UG1.V8 UG18.V12
FB_D_D50: UG1.V6 UG18.U13
FB_D_D51: UG1.V9 UG18.U11
FB_D_D52: UG1.U4 UG18.P12
FB_D_D53: UG1.R5 UG18.N13
FB_D_D54: UG1.R6 UG18.M13
FB_D_D55: UG1.U8 UG18.P13
FB_D_D56: UG1.P6 UG18.U4
FB_D_D57: UG1.R9 UG18.P3
FB_D_D58: UG1.P4 UG18.U3
FB_D_D59: UG1.P5 UG18.V3
FB_D_D60: UG1.L7 UG18.U2
FB_D_D61: UG1.L6 UG18.N2
FB_D_D62: UG1.L4 UG18.P2
FB_D_D63: UG1.L5 UG18.M2
FB_D_DBI0: UG1.AJ1 UG17.D2
FB_D_DBI1: UG1.AG1 UG17.D13
FB_D_DBI2: UG1.AA7 UG17.R13
FB_D_DBI3: UG1.AD5 UG17.R2
FB_D_DBI4: UG1.D3 UG18.D2
FB_D_DBI5: UG1.H3 UG18.D13
FB_D_DBI6: UG1.U5 UG18.R13
FB_D_DBI7: UG1.M9 UG18.R2
FB_D_DEBUG0: RG1412.1 UG1.AD3
FB_D_DEBUG1: RG1413.1 UG1.J3
FB_D_EDC0: UG1.AJ3 UG17.C2
FB_D_EDC1: UG1.AG2 UG17.C13
FB_D_EDC2: UG1.AA9 UG17.T13
FB_D_EDC3: UG1.AF4 UG17.T2
FB_D_EDC4: UG1.E3 UG18.C2
FB_D_EDC5: UG1.H2 UG18.C13
FB_D_EDC6: UG1.U6 UG18.T13
FB_D_EDC7: UG1.M5 UG18.T2
FB_D_WCK01: UG1.AJ8 UG17.D4
FB_D_WCK23: UG1.AD8 UG17.R11
FB_D_WCK45: UG1.J6 UG18.D4
FB_D_WCK67: UG1.P8 UG18.R11
FB_D_WCK#01: UG1.AJ7 UG17.D5
FB_D_WCK#23: UG1.AD9 UG17.R10
FB_D_WCK#45: UG1.J7 UG18.D5
FB_D_WCK#67: UG1.P7 UG18.R10
FB_D_WCKB01: UG1.AG8 UG17.D11
FB_D_WCKB23: UG1.AC7 UG17.R4
FB_D_WCKB45: UG1.H7 UG18.D11
FB_D_WCKB67: UG1.M7 UG18.R4
FB_D_WCKB#01: UG1.AG9 UG17.D10
FB_D_WCKB#23: UG1.AC8 UG17.R5
FB_D_WCKB#45: UG1.H6 UG18.D10
FB_D_WCKB#67: UG1.M8 UG18.R5
FB_FBVDDQ: PCW42.2 PCW44.2 PRW19.1 PRW20.1 PRW56.1 PUW1.10
FB_GND_SENSE: PRW9.2 RG7.2
FB_VCCIO: PRH9.1 PRH17.2 PRH20.1 PUH2.11
FB_VDDQ_SENSE: PRW13.2 RG35.2
FB_VDDQ_SENSE_R: RG35.1 UG1.E52
FB_VREF: CG6826.1 RG59.1 UG1.P45
FBCAL_GND: RG68.1 UG1.P44
FBCAL_TERM: RG69.1 UG1.R45
FBCAL_VDDQ: RG67.1 UG1.R44
FBRTN: PCV6.1 PCV13.1 PCV20.2 PRV6.2 PRV28.1 PRV39.1 PUV1.32
FBRTN_FBVDDQ: PCW12.2 PRW6.1 PRW9.1 PUW1.9
FBVDD/Q_EN: CG7095.1 PQW1.2 PRW15.2 QG523.2 RG557.1 RG1513.2 UG27.4
FBVDDQ_PH2: PLW02.1 PRW45.1 PUW3.11 PUW3.12
FBVDDQ_SNB1: PCW23.1 PRW35.2
FBVDDQ_VIN: PCW14.1 PCW17.1 PCW18.1 PCW19.1 PCW20.1 PCW25.1 PCW29.1 PCW32.1 PCW33.1 PCW34.1 PCW35.1 PCW36.1 PCW39.1 PCW40.1 PLW11.2 PUW2.8 PUW2.9 PUW3.8 PUW3.9
FP_FUSE: RG528.1 RG1558.2 UG1.BE7 UG9.3
FP_FUSE_GPU: CG7117.2 RG1559.2 UG1.BD14 UG9.1 UG9.2
FRWPG: PRV99.2 PRV102.1 PRV199.2 PUV3.24
FS_FBVDDQ: PRW30.1 PRW32.2 PUW1.8
FSET_CHG: PRB24.1 PUB1.12
GC6_EVENT#: DG2.1 UH1.BB26
GC6_EVENT#_D: DG2.2 RG8.1 UG1.BD1
GC6_FB_EN: QG511.1 RG561.2 UH1.BF29
GPD_7: RH11.1 RH594.2 UH1.BE41
GPIO8: RT124.2 RT125.1 UT4.H6
GPP_H12: RH100.2 UH1.AB47
GPP_H15: RH99.1 UH1.AC47
GPP_J9: RH218.1 UH1.AU9
GPPJ_RCOMP_1P8: RH216.1 UH1.BD1 UH1.BE1 UH1.BE2
GPU_B+: PCW21.1 PCW24.1 PLW11.1 PRV108.1 PRV109.4 PRW33.1
GPU_BUFRST#: T6.1(TP-1) UG1.BF9
GPU_DP_AUXN: RV618.1 RV665.1 UG1.BL8 UV3.6 UV3.13
GPU_DP_AUXN_C: CV25.1 UV3.5
GPU_DP_AUXN_R: CV25.2 RV618.2
GPU_DP_AUXP: RV619.1 RV664.1 UG1.BK8 UV3.3 UV3.10
GPU_DP_AUXP_C: CV24.1 UV3.2
GPU_DP_AUXP_R: CV24.2 RV619.2
GPU_DP_HPD#: QV97.3 RX5.2 UG1.BE3
GPU_DP_HPD_R: CX1.1 JDP.2 RX2.2
GPU_DP_N0: CV27.1 UG1.BG17
GPU_DP_N0_C: CV27.2 JDP.5
GPU_DP_N1: CV30.1 UG1.BF15
GPU_DP_N1_C: CV30.2 JDP.11
GPU_DP_N2: CV33.1 UG1.BF14
GPU_DP_N2_C: CV33.2 JDP.17
GPU_DP_N3: CV31.1 UG1.BG14
GPU_DP_N3_C: CV31.2 JDP.12
GPU_DP_P0: CV26.1 UG1.BH17
GPU_DP_P0_C: CV26.2 JDP.3
GPU_DP_P1: CV28.1 UG1.BG15
GPU_DP_P1_C: CV28.2 JDP.9
GPU_DP_P2: CV32.1 UG1.BE14
GPU_DP_P2_C: CV32.2 JDP.15
GPU_DP_P3: CV29.1 UG1.BH14
GPU_DP_P3_C: CV29.2 JDP.10
GPU_DRVON: PQV1.3 PRV51.1 PRV121.1 PRV123.1 PRV138.1 PRV149.1 PRV160.1 PRV171.1 PRV182.1 PRV183.1 PUV1.36
GPU_FAN_FB: DF2.2 RF4.1 UE5.N11
GPU_FAN_PWM: JFAN2.2 RF5.1 UE5.N10
GPU_FBVDD_PSI: RG1581.1 RG1582.2 RG1583.1 RG1596.2 UG1.BB2
GPU_GC6_FB_EN: QG511.3 RG22.1 RG553.1 UG1.BB5 UG27.1 UG41.1 UG44.2
GPU_GC6_FB_FGC6_EN: CG7090.1 RG1511.2 UG39.2 UG43.1
GPU_HDMI_CLKN: CV1057.2 UG1.BF17
GPU_HDMI_CLKP: CV1058.2 UG1.BE17
GPU_HDMI_CTRL_CLK: QV96.4 RV648.2 UG1.BK9
GPU_HDMI_CTRL_DAT: QV96.1 RV652.2 UG1.BL9
GPU_HDMI_HPD#: QV97.6 RX7.2 UG1.BA4
GPU_HDMI_TX_N0: CV1060.2 UG1.BF18
GPU_HDMI_TX_N1: CV1062.2 UG1.BG20
GPU_HDMI_TX_N2: CV1064.2 UG1.BF20
GPU_HDMI_TX_P0: CV1059.2 UG1.BG18
GPU_HDMI_TX_P1: CV1061.2 UG1.BH20
GPU_HDMI_TX_P2: CV1063.2 UG1.BE20
GPU_NVVDD_PSI#: RG15.1 RG1578.2 RG1579.1 RG1595.2 UG1.BD2
GPU_OVERT#: DG3.1 QG521.3 RG534.2 UE5.E5 UG23.6
GPU_PWM1: PRV61.1 PUV1.11 PUV4.1
GPU_PWM2: PRV70.1 PUV1.10 PUV5.1
GPU_PWM3: PRV77.1 PUV1.9 PUV6.1
GPU_PWM4: PRV74.1 PUV1.8 PUV7.1
GPU_PWM5: PRV76.1 PUV1.7 PUV9.1
GPU_PWM6: PRV78.1 PUV1.6 PUV8.1
GPU_PWM7: PRV200.1 PUV1.5 PUV10.1
GPU_PWM8: PRV201.1 PUV1.4 PUV11.1
GPU_STRAP5_EC: QG516.2 RE689.2 UE5.F10
GSYNC_ID: RH29.1 RH30.1 UH1.BE17
GT_SW1: PLG01.1 PRG04.1 PUG01.11 PUG01.12
H_CATERR#: RC693.2 UC1.BM30
H_CPUPWRGD: CH194.1 UC1.BT31 UH1.AE3
H_DRAMRST#: DT16.1 RD31.2 RD35.2 UH1.BB46
H_PECI: RH73.2 RH1022.2 UC1.BT34
H_PM_DOWN: RH14.1 RH155.1 UH1.AE2
H_PM_SYNC: RH15.2 UC1.BM34
H_PM_SYNC_R: RH15.1 UH1.AF3
H_PROCHOT#: PCB35.1 PQ5.1 PR34.2 PRB17.1 PRZ28.2 PRZ73.2 QE2.1 RH158.1 RH165.2
H_THERMTRIP#: RH79.2 RH163.2 UC1.J31
H_THERMTRIP#_R: RH79.1 UH1.AD3
H_VCCST_PWRGD: CH193.1 Q7.3 RH154.1 RH164.2 UE5.K1
HDA_BIT_CLK: RH1031.2 UH1.BD11
HDA_BIT_CLK_R: CH245.1 JIO1.C4 RH1031.1
HDA_RST#: RP2.6 UH1.BE10
HDA_RST#_R: JIO1.F3 RP2.3
HDA_SDIN: JIO1.H1 UH1.BE11
HDA_SDOUT: RH16.2 RP2.8 UH1.BF12
HDA_SDOUT_R: JIO1.F1 RP2.1
HDA_SPKR: JIO1.F4 RH600.1 UH1.AW29
HDA_SYNC: RP2.7 UH1.BG13
HDA_SYNC_R: JIO1.C3 RP2.2
HDMI_C_CLKN: CV1057.1 LV3.1 RV641.1 RX33.1
HDMI_C_CLKP: CV1058.1 LV3.4 RV640.1 RX34.1
HDMI_C_TX_N0: CV1060.1 LV4.1 RV643.1 RX31.1
HDMI_C_TX_N1: CV1062.1 LV5.1 RV642.1 RX35.1
HDMI_C_TX_N2: CV1064.1 LV6.1 RV645.1 RX37.1
HDMI_C_TX_P0: CV1059.1 LV4.4 RV646.1 RX32.1
HDMI_C_TX_P1: CV1061.1 LV5.4 RV639.1 RX36.1
