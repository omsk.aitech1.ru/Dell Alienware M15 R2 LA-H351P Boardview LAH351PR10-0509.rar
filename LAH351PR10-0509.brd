# Allegro board LAH351PR10-0509.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CVILU_CF5020FD0RK-05-NH_20P
  oval 0.305x0.94 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.651x1.397 smd: 21(-2.325,-3.375) 22(11.825,-3.375)
CVILU_CH51102M100-0P_10P-T
  oval 0.762x2.388 smd: 1(0,0) 2(0,3.9) 3(1.27,0) 4(1.27,3.9) 5(2.54,0) 6(2.54,3.9) 7(3.81,0) 8(3.81,3.9) 9(5.08,0) 10(5.08,3.9)
CVILU_CI4204M2HR0-NH_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.925) 6(6.6,-4.925)
CYNTE_PCMB042T-1R0MS_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CYNTE_PCMB103T-3R3MS_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DS80PCI402SQNOPB_WQFN54_10X5P5
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 28(8.5,5.6) 29(8,5.6) 30(7.5,5.6) 31(7,5.6) 32(6.5,5.6) 33(6,5.6) 34(5.5,5.6) 35(5,5.6) 36(4.5,5.6) 37(4,5.6) 38(3.5,5.6) 39(3,5.6) 40(2.5,5.6) 41(2,5.6) 42(1.5,5.6) 43(1,5.6) 44(0.5,5.6) 45(0,5.6)
  oval 0.889x0.254 smd: 19(9.3,0.8) 20(9.3,1.3) 21(9.3,1.8) 22(9.3,2.3) 23(9.3,2.8) 24(9.3,3.3) 25(9.3,3.8) 26(9.3,4.3) 27(9.3,4.8) 46(-0.8,4.8) 47(-0.8,4.3) 48(-0.8,3.8) 49(-0.8,3.3) 50(-0.8,2.8) 51(-0.8,2.3) 52(-0.8,1.8) 53(-0.8,1.3) 54(-0.8,0.8)
  rect 7.493x3.505 smd: 55(4.25,2.8)
EN25F80-75HCP_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
F75305M_MSOP10
  oval 0.254x1.626 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,4.3) 7(1.5,4.3) 8(1,4.3) 9(0.5,4.3) 10(0,4.3)
  rect 1.6x1.727 smd: 11(1,2.15)
F_SMD1812P150TF-24
  rect 1.778x3.15 smd: 1(0,0) 2(5.23,0)
F_SPR-P110
  rect 0.991x1.499 smd: 1(0,0) 2(2.2,0)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G517AH1TP1U_TSOT23-6
  oval 0.508x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0.95,3) 6(0,3)
GS7616SC-R_SOT363-6
  oval 0.457x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
H_1P8
  round 2.311 hole 1.803: 1(0,0)
H_2P6-G
  round 3.099 hole 2.591: 1(0,0)
H_3P7-G
  round 4.216 hole 3.708: 1(0,0)
H_4P0
  round 4.496 hole 3.988: 1(0,0)
H_4P0-G
  round 4.496 hole 3.988: 1(0,0)
H_4P3X3P7-G
  oval 4.801x4.216 hole 4.293x3.708: 1(0,0)
HRS_DF52-6S-0P8H-21_6P-T
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0)
  rect 0.889x1.6 smd: 7(-1.25,-1.92) 8(5.25,-1.92)
INPAQ_HCM1012GH900BP_4P-NPM
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INTEL_CMC_PRIMARY_36P-T
  round 0.889 hole 0.889 unplated: (-0.876,-0.658) (0.774,-6.054)
  round 0.368 smd: 1(0,0) 2(0.477,-0.275) 3(0.885,0.093) 4(1.268,-0.302) 5(1.763,-0.062) 6(2.021,-0.547) 7(2.563,-0.452) 8(2.677,-0.99) 9(3.224,-1.048) 10(3.186,-1.596) 11(3.696,-1.803) 12(3.509,-2.32) 13(3.942,-2.659) 14(3.619,-3.104) 15(3.942,-3.549) 16(3.509,-3.888) 17(3.696,-4.405) 18(3.186,-4.611) 19(3.224,-5.16) 20(2.677,-5.218) 21(2.563,-5.756) 22(2.021,-5.661) 23(-0.491,-5.652) 24(-1.034,-5.743) 25(-1.145,-5.205) 26(-1.691,-5.143) 27(-1.649,-4.595) 28(-2.157,-4.385) 29(-1.966,-3.869) 30(-2.397,-3.527) 31(-2.071,-3.084) 32(-2.391,-2.637) 33(-1.955,-2.301) 34(-2.139,-1.782) 35(-1.631,-1.578)
  round 4.597 hole 2.286: 36(0.774,-3.104)
ISL88739AHRZ-T_QFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.642x2.642 smd: 33(2.05,-1.4)
ISL95338HRTZ-T_TQFN32_4X4
  oval 0.94x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.254x0.94 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.642x2.642 smd: 33(2.05,-1.4)
JAE_DX07SA24XJ2R1000_24P
  round 0.762 hole 0.762 unplated: (-0.85,-0.66)
  oval 0.94x0.762 hole 0.94x0.762 unplated: (6.35,-0.66)
  custom 0.275x0.275 hole 0.61x1.6: 1(-1.85,-5.06) 2(7.35,-5.06)
  oval 1.092x2.108 hole 0.61x1.6: 3(-1.85,-2.06) 4(7.35,-2.06)
  oval 0.305x1.092 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  round 0.61 hole 0.406: B1(5.55,-1.31) B2(5.15,-2.01) B3(4.35,-2.01) B4(3.95,-1.31) B5(3.55,-2.01) B6(3.15,-1.31) B7(2.35,-1.31) B8(1.95,-2.01) B9(1.55,-1.31) B10(1.15,-2.01) B11(0.35,-2.01) B12(-0.05,-1.31)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X39-NPM
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X79-NPM
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
K4A8G165WB-BCPB_FBGA_96P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P7(4.801,-10.401) P8(5.601,-10.401) P9(6.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R7(4.801,-11.201) R8(5.601,-11.201) R9(6.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T7(4.801,-12.002) T8(5.601,-12.002) T9(6.401,-12.002)
KB9542G-B_VFBGA_124P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) A12(5.501,0) A13(6.002,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) B12(5.501,-0.5) B13(6.002,-0.5) C1(0,-1) C2(0.5,-1) C12(5.501,-1) C13(6.002,-1) D1(0,-1.5) D2(0.5,-1.5) D4(1.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D9(4.001,-1.5) D10(4.501,-1.5) D12(5.501,-1.5) D13(6.002,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E7(3.001,-2.001) E9(4.001,-2.001) E10(4.501,-2.001) E12(5.501,-2.001) E13(6.002,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F9(4.001,-2.501) F10(4.501,-2.501) F12(5.501,-2.501) F13(6.002,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G9(4.001,-3.001) G10(4.501,-3.001) G12(5.501,-3.001) G13(6.002,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H9(4.001,-3.501) H10(4.501,-3.501) H12(5.501,-3.501) H13(6.002,-3.501) J1(0,-4.001) J2(0.5,-4.001) J4(1.5,-4.001) J5(2.001,-4.001) J7(3.001,-4.001) J9(4.001,-4.001) J10(4.501,-4.001) J12(5.501,-4.001) J13(6.002,-4.001) K1(0,-4.501) K2(0.5,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K12(5.501,-4.501) K13(6.002,-4.501) L1(0,-5.001) L2(0.5,-5.001) L12(5.501,-5.001) L13(6.002,-5.001) M1(0,-5.501) M2(0.5,-5.501) M3(1,-5.501) M4(1.5,-5.501) M5(2.001,-5.501) M6(2.501,-5.501) M7(3.001,-5.501) M8(3.501,-5.501) M9(4.001,-5.501) M10(4.501,-5.501) M11(5.001,-5.501) M12(5.501,-5.501) M13(6.002,-5.501) N1(0,-6.002) N2(0.5,-6.002) N3(1,-6.002) N4(1.5,-6.002) N5(2.001,-6.002) N6(2.501,-6.002) N7(3.001,-6.002) N8(3.501,-6.002) N9(4.001,-6.002) N10(4.501,-6.002) N11(5.001,-6.002) N12(5.501,-6.002) N13(6.002,-6.002)
KC3810NF-A0_QFN24_4X4
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 13(4.1,-2.5) 14(4.1,-2) 15(4.1,-1.5) 16(4.1,-1) 17(4.1,-0.5) 18(4.1,0)
  oval 0.254x0.889 smd: 7(0.8,-3.3) 8(1.3,-3.3) 9(1.8,-3.3) 10(2.3,-3.3) 11(2.8,-3.3) 12(3.3,-3.3) 19(3.3,0.8) 20(2.8,0.8) 21(2.3,0.8) 22(1.8,0.8) 23(1.3,0.8) 24(0.8,0.8)
  rect 2.438x2.438 smd: 25(2.05,-1.25)
KC_FBMA-L11-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
L2N7002DW1T1G_SC88-6
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
LBSS138LT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LBSS139DW1T1G_SOT363-6
  oval 0.305x0.66 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.84) 5(0.65,1.84) 6(0,1.84)
LMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
LMUN5113T1G_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
LOTES_YPCI0020-P001A_75P-T
  round 1.092 hole 1.092 unplated: (-20.25,0.5)
  round 1.6 hole 1.6 unplated: (1.75,0.5)
  round 0.762 hole 0.508: 1(0,0) 3(-0.5,-0.8) 5(-1,0) 7(-1.5,-0.8) 9(-2,0) 11(-2.5,-0.8) 13(-3,0) 15(-3.5,-0.8) 17(-4,0) 19(-4.5,-0.8) 21(-5,0) 23(-5.5,-0.8) 25(-6,0) 27(-6.5,-0.8) 29(-7,0) 31(-7.5,-0.8) 33(-8,0) 35(-8.5,-0.8) 37(-9,0) 39(-9.5,-0.8) 41(-10,0) 43(-10.5,-0.8) 45(-11,0) 47(-11.5,-0.8) 49(-12,0) 51(-12.5,-0.8) 53(-13,0) 55(-13.5,-0.8) 57(-14,0) 67(-16.5,-0.8) 69(-17,0) 71(-17.5,-0.8) 73(-18,0) 75(-18.5,-0.8)
  oval 0.305x1.499 smd: 2(-0.25,2.05) 4(-0.75,2.05) 6(-1.25,2.05) 8(-1.75,2.05) 10(-2.25,2.05) 12(-2.75,2.05) 14(-3.25,2.05) 16(-3.75,2.05) 18(-4.25,2.05) 20(-4.75,2.05) 22(-5.25,2.05) 24(-5.75,2.05) 26(-6.25,2.05) 28(-6.75,2.05) 30(-7.25,2.05) 32(-7.75,2.05) 34(-8.25,2.05) 36(-8.75,2.05) 38(-9.25,2.05) 40(-9.75,2.05) 42(-10.25,2.05) 44(-10.75,2.05) 46(-11.25,2.05) 48(-11.75,2.05) 50(-12.25,2.05) 52(-12.75,2.05) 54(-13.25,2.05) 56(-13.75,2.05) 58(-14.25,2.05) 68(-16.75,2.05) 70(-17.25,2.05) 72(-17.75,2.05) 74(-18.25,2.05)
  rect 1.194x2.743 smd: 76(-20.635,-4.47) 77(2.135,-4.47)
LTC015EUBFS8TL_UMT3F
  oval 0.787x0.889 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MAG_MLD-06CZH1R0M-N1L_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
MAG_MMD-05BD-R68M-R1L_4P
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
MAG_MMD-06CZ-1R5M-V1_2P
  rect 2.134x3.429 smd: 1(0,0) 2(5.855,0)
MAG_MND-04ABIR60M-XGL_2P
  rect 1.448x3.708 smd: 1(0,0) 2(2.845,0)
MAG_SLA-05AHN2R2MX2L_2P
  rect 1.905x2.489 smd: 1(0,0) 2(4.095,0)
MESS138W-G_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
MMBT3904WH_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MT61K256M32JE-13-A_FBGA_180P
  round 0.343 smd: A1(0,0) A2(0.75,0) A3(1.5,0) A4(2.249,0) A5(2.999,0) A10(6.748,0) A11(7.498,0) A12(8.248,0) A13(8.998,0) A14(9.748,0) B1(0,-0.75) B2(0.75,-0.75) B3(1.5,-0.75) B4(2.249,-0.75) B5(2.999,-0.75) B10(6.748,-0.75) B11(7.498,-0.75) B12(8.248,-0.75) B13(8.998,-0.75) B14(9.748,-0.75) C1(0,-1.5) C2(0.75,-1.5) C3(1.5,-1.5) C4(2.249,-1.5) C5(2.999,-1.5) C10(6.748,-1.5) C11(7.498,-1.5) C12(8.248,-1.5) C13(8.998,-1.5) C14(9.748,-1.5) D1(0,-2.249) D2(0.75,-2.249) D3(1.5,-2.249) D4(2.249,-2.249) D5(2.999,-2.249) D10(6.748,-2.249) D11(7.498,-2.249) D12(8.248,-2.249) D13(8.998,-2.249) D14(9.748,-2.249) E1(0,-2.999) E2(0.75,-2.999) E3(1.5,-2.999) E4(2.249,-2.999) E5(2.999,-2.999) E10(6.748,-2.999) E11(7.498,-2.999) E12(8.248,-2.999) E13(8.998,-2.999) E14(9.748,-2.999) F1(0,-3.749) F2(0.75,-3.749) F3(1.5,-3.749) F4(2.249,-3.749) F5(2.999,-3.749) F10(6.748,-3.749) F11(7.498,-3.749) F12(8.248,-3.749) F13(8.998,-3.749) F14(9.748,-3.749) G1(0,-4.499) G2(0.75,-4.499) G3(1.5,-4.499) G4(2.249,-4.499) G5(2.999,-4.499) G10(6.748,-4.499) G11(7.498,-4.499) G12(8.248,-4.499) G13(8.998,-4.499) G14(9.748,-4.499) H1(0,-5.249) H2(0.75,-5.249) H3(1.5,-5.249) H4(2.249,-5.249) H5(2.999,-5.249) H10(6.748,-5.249) H11(7.498,-5.249) H12(8.248,-5.249) H13(8.998,-5.249) H14(9.748,-5.249) J1(0,-5.998) J2(0.75,-5.998) J3(1.5,-5.998) J4(2.249,-5.998) J5(2.999,-5.998) J10(6.748,-5.998) J11(7.498,-5.998) J12(8.248,-5.998) J13(8.998,-5.998) J14(9.748,-5.998) K1(0,-6.748) K2(0.75,-6.748) K3(1.5,-6.748) K4(2.249,-6.748) K5(2.999,-6.748) K10(6.748,-6.748) K11(7.498,-6.748) K12(8.248,-6.748) K13(8.998,-6.748) K14(9.748,-6.748) L1(0,-7.498) L2(0.75,-7.498) L3(1.5,-7.498) L4(2.249,-7.498) L5(2.999,-7.498) L10(6.748,-7.498) L11(7.498,-7.498) L12(8.248,-7.498) L13(8.998,-7.498) L14(9.748,-7.498) M1(0,-8.248) M2(0.75,-8.248) M3(1.5,-8.248) M4(2.249,-8.248) M5(2.999,-8.248) M10(6.748,-8.248) M11(7.498,-8.248) M12(8.248,-8.248) M13(8.998,-8.248) M14(9.748,-8.248) N1(0,-8.998) N2(0.75,-8.998) N3(1.5,-8.998) N4(2.249,-8.998) N5(2.999,-8.998) N10(6.748,-8.998) N11(7.498,-8.998) N12(8.248,-8.998) N13(8.998,-8.998) N14(9.748,-8.998) P1(0,-9.748) P2(0.75,-9.748) P3(1.5,-9.748) P4(2.249,-9.748) P5(2.999,-9.748) P10(6.748,-9.748) P11(7.498,-9.748) P12(8.248,-9.748) P13(8.998,-9.748) P14(9.748,-9.748) R1(0,-10.497) R2(0.75,-10.497) R3(1.5,-10.497) R4(2.249,-10.497) R5(2.999,-10.497) R10(6.748,-10.497) R11(7.498,-10.497) R12(8.248,-10.497) R13(8.998,-10.497) R14(9.748,-10.497) T1(0,-11.247) T2(0.75,-11.247) T3(1.5,-11.247) T4(2.249,-11.247) T5(2.999,-11.247) T10(6.748,-11.247) T11(7.498,-11.247) T12(8.248,-11.247) T13(8.998,-11.247) T14(9.748,-11.247) U1(0,-11.997) U2(0.75,-11.997) U3(1.5,-11.997) U4(2.249,-11.997) U5(2.999,-11.997) U10(6.748,-11.997) U11(7.498,-11.997) U12(8.248,-11.997) U13(8.998,-11.997) U14(9.748,-11.997) V1(0,-12.747) V2(0.75,-12.747) V3(1.5,-12.747) V4(2.249,-12.747) V5(2.999,-12.747) V10(6.748,-12.747) V11(7.498,-12.747) V12(8.248,-12.747) V13(8.998,-12.747) V14(9.748,-12.747)
MURAT_BLM15AG121SN1D_L0402_2P
  rect 0.457x0.711 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15AX601SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_DLM0NSN900HY2D_4P
  rect 0.305x0.305 smd: 1(0,0) 2(0.6,0) 3(0.6,-0.5) 4(0,-0.5)
MURAT_LQM18PN1R0MFHD_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
N18E-G3-ES-A1_FCBGA_2228P
  round 0.33 smd: A2(0.7,0) A3(1.4,0) A50(34.301,0) A51(35.001,0) B1(0,-0.7) B2(0.7,-0.7) B3(1.4,-0.7) B50(34.301,-0.7) B51(35.001,-0.7) B52(35.701,-0.7) BK1(0,-34.301) BK2(0.7,-34.301) BK3(1.4,-34.301) BK50(34.301,-34.301) BK51(35.001,-34.301) BK52(35.701,-34.301) BL1(0,-35.001) BL2(0.7,-35.001) BL3(1.4,-35.001) BL50(34.301,-35.001) BL51(35.001,-35.001) BL52(35.701,-35.001) BM2(0.7,-35.701) BM3(1.4,-35.701) BM50(34.301,-35.701) BM51(35.001,-35.701) C1(0,-1.4) C2(0.7,-1.4) C3(1.4,-1.4) C50(34.301,-1.4) C51(35.001,-1.4) C52(35.701,-1.4)
  round 0.305 smd: A4(2.1,0) A5(2.8,0) A6(3.5,0) A8(4.9,0) A9(5.6,0) A11(7,0) A12(7.7,0) A14(9.1,0) A15(9.8,0) A17(11.2,0) A18(11.9,0) A20(13.3,0) A21(14,0) A23(15.401,0) A24(16.101,0) A26(17.501,0) A27(18.201,0) A29(19.601,0) A30(20.301,0) A32(21.701,0) A33(22.401,0) A35(23.801,0) A36(24.501,0) A38(25.901,0) A39(26.601,0) A41(28.001,0) A42(28.701,0) A44(30.101,0) A45(30.801,0) A47(32.201,0) A48(32.901,0) A49(33.601,0) AA1(0,-14) AA2(0.7,-14) AA3(1.4,-14) AA4(2.1,-14) AA5(2.8,-14) AA6(3.5,-14) AA7(4.2,-14) AA8(4.9,-14) AA9(5.6,-14) AA10(6.3,-14) AA11(7,-14) AA13(8.4,-14) AA14(9.1,-14) AA15(9.8,-14) AA16(10.5,-14) AA17(11.2,-14) AA18(11.9,-14) AA19(12.6,-14) AA20(13.3,-14) AA21(14,-14) AA22(14.701,-14) AA23(15.401,-14) AA24(16.101,-14) AA25(16.801,-14) AA26(17.501,-14) AA27(18.201,-14) AA28(18.901,-14) AA29(19.601,-14) AA30(20.301,-14) AA31(21.001,-14) AA32(21.701,-14) AA33(22.401,-14) AA34(23.101,-14) AA35(23.801,-14) AA36(24.501,-14) AA37(25.201,-14) AA38(25.901,-14) AA39(26.601,-14) AA40(27.301,-14) AA42(28.701,-14) AA43(29.401,-14) AA44(30.101,-14) AA45(30.801,-14) AA46(31.501,-14) AA47(32.201,-14) AA48(32.901,-14) AA49(33.601,-14) AA50(34.301,-14) AA51(35.001,-14) AA52(35.701,-14) AB2(0.7,-14.701) AB4(2.1,-14.701) AB6(3.5,-14.701) AB8(4.9,-14.701) AB10(6.3,-14.701) AB13(8.4,-14.701) AB14(9.1,-14.701) AB15(9.8,-14.701) AB16(10.5,-14.701) AB17(11.2,-14.701) AB18(11.9,-14.701) AB19(12.6,-14.701) AB20(13.3,-14.701) AB21(14,-14.701) AB22(14.701,-14.701) AB23(15.401,-14.701) AB24(16.101,-14.701) AB25(16.801,-14.701) AB26(17.501,-14.701) AB27(18.201,-14.701) AB28(18.901,-14.701) AB29(19.601,-14.701) AB30(20.301,-14.701) AB31(21.001,-14.701) AB32(21.701,-14.701) AB33(22.401,-14.701) AB34(23.101,-14.701) AB35(23.801,-14.701) AB36(24.501,-14.701) AB37(25.201,-14.701) AB38(25.901,-14.701) AB39(26.601,-14.701) AB40(27.301,-14.701) AB43(29.401,-14.701) AB45(30.801,-14.701) AB47(32.201,-14.701) AB49(33.601,-14.701) AB51(35.001,-14.701) AC1(0,-15.401) AC2(0.7,-15.401) AC3(1.4,-15.401) AC4(2.1,-15.401) AC5(2.8,-15.401) AC6(3.5,-15.401) AC7(4.2,-15.401) AC8(4.9,-15.401) AC9(5.6,-15.401) AC10(6.3,-15.401) AC11(7,-15.401) AC13(8.4,-15.401) AC14(9.1,-15.401) AC15(9.8,-15.401) AC16(10.5,-15.401) AC17(11.2,-15.401) AC18(11.9,-15.401) AC19(12.6,-15.401) AC20(13.3,-15.401) AC21(14,-15.401) AC22(14.701,-15.401) AC23(15.401,-15.401) AC24(16.101,-15.401) AC25(16.801,-15.401) AC26(17.501,-15.401) AC27(18.201,-15.401) AC28(18.901,-15.401) AC29(19.601,-15.401) AC30(20.301,-15.401) AC31(21.001,-15.401) AC32(21.701,-15.401) AC33(22.401,-15.401) AC34(23.101,-15.401) AC35(23.801,-15.401) AC36(24.501,-15.401) AC37(25.201,-15.401) AC38(25.901,-15.401) AC39(26.601,-15.401) AC40(27.301,-15.401) AC42(28.701,-15.401) AC43(29.401,-15.401) AC44(30.101,-15.401) AC45(30.801,-15.401) AC46(31.501,-15.401) AC47(32.201,-15.401) AC48(32.901,-15.401) AC49(33.601,-15.401) AC50(34.301,-15.401) AC51(35.001,-15.401) AC52(35.701,-15.401) AD1(0,-16.101) AD2(0.7,-16.101) AD3(1.4,-16.101) AD4(2.1,-16.101) AD5(2.8,-16.101) AD6(3.5,-16.101) AD7(4.2,-16.101) AD8(4.9,-16.101) AD9(5.6,-16.101) AD10(6.3,-16.101) AD11(7,-16.101) AD13(8.4,-16.101) AD14(9.1,-16.101) AD15(9.8,-16.101) AD16(10.5,-16.101) AD17(11.2,-16.101) AD18(11.9,-16.101) AD19(12.6,-16.101) AD20(13.3,-16.101) AD21(14,-16.101) AD22(14.701,-16.101) AD23(15.401,-16.101) AD24(16.101,-16.101) AD25(16.801,-16.101) AD26(17.501,-16.101) AD27(18.201,-16.101) AD28(18.901,-16.101) AD29(19.601,-16.101) AD30(20.301,-16.101) AD31(21.001,-16.101) AD32(21.701,-16.101) AD33(22.401,-16.101) AD34(23.101,-16.101) AD35(23.801,-16.101) AD36(24.501,-16.101) AD37(25.201,-16.101) AD38(25.901,-16.101) AD39(26.601,-16.101) AD40(27.301,-16.101) AD42(28.701,-16.101) AD43(29.401,-16.101) AD44(30.101,-16.101) AD45(30.801,-16.101) AD46(31.501,-16.101) AD47(32.201,-16.101) AD48(32.901,-16.101) AD49(33.601,-16.101) AD50(34.301,-16.101) AD51(35.001,-16.101) AD52(35.701,-16.101) AE2(0.7,-16.801) AE4(2.1,-16.801) AE6(3.5,-16.801) AE8(4.9,-16.801) AE10(6.3,-16.801) AE13(8.4,-16.801) AE14(9.1,-16.801) AE15(9.8,-16.801) AE16(10.5,-16.801) AE17(11.2,-16.801) AE18(11.9,-16.801) AE19(12.6,-16.801) AE20(13.3,-16.801) AE21(14,-16.801) AE22(14.701,-16.801) AE23(15.401,-16.801) AE24(16.101,-16.801) AE25(16.801,-16.801) AE26(17.501,-16.801) AE27(18.201,-16.801) AE28(18.901,-16.801) AE29(19.601,-16.801) AE30(20.301,-16.801) AE31(21.001,-16.801) AE32(21.701,-16.801) AE33(22.401,-16.801) AE34(23.101,-16.801) AE35(23.801,-16.801) AE36(24.501,-16.801) AE37(25.201,-16.801) AE38(25.901,-16.801) AE39(26.601,-16.801) AE40(27.301,-16.801) AE43(29.401,-16.801) AE45(30.801,-16.801) AE47(32.201,-16.801) AE49(33.601,-16.801) AE51(35.001,-16.801) AF1(0,-17.501) AF2(0.7,-17.501) AF3(1.4,-17.501) AF4(2.1,-17.501) AF5(2.8,-17.501) AF6(3.5,-17.501) AF7(4.2,-17.501) AF8(4.9,-17.501) AF9(5.6,-17.501) AF10(6.3,-17.501) AF11(7,-17.501) AF13(8.4,-17.501) AF14(9.1,-17.501) AF15(9.8,-17.501) AF16(10.5,-17.501) AF17(11.2,-17.501) AF18(11.9,-17.501) AF19(12.6,-17.501) AF20(13.3,-17.501) AF21(14,-17.501) AF22(14.701,-17.501) AF23(15.401,-17.501) AF24(16.101,-17.501) AF25(16.801,-17.501) AF26(17.501,-17.501) AF27(18.201,-17.501) AF28(18.901,-17.501) AF29(19.601,-17.501) AF30(20.301,-17.501) AF31(21.001,-17.501) AF32(21.701,-17.501) AF33(22.401,-17.501) AF34(23.101,-17.501) AF35(23.801,-17.501) AF36(24.501,-17.501) AF37(25.201,-17.501) AF38(25.901,-17.501) AF39(26.601,-17.501) AF40(27.301,-17.501) AF42(28.701,-17.501) AF43(29.401,-17.501) AF44(30.101,-17.501) AF45(30.801,-17.501) AF46(31.501,-17.501) AF47(32.201,-17.501) AF48(32.901,-17.501) AF49(33.601,-17.501) AF50(34.301,-17.501) AF51(35.001,-17.501) AF52(35.701,-17.501) AG1(0,-18.201) AG2(0.7,-18.201) AG3(1.4,-18.201) AG4(2.1,-18.201) AG5(2.8,-18.201) AG6(3.5,-18.201) AG7(4.2,-18.201) AG8(4.9,-18.201) AG9(5.6,-18.201) AG10(6.3,-18.201) AG11(7,-18.201) AG13(8.4,-18.201) AG14(9.1,-18.201) AG15(9.8,-18.201) AG16(10.5,-18.201) AG17(11.2,-18.201) AG18(11.9,-18.201) AG19(12.6,-18.201) AG20(13.3,-18.201) AG21(14,-18.201) AG22(14.701,-18.201) AG23(15.401,-18.201) AG24(16.101,-18.201) AG25(16.801,-18.201) AG26(17.501,-18.201) AG27(18.201,-18.201) AG28(18.901,-18.201) AG29(19.601,-18.201) AG30(20.301,-18.201) AG31(21.001,-18.201) AG32(21.701,-18.201) AG33(22.401,-18.201) AG34(23.101,-18.201) AG35(23.801,-18.201) AG36(24.501,-18.201) AG37(25.201,-18.201) AG38(25.901,-18.201) AG39(26.601,-18.201) AG40(27.301,-18.201) AG42(28.701,-18.201) AG43(29.401,-18.201) AG44(30.101,-18.201) AG45(30.801,-18.201) AG46(31.501,-18.201) AG47(32.201,-18.201) AG48(32.901,-18.201) AG49(33.601,-18.201) AG50(34.301,-18.201) AG51(35.001,-18.201) AG52(35.701,-18.201) AH2(0.7,-18.901) AH4(2.1,-18.901) AH6(3.5,-18.901) AH8(4.9,-18.901) AH10(6.3,-18.901) AH13(8.4,-18.901) AH14(9.1,-18.901) AH15(9.8,-18.901) AH16(10.5,-18.901) AH17(11.2,-18.901) AH18(11.9,-18.901) AH19(12.6,-18.901) AH20(13.3,-18.901) AH21(14,-18.901) AH22(14.701,-18.901) AH23(15.401,-18.901) AH24(16.101,-18.901) AH25(16.801,-18.901) AH26(17.501,-18.901) AH27(18.201,-18.901) AH28(18.901,-18.901) AH29(19.601,-18.901) AH30(20.301,-18.901) AH31(21.001,-18.901) AH32(21.701,-18.901) AH33(22.401,-18.901) AH34(23.101,-18.901) AH35(23.801,-18.901) AH36(24.501,-18.901) AH37(25.201,-18.901) AH38(25.901,-18.901) AH39(26.601,-18.901) AH40(27.301,-18.901) AH43(29.401,-18.901) AH45(30.801,-18.901) AH47(32.201,-18.901) AH49(33.601,-18.901) AH51(35.001,-18.901) AJ1(0,-19.601) AJ2(0.7,-19.601) AJ3(1.4,-19.601) AJ4(2.1,-19.601) AJ5(2.8,-19.601) AJ6(3.5,-19.601) AJ7(4.2,-19.601) AJ8(4.9,-19.601) AJ9(5.6,-19.601) AJ10(6.3,-19.601) AJ11(7,-19.601) AJ13(8.4,-19.601) AJ14(9.1,-19.601) AJ15(9.8,-19.601) AJ16(10.5,-19.601) AJ17(11.2,-19.601) AJ18(11.9,-19.601) AJ19(12.6,-19.601) AJ20(13.3,-19.601) AJ21(14,-19.601) AJ22(14.701,-19.601) AJ23(15.401,-19.601) AJ24(16.101,-19.601) AJ25(16.801,-19.601) AJ26(17.501,-19.601) AJ27(18.201,-19.601) AJ28(18.901,-19.601) AJ29(19.601,-19.601) AJ30(20.301,-19.601) AJ31(21.001,-19.601) AJ32(21.701,-19.601) AJ33(22.401,-19.601) AJ34(23.101,-19.601) AJ35(23.801,-19.601) AJ36(24.501,-19.601) AJ37(25.201,-19.601) AJ38(25.901,-19.601) AJ39(26.601,-19.601) AJ40(27.301,-19.601) AJ42(28.701,-19.601) AJ43(29.401,-19.601) AJ44(30.101,-19.601) AJ45(30.801,-19.601) AJ46(31.501,-19.601) AJ47(32.201,-19.601) AJ48(32.901,-19.601) AJ49(33.601,-19.601) AJ50(34.301,-19.601) AJ51(35.001,-19.601) AJ52(35.701,-19.601) AK1(0,-20.301) AK2(0.7,-20.301) AK3(1.4,-20.301) AK4(2.1,-20.301) AK5(2.8,-20.301) AK6(3.5,-20.301) AK7(4.2,-20.301) AK8(4.9,-20.301) AK9(5.6,-20.301) AK10(6.3,-20.301) AK11(7,-20.301) AK13(8.4,-20.301) AK14(9.1,-20.301) AK15(9.8,-20.301) AK16(10.5,-20.301) AK17(11.2,-20.301) AK18(11.9,-20.301) AK19(12.6,-20.301) AK20(13.3,-20.301) AK21(14,-20.301) AK22(14.701,-20.301) AK23(15.401,-20.301) AK24(16.101,-20.301) AK25(16.801,-20.301) AK26(17.501,-20.301) AK27(18.201,-20.301) AK28(18.901,-20.301) AK29(19.601,-20.301) AK30(20.301,-20.301) AK31(21.001,-20.301) AK32(21.701,-20.301) AK33(22.401,-20.301) AK34(23.101,-20.301) AK35(23.801,-20.301) AK36(24.501,-20.301) AK37(25.201,-20.301) AK38(25.901,-20.301) AK39(26.601,-20.301) AK40(27.301,-20.301) AK42(28.701,-20.301) AK43(29.401,-20.301) AK44(30.101,-20.301) AK45(30.801,-20.301) AK46(31.501,-20.301) AK47(32.201,-20.301) AK48(32.901,-20.301) AK49(33.601,-20.301) AK50(34.301,-20.301) AK51(35.001,-20.301) AK52(35.701,-20.301) AL2(0.7,-21.001) AL4(2.1,-21.001) AL6(3.5,-21.001) AL8(4.9,-21.001) AL10(6.3,-21.001) AL13(8.4,-21.001) AL14(9.1,-21.001) AL15(9.8,-21.001) AL16(10.5,-21.001) AL17(11.2,-21.001) AL18(11.9,-21.001) AL19(12.6,-21.001) AL20(13.3,-21.001) AL21(14,-21.001) AL22(14.701,-21.001) AL23(15.401,-21.001) AL24(16.101,-21.001) AL25(16.801,-21.001) AL26(17.501,-21.001) AL27(18.201,-21.001) AL28(18.901,-21.001) AL29(19.601,-21.001) AL30(20.301,-21.001) AL31(21.001,-21.001) AL32(21.701,-21.001) AL33(22.401,-21.001) AL34(23.101,-21.001) AL35(23.801,-21.001) AL36(24.501,-21.001) AL37(25.201,-21.001) AL38(25.901,-21.001) AL39(26.601,-21.001) AL40(27.301,-21.001) AL43(29.401,-21.001) AL45(30.801,-21.001) AL47(32.201,-21.001) AL49(33.601,-21.001) AL51(35.001,-21.001) AM1(0,-21.701) AM2(0.7,-21.701) AM3(1.4,-21.701) AM4(2.1,-21.701) AM5(2.8,-21.701) AM6(3.5,-21.701) AM7(4.2,-21.701) AM8(4.9,-21.701) AM9(5.6,-21.701) AM10(6.3,-21.701) AM11(7,-21.701) AM13(8.4,-21.701) AM14(9.1,-21.701) AM15(9.8,-21.701) AM16(10.5,-21.701) AM17(11.2,-21.701) AM18(11.9,-21.701) AM19(12.6,-21.701) AM20(13.3,-21.701) AM21(14,-21.701) AM22(14.701,-21.701) AM23(15.401,-21.701) AM24(16.101,-21.701) AM25(16.801,-21.701) AM26(17.501,-21.701) AM27(18.201,-21.701) AM28(18.901,-21.701) AM29(19.601,-21.701) AM30(20.301,-21.701) AM31(21.001,-21.701) AM32(21.701,-21.701) AM33(22.401,-21.701) AM34(23.101,-21.701) AM35(23.801,-21.701) AM36(24.501,-21.701) AM37(25.201,-21.701) AM38(25.901,-21.701) AM39(26.601,-21.701) AM40(27.301,-21.701) AM42(28.701,-21.701) AM43(29.401,-21.701) AM44(30.101,-21.701) AM45(30.801,-21.701) AM46(31.501,-21.701) AM47(32.201,-21.701) AM48(32.901,-21.701) AM49(33.601,-21.701) AM50(34.301,-21.701) AM51(35.001,-21.701) AM52(35.701,-21.701) AN1(0,-22.401) AN2(0.7,-22.401) AN3(1.4,-22.401) AN4(2.1,-22.401) AN5(2.8,-22.401) AN6(3.5,-22.401) AN7(4.2,-22.401) AN8(4.9,-22.401) AN9(5.6,-22.401) AN10(6.3,-22.401) AN11(7,-22.401) AN13(8.4,-22.401) AN14(9.1,-22.401) AN15(9.8,-22.401) AN16(10.5,-22.401) AN17(11.2,-22.401) AN18(11.9,-22.401) AN19(12.6,-22.401) AN20(13.3,-22.401) AN21(14,-22.401) AN22(14.701,-22.401) AN23(15.401,-22.401) AN24(16.101,-22.401) AN25(16.801,-22.401) AN26(17.501,-22.401) AN27(18.201,-22.401) AN28(18.901,-22.401) AN29(19.601,-22.401) AN30(20.301,-22.401) AN31(21.001,-22.401) AN32(21.701,-22.401) AN33(22.401,-22.401) AN34(23.101,-22.401) AN35(23.801,-22.401) AN36(24.501,-22.401) AN37(25.201,-22.401) AN38(25.901,-22.401) AN39(26.601,-22.401) AN40(27.301,-22.401) AN42(28.701,-22.401) AN43(29.401,-22.401) AN44(30.101,-22.401) AN45(30.801,-22.401) AN46(31.501,-22.401) AN47(32.201,-22.401) AN48(32.901,-22.401) AN49(33.601,-22.401) AN50(34.301,-22.401) AN51(35.001,-22.401) AN52(35.701,-22.401) AP2(0.7,-23.101) AP4(2.1,-23.101) AP6(3.5,-23.101) AP8(4.9,-23.101) AP10(6.3,-23.101) AP13(8.4,-23.101) AP14(9.1,-23.101) AP15(9.8,-23.101) AP16(10.5,-23.101) AP17(11.2,-23.101) AP18(11.9,-23.101) AP19(12.6,-23.101) AP20(13.3,-23.101) AP21(14,-23.101) AP22(14.701,-23.101) AP23(15.401,-23.101) AP24(16.101,-23.101) AP25(16.801,-23.101) AP26(17.501,-23.101) AP27(18.201,-23.101) AP28(18.901,-23.101) AP29(19.601,-23.101) AP30(20.301,-23.101) AP31(21.001,-23.101) AP32(21.701,-23.101) AP33(22.401,-23.101) AP34(23.101,-23.101) AP35(23.801,-23.101) AP36(24.501,-23.101) AP37(25.201,-23.101) AP38(25.901,-23.101) AP39(26.601,-23.101) AP40(27.301,-23.101) AP43(29.401,-23.101) AP45(30.801,-23.101) AP47(32.201,-23.101) AP49(33.601,-23.101) AP51(35.001,-23.101) AR1(0,-23.801) AR2(0.7,-23.801) AR3(1.4,-23.801) AR4(2.1,-23.801) AR5(2.8,-23.801) AR6(3.5,-23.801) AR7(4.2,-23.801) AR8(4.9,-23.801) AR9(5.6,-23.801) AR10(6.3,-23.801) AR11(7,-23.801) AR13(8.4,-23.801) AR14(9.1,-23.801) AR15(9.8,-23.801) AR16(10.5,-23.801) AR17(11.2,-23.801) AR18(11.9,-23.801) AR19(12.6,-23.801) AR20(13.3,-23.801) AR21(14,-23.801) AR22(14.701,-23.801) AR23(15.401,-23.801) AR24(16.101,-23.801) AR25(16.801,-23.801) AR26(17.501,-23.801) AR27(18.201,-23.801) AR28(18.901,-23.801) AR29(19.601,-23.801) AR30(20.301,-23.801) AR31(21.001,-23.801) AR32(21.701,-23.801) AR33(22.401,-23.801) AR34(23.101,-23.801) AR35(23.801,-23.801) AR36(24.501,-23.801) AR37(25.201,-23.801) AR38(25.901,-23.801) AR39(26.601,-23.801) AR40(27.301,-23.801) AR42(28.701,-23.801) AR43(29.401,-23.801) AR44(30.101,-23.801) AR45(30.801,-23.801) AR46(31.501,-23.801) AR47(32.201,-23.801) AR48(32.901,-23.801) AR49(33.601,-23.801) AR50(34.301,-23.801) AR51(35.001,-23.801) AR52(35.701,-23.801) AT1(0,-24.501) AT2(0.7,-24.501) AT3(1.4,-24.501) AT4(2.1,-24.501) AT5(2.8,-24.501) AT6(3.5,-24.501) AT7(4.2,-24.501) AT8(4.9,-24.501) AT9(5.6,-24.501) AT10(6.3,-24.501) AT11(7,-24.501) AT13(8.4,-24.501) AT14(9.1,-24.501) AT15(9.8,-24.501) AT16(10.5,-24.501) AT17(11.2,-24.501) AT18(11.9,-24.501) AT19(12.6,-24.501) AT20(13.3,-24.501) AT21(14,-24.501) AT22(14.701,-24.501) AT23(15.401,-24.501) AT24(16.101,-24.501) AT25(16.801,-24.501) AT26(17.501,-24.501) AT27(18.201,-24.501) AT28(18.901,-24.501) AT29(19.601,-24.501) AT30(20.301,-24.501) AT31(21.001,-24.501) AT32(21.701,-24.501) AT33(22.401,-24.501) AT34(23.101,-24.501) AT35(23.801,-24.501) AT36(24.501,-24.501) AT37(25.201,-24.501) AT38(25.901,-24.501) AT39(26.601,-24.501) AT40(27.301,-24.501) AT42(28.701,-24.501) AT43(29.401,-24.501) AT44(30.101,-24.501) AT45(30.801,-24.501) AT46(31.501,-24.501) AT47(32.201,-24.501) AT48(32.901,-24.501) AT49(33.601,-24.501) AT50(34.301,-24.501) AT51(35.001,-24.501) AT52(35.701,-24.501) AU2(0.7,-25.201) AU4(2.1,-25.201) AU6(3.5,-25.201) AU8(4.9,-25.201) AU10(6.3,-25.201) AU13(8.4,-25.201) AU14(9.1,-25.201) AU15(9.8,-25.201) AU16(10.5,-25.201) AU17(11.2,-25.201) AU18(11.9,-25.201) AU19(12.6,-25.201) AU20(13.3,-25.201) AU21(14,-25.201) AU22(14.701,-25.201) AU23(15.401,-25.201) AU24(16.101,-25.201) AU25(16.801,-25.201) AU26(17.501,-25.201) AU27(18.201,-25.201) AU28(18.901,-25.201) AU29(19.601,-25.201) AU30(20.301,-25.201) AU31(21.001,-25.201) AU32(21.701,-25.201) AU33(22.401,-25.201) AU34(23.101,-25.201) AU35(23.801,-25.201) AU36(24.501,-25.201) AU37(25.201,-25.201) AU38(25.901,-25.201) AU39(26.601,-25.201) AU40(27.301,-25.201) AU43(29.401,-25.201) AU45(30.801,-25.201) AU47(32.201,-25.201) AU49(33.601,-25.201) AU51(35.001,-25.201) AV1(0,-25.901) AV2(0.7,-25.901) AV3(1.4,-25.901) AV4(2.1,-25.901) AV5(2.8,-25.901) AV6(3.5,-25.901) AV7(4.2,-25.901) AV8(4.9,-25.901) AV9(5.6,-25.901) AV10(6.3,-25.901) AV11(7,-25.901) AV13(8.4,-25.901) AV14(9.1,-25.901) AV15(9.8,-25.901) AV16(10.5,-25.901) AV17(11.2,-25.901) AV18(11.9,-25.901) AV19(12.6,-25.901) AV20(13.3,-25.901) AV21(14,-25.901) AV22(14.701,-25.901) AV23(15.401,-25.901) AV24(16.101,-25.901) AV25(16.801,-25.901) AV26(17.501,-25.901) AV27(18.201,-25.901) AV28(18.901,-25.901) AV29(19.601,-25.901) AV30(20.301,-25.901) AV31(21.001,-25.901) AV32(21.701,-25.901) AV33(22.401,-25.901) AV34(23.101,-25.901) AV35(23.801,-25.901) AV36(24.501,-25.901) AV37(25.201,-25.901) AV38(25.901,-25.901) AV39(26.601,-25.901) AV40(27.301,-25.901) AV42(28.701,-25.901) AV43(29.401,-25.901) AV44(30.101,-25.901) AV45(30.801,-25.901) AV46(31.501,-25.901) AV47(32.201,-25.901) AV48(32.901,-25.901) AV49(33.601,-25.901) AV50(34.301,-25.901) AV51(35.001,-25.901) AV52(35.701,-25.901) AW1(0,-26.601) AW2(0.7,-26.601) AW3(1.4,-26.601) AW4(2.1,-26.601) AW5(2.8,-26.601) AW6(3.5,-26.601) AW7(4.2,-26.601) AW8(4.9,-26.601) AW9(5.6,-26.601) AW10(6.3,-26.601) AW11(7,-26.601) AW13(8.4,-26.601) AW14(9.1,-26.601) AW15(9.8,-26.601) AW16(10.5,-26.601) AW17(11.2,-26.601) AW18(11.9,-26.601) AW19(12.6,-26.601) AW20(13.3,-26.601) AW21(14,-26.601) AW22(14.701,-26.601) AW23(15.401,-26.601) AW24(16.101,-26.601) AW25(16.801,-26.601) AW26(17.501,-26.601) AW27(18.201,-26.601) AW28(18.901,-26.601) AW29(19.601,-26.601) AW30(20.301,-26.601) AW31(21.001,-26.601) AW32(21.701,-26.601) AW33(22.401,-26.601) AW34(23.101,-26.601) AW35(23.801,-26.601) AW36(24.501,-26.601) AW37(25.201,-26.601) AW38(25.901,-26.601) AW39(26.601,-26.601) AW40(27.301,-26.601) AW42(28.701,-26.601) AW43(29.401,-26.601) AW44(30.101,-26.601) AW45(30.801,-26.601) AW46(31.501,-26.601) AW47(32.201,-26.601) AW48(32.901,-26.601) AW49(33.601,-26.601) AW50(34.301,-26.601) AW51(35.001,-26.601) AW52(35.701,-26.601) AY2(0.7,-27.301) AY4(2.1,-27.301) AY6(3.5,-27.301) AY8(4.9,-27.301) AY10(6.3,-27.301) AY13(8.4,-27.301) AY14(9.1,-27.301) AY15(9.8,-27.301) AY16(10.5,-27.301) AY17(11.2,-27.301) AY18(11.9,-27.301) AY19(12.6,-27.301) AY20(13.3,-27.301) AY21(14,-27.301) AY22(14.701,-27.301) AY23(15.401,-27.301) AY24(16.101,-27.301) AY25(16.801,-27.301) AY26(17.501,-27.301) AY27(18.201,-27.301) AY28(18.901,-27.301) AY29(19.601,-27.301) AY30(20.301,-27.301) AY31(21.001,-27.301) AY32(21.701,-27.301) AY33(22.401,-27.301) AY34(23.101,-27.301) AY35(23.801,-27.301) AY36(24.501,-27.301) AY37(25.201,-27.301) AY38(25.901,-27.301) AY39(26.601,-27.301) AY40(27.301,-27.301) AY43(29.401,-27.301) AY45(30.801,-27.301) AY47(32.201,-27.301) AY49(33.601,-27.301) AY51(35.001,-27.301) B4(2.1,-0.7) B5(2.8,-0.7) B6(3.5,-0.7) B7(4.2,-0.7) B8(4.9,-0.7) B9(5.6,-0.7) B10(6.3,-0.7) B11(7,-0.7) B12(7.7,-0.7) B13(8.4,-0.7) B14(9.1,-0.7) B15(9.8,-0.7) B16(10.5,-0.7) B17(11.2,-0.7) B18(11.9,-0.7) B19(12.6,-0.7) B20(13.3,-0.7) B21(14,-0.7) B22(14.701,-0.7) B23(15.401,-0.7) B24(16.101,-0.7) B25(16.801,-0.7) B26(17.501,-0.7) B27(18.201,-0.7) B28(18.901,-0.7) B29(19.601,-0.7) B30(20.301,-0.7) B31(21.001,-0.7) B32(21.701,-0.7) B33(22.401,-0.7) B34(23.101,-0.7) B35(23.801,-0.7) B36(24.501,-0.7) B37(25.201,-0.7) B38(25.901,-0.7) B39(26.601,-0.7) B40(27.301,-0.7) B41(28.001,-0.7) B42(28.701,-0.7) B43(29.401,-0.7) B44(30.101,-0.7) B45(30.801,-0.7) B46(31.501,-0.7) B47(32.201,-0.7) B48(32.901,-0.7) B49(33.601,-0.7) BA1(0,-28.001) BA2(0.7,-28.001) BA3(1.4,-28.001) BA4(2.1,-28.001) BA5(2.8,-28.001) BA6(3.5,-28.001) BA7(4.2,-28.001) BA8(4.9,-28.001) BA9(5.6,-28.001) BA10(6.3,-28.001) BA43(29.401,-28.001) BA44(30.101,-28.001) BA45(30.801,-28.001) BA46(31.501,-28.001) BA47(32.201,-28.001) BA48(32.901,-28.001) BA49(33.601,-28.001) BA50(34.301,-28.001) BA51(35.001,-28.001) BA52(35.701,-28.001) BB1(0,-28.701) BB2(0.7,-28.701) BB3(1.4,-28.701) BB4(2.1,-28.701) BB5(2.8,-28.701) BB6(3.5,-28.701) BB7(4.2,-28.701) BB8(4.9,-28.701) BB14(9.1,-28.701) BB15(9.8,-28.701) BB17(11.2,-28.701) BB18(11.9,-28.701) BB20(13.3,-28.701) BB21(14,-28.701) BB23(15.401,-28.701) BB24(16.101,-28.701) BB26(17.501,-28.701) BB27(18.201,-28.701) BB29(19.601,-28.701) BB30(20.301,-28.701) BB32(21.701,-28.701) BB33(22.401,-28.701) BB35(23.801,-28.701) BB36(24.501,-28.701) BB38(25.901,-28.701) BB39(26.601,-28.701) BB45(30.801,-28.701) BB46(31.501,-28.701) BB47(32.201,-28.701) BB48(32.901,-28.701) BB49(33.601,-28.701) BB50(34.301,-28.701) BB51(35.001,-28.701) BB52(35.701,-28.701) BC2(0.7,-29.401) BC4(2.1,-29.401) BC6(3.5,-29.401) BC8(4.9,-29.401) BC12(7.7,-29.401) BC13(8.4,-29.401) BC14(9.1,-29.401) BC15(9.8,-29.401) BC16(10.5,-29.401) BC17(11.2,-29.401) BC18(11.9,-29.401) BC19(12.6,-29.401) BC20(13.3,-29.401) BC21(14,-29.401) BC22(14.701,-29.401) BC23(15.401,-29.401) BC24(16.101,-29.401) BC25(16.801,-29.401) BC26(17.501,-29.401) BC27(18.201,-29.401) BC28(18.901,-29.401) BC29(19.601,-29.401) BC30(20.301,-29.401) BC31(21.001,-29.401) BC32(21.701,-29.401) BC33(22.401,-29.401) BC34(23.101,-29.401) BC35(23.801,-29.401) BC36(24.501,-29.401) BC37(25.201,-29.401) BC38(25.901,-29.401) BC39(26.601,-29.401) BC40(27.301,-29.401) BC41(28.001,-29.401) BC45(30.801,-29.401) BC47(32.201,-29.401) BC49(33.601,-29.401) BC51(35.001,-29.401) BD1(0,-30.101) BD2(0.7,-30.101) BD3(1.4,-30.101) BD4(2.1,-30.101) BD5(2.8,-30.101) BD6(3.5,-30.101) BD7(4.2,-30.101) BD12(7.7,-30.101) BD14(9.1,-30.101) BD15(9.8,-30.101) BD17(11.2,-30.101) BD18(11.9,-30.101) BD20(13.3,-30.101) BD21(14,-30.101) BD23(15.401,-30.101) BD24(16.101,-30.101) BD26(17.501,-30.101) BD27(18.201,-30.101) BD29(19.601,-30.101) BD30(20.301,-30.101) BD32(21.701,-30.101) BD33(22.401,-30.101) BD35(23.801,-30.101) BD36(24.501,-30.101) BD38(25.901,-30.101) BD39(26.601,-30.101) BD41(28.001,-30.101) BD46(31.501,-30.101) BD47(32.201,-30.101) BD48(32.901,-30.101) BD49(33.601,-30.101) BD50(34.301,-30.101) BD51(35.001,-30.101) BD52(35.701,-30.101) BE1(0,-30.801) BE2(0.7,-30.801) BE3(1.4,-30.801) BE4(2.1,-30.801) BE5(2.8,-30.801) BE6(3.5,-30.801) BE7(4.2,-30.801) BE10(6.3,-30.801) BE11(7,-30.801) BE12(7.7,-30.801) BE13(8.4,-30.801) BE14(9.1,-30.801) BE15(9.8,-30.801) BE16(10.5,-30.801) BE17(11.2,-30.801) BE18(11.9,-30.801) BE19(12.6,-30.801) BE20(13.3,-30.801) BE21(14,-30.801) BE22(14.701,-30.801) BE23(15.401,-30.801) BE24(16.101,-30.801) BE25(16.801,-30.801) BE26(17.501,-30.801) BE27(18.201,-30.801) BE28(18.901,-30.801) BE29(19.601,-30.801) BE30(20.301,-30.801) BE31(21.001,-30.801) BE32(21.701,-30.801) BE33(22.401,-30.801) BE34(23.101,-30.801) BE35(23.801,-30.801) BE36(24.501,-30.801) BE37(25.201,-30.801) BE38(25.901,-30.801) BE39(26.601,-30.801) BE40(27.301,-30.801) BE41(28.001,-30.801) BE42(28.701,-30.801) BE43(29.401,-30.801) BE46(31.501,-30.801) BE47(32.201,-30.801) BE48(32.901,-30.801) BE49(33.601,-30.801) BE50(34.301,-30.801) BE51(35.001,-30.801) BE52(35.701,-30.801) BF2(0.7,-31.501) BF4(2.1,-31.501) BF6(3.5,-31.501) BF8(4.9,-31.501) BF9(5.6,-31.501) BF11(7,-31.501) BF12(7.7,-31.501) BF14(9.1,-31.501) BF15(9.8,-31.501) BF17(11.2,-31.501) BF18(11.9,-31.501) BF20(13.3,-31.501) BF21(14,-31.501) BF23(15.401,-31.501) BF24(16.101,-31.501) BF26(17.501,-31.501) BF27(18.201,-31.501) BF29(19.601,-31.501) BF30(20.301,-31.501) BF32(21.701,-31.501) BF33(22.401,-31.501) BF35(23.801,-31.501) BF36(24.501,-31.501) BF38(25.901,-31.501) BF39(26.601,-31.501) BF41(28.001,-31.501) BF42(28.701,-31.501) BF44(30.101,-31.501) BF45(30.801,-31.501) BF47(32.201,-31.501) BF49(33.601,-31.501) BF51(35.001,-31.501) BG1(0,-32.201) BG2(0.7,-32.201) BG3(1.4,-32.201) BG4(2.1,-32.201) BG5(2.8,-32.201) BG6(3.5,-32.201) BG7(4.2,-32.201) BG8(4.9,-32.201) BG9(5.6,-32.201) BG10(6.3,-32.201) BG11(7,-32.201) BG12(7.7,-32.201) BG13(8.4,-32.201) BG14(9.1,-32.201) BG15(9.8,-32.201) BG16(10.5,-32.201) BG17(11.2,-32.201) BG18(11.9,-32.201) BG19(12.6,-32.201) BG20(13.3,-32.201) BG21(14,-32.201) BG22(14.701,-32.201) BG23(15.401,-32.201) BG24(16.101,-32.201) BG25(16.801,-32.201) BG26(17.501,-32.201) BG27(18.201,-32.201) BG28(18.901,-32.201) BG29(19.601,-32.201) BG30(20.301,-32.201) BG31(21.001,-32.201) BG32(21.701,-32.201) BG33(22.401,-32.201) BG34(23.101,-32.201) BG35(23.801,-32.201) BG36(24.501,-32.201) BG37(25.201,-32.201) BG38(25.901,-32.201) BG39(26.601,-32.201) BG40(27.301,-32.201) BG41(28.001,-32.201) BG42(28.701,-32.201) BG43(29.401,-32.201) BG44(30.101,-32.201) BG45(30.801,-32.201) BG46(31.501,-32.201) BG47(32.201,-32.201) BG48(32.901,-32.201) BG49(33.601,-32.201) BG50(34.301,-32.201) BG51(35.001,-32.201) BG52(35.701,-32.201) BH1(0,-32.901) BH2(0.7,-32.901) BH3(1.4,-32.901) BH4(2.1,-32.901) BH5(2.8,-32.901) BH6(3.5,-32.901) BH8(4.9,-32.901) BH9(5.6,-32.901) BH11(7,-32.901) BH12(7.7,-32.901) BH14(9.1,-32.901) BH15(9.8,-32.901) BH17(11.2,-32.901) BH18(11.9,-32.901) BH20(13.3,-32.901) BH21(14,-32.901) BH23(15.401,-32.901) BH24(16.101,-32.901) BH26(17.501,-32.901) BH27(18.201,-32.901) BH29(19.601,-32.901) BH30(20.301,-32.901) BH32(21.701,-32.901) BH33(22.401,-32.901) BH35(23.801,-32.901) BH36(24.501,-32.901) BH38(25.901,-32.901) BH39(26.601,-32.901) BH41(28.001,-32.901) BH42(28.701,-32.901) BH44(30.101,-32.901) BH45(30.801,-32.901) BH47(32.201,-32.901) BH48(32.901,-32.901) BH49(33.601,-32.901) BH50(34.301,-32.901) BH51(35.001,-32.901) BH52(35.701,-32.901) BJ1(0,-33.601) BJ2(0.7,-33.601) BJ3(1.4,-33.601) BJ4(2.1,-33.601) BJ5(2.8,-33.601) BJ6(3.5,-33.601) BJ7(4.2,-33.601) BJ8(4.9,-33.601) BJ9(5.6,-33.601) BJ10(6.3,-33.601) BJ11(7,-33.601) BJ12(7.7,-33.601) BJ13(8.4,-33.601) BJ14(9.1,-33.601) BJ15(9.8,-33.601) BJ16(10.5,-33.601) BJ17(11.2,-33.601) BJ18(11.9,-33.601) BJ19(12.6,-33.601) BJ20(13.3,-33.601) BJ21(14,-33.601) BJ22(14.701,-33.601) BJ23(15.401,-33.601) BJ24(16.101,-33.601) BJ25(16.801,-33.601) BJ26(17.501,-33.601) BJ27(18.201,-33.601) BJ28(18.901,-33.601) BJ29(19.601,-33.601) BJ30(20.301,-33.601) BJ31(21.001,-33.601) BJ32(21.701,-33.601) BJ33(22.401,-33.601) BJ34(23.101,-33.601) BJ35(23.801,-33.601) BJ36(24.501,-33.601) BJ37(25.201,-33.601) BJ38(25.901,-33.601) BJ39(26.601,-33.601) BJ40(27.301,-33.601) BJ41(28.001,-33.601) BJ42(28.701,-33.601) BJ43(29.401,-33.601) BJ44(30.101,-33.601) BJ45(30.801,-33.601) BJ46(31.501,-33.601) BJ47(32.201,-33.601) BJ48(32.901,-33.601) BJ49(33.601,-33.601) BJ50(34.301,-33.601) BJ51(35.001,-33.601) BJ52(35.701,-33.601) BK4(2.1,-34.301) BK5(2.8,-34.301) BK6(3.5,-34.301) BK8(4.9,-34.301) BK9(5.6,-34.301) BK11(7,-34.301) BK12(7.7,-34.301) BK14(9.1,-34.301) BK15(9.8,-34.301) BK17(11.2,-34.301) BK18(11.9,-34.301) BK20(13.3,-34.301) BK21(14,-34.301) BK23(15.401,-34.301) BK24(16.101,-34.301) BK26(17.501,-34.301) BK27(18.201,-34.301) BK29(19.601,-34.301) BK30(20.301,-34.301) BK32(21.701,-34.301) BK33(22.401,-34.301) BK35(23.801,-34.301) BK36(24.501,-34.301) BK38(25.901,-34.301) BK39(26.601,-34.301) BK41(28.001,-34.301) BK42(28.701,-34.301) BK44(30.101,-34.301) BK45(30.801,-34.301) BK47(32.201,-34.301) BK48(32.901,-34.301) BK49(33.601,-34.301) BL4(2.1,-35.001) BL5(2.8,-35.001) BL6(3.5,-35.001) BL7(4.2,-35.001) BL8(4.9,-35.001) BL9(5.6,-35.001) BL10(6.3,-35.001) BL11(7,-35.001) BL12(7.7,-35.001) BL13(8.4,-35.001) BL14(9.1,-35.001) BL15(9.8,-35.001) BL16(10.5,-35.001) BL17(11.2,-35.001) BL18(11.9,-35.001) BL19(12.6,-35.001) BL20(13.3,-35.001) BL21(14,-35.001) BL22(14.701,-35.001) BL23(15.401,-35.001) BL24(16.101,-35.001) BL25(16.801,-35.001) BL26(17.501,-35.001) BL27(18.201,-35.001) BL28(18.901,-35.001) BL29(19.601,-35.001) BL30(20.301,-35.001) BL31(21.001,-35.001) BL32(21.701,-35.001) BL33(22.401,-35.001) BL34(23.101,-35.001) BL35(23.801,-35.001) BL36(24.501,-35.001) BL37(25.201,-35.001) BL38(25.901,-35.001) BL39(26.601,-35.001) BL40(27.301,-35.001) BL41(28.001,-35.001) BL42(28.701,-35.001) BL43(29.401,-35.001) BL44(30.101,-35.001) BL45(30.801,-35.001) BL46(31.501,-35.001) BL47(32.201,-35.001) BL48(32.901,-35.001) BL49(33.601,-35.001) BM4(2.1,-35.701) BM5(2.8,-35.701) BM6(3.5,-35.701) BM8(4.9,-35.701) BM9(5.6,-35.701) BM11(7,-35.701) BM12(7.7,-35.701) BM14(9.1,-35.701) BM15(9.8,-35.701) BM17(11.2,-35.701) BM18(11.9,-35.701) BM20(13.3,-35.701) BM21(14,-35.701) BM23(15.401,-35.701) BM24(16.101,-35.701) BM26(17.501,-35.701) BM27(18.201,-35.701) BM29(19.601,-35.701) BM30(20.301,-35.701) BM32(21.701,-35.701) BM33(22.401,-35.701) BM35(23.801,-35.701) BM36(24.501,-35.701) BM38(25.901,-35.701) BM39(26.601,-35.701) BM41(28.001,-35.701) BM42(28.701,-35.701) BM44(30.101,-35.701) BM45(30.801,-35.701) BM47(32.201,-35.701) BM48(32.901,-35.701) BM49(33.601,-35.701) C4(2.1,-1.4) C5(2.8,-1.4) C6(3.5,-1.4) C8(4.9,-1.4) C9(5.6,-1.4) C11(7,-1.4) C12(7.7,-1.4) C14(9.1,-1.4) C15(9.8,-1.4) C17(11.2,-1.4) C18(11.9,-1.4) C20(13.3,-1.4) C21(14,-1.4) C23(15.401,-1.4) C24(16.101,-1.4) C26(17.501,-1.4) C27(18.201,-1.4) C29(19.601,-1.4) C30(20.301,-1.4) C32(21.701,-1.4) C33(22.401,-1.4) C35(23.801,-1.4) C36(24.501,-1.4) C38(25.901,-1.4) C39(26.601,-1.4) C41(28.001,-1.4) C42(28.701,-1.4) C44(30.101,-1.4) C45(30.801,-1.4) C47(32.201,-1.4) C48(32.901,-1.4) C49(33.601,-1.4) D1(0,-2.1) D2(0.7,-2.1) D3(1.4,-2.1) D4(2.1,-2.1) D5(2.8,-2.1) D6(3.5,-2.1) D7(4.2,-2.1) D8(4.9,-2.1) D9(5.6,-2.1) D10(6.3,-2.1) D11(7,-2.1) D12(7.7,-2.1) D13(8.4,-2.1) D14(9.1,-2.1) D15(9.8,-2.1) D16(10.5,-2.1) D17(11.2,-2.1) D18(11.9,-2.1) D19(12.6,-2.1) D20(13.3,-2.1) D21(14,-2.1) D22(14.701,-2.1) D23(15.401,-2.1) D24(16.101,-2.1) D25(16.801,-2.1) D26(17.501,-2.1) D27(18.201,-2.1) D28(18.901,-2.1) D29(19.601,-2.1) D30(20.301,-2.1) D31(21.001,-2.1) D32(21.701,-2.1) D33(22.401,-2.1) D34(23.101,-2.1) D35(23.801,-2.1) D36(24.501,-2.1) D37(25.201,-2.1) D38(25.901,-2.1) D39(26.601,-2.1) D40(27.301,-2.1) D41(28.001,-2.1) D42(28.701,-2.1) D43(29.401,-2.1) D44(30.101,-2.1) D45(30.801,-2.1) D46(31.501,-2.1) D47(32.201,-2.1) D48(32.901,-2.1) D49(33.601,-2.1) D50(34.301,-2.1) D51(35.001,-2.1) D52(35.701,-2.1) E1(0,-2.8) E2(0.7,-2.8) E3(1.4,-2.8) E4(2.1,-2.8) E5(2.8,-2.8) E6(3.5,-2.8) E8(4.9,-2.8) E9(5.6,-2.8) E11(7,-2.8) E12(7.7,-2.8) E14(9.1,-2.8) E15(9.8,-2.8) E17(11.2,-2.8) E18(11.9,-2.8) E20(13.3,-2.8) E21(14,-2.8) E23(15.401,-2.8) E24(16.101,-2.8) E26(17.501,-2.8) E27(18.201,-2.8) E29(19.601,-2.8) E30(20.301,-2.8) E32(21.701,-2.8) E33(22.401,-2.8) E35(23.801,-2.8) E36(24.501,-2.8) E38(25.901,-2.8) E39(26.601,-2.8) E41(28.001,-2.8) E42(28.701,-2.8) E44(30.101,-2.8) E45(30.801,-2.8) E47(32.201,-2.8) E48(32.901,-2.8) E49(33.601,-2.8) E50(34.301,-2.8) E51(35.001,-2.8) E52(35.701,-2.8) F1(0,-3.5) F2(0.7,-3.5) F3(1.4,-3.5) F4(2.1,-3.5) F5(2.8,-3.5) F6(3.5,-3.5) F7(4.2,-3.5) F8(4.9,-3.5) F9(5.6,-3.5) F10(6.3,-3.5) F11(7,-3.5) F12(7.7,-3.5) F13(8.4,-3.5) F14(9.1,-3.5) F15(9.8,-3.5) F16(10.5,-3.5) F17(11.2,-3.5) F18(11.9,-3.5) F19(12.6,-3.5) F20(13.3,-3.5) F21(14,-3.5) F22(14.701,-3.5) F23(15.401,-3.5) F24(16.101,-3.5) F25(16.801,-3.5) F26(17.501,-3.5) F27(18.201,-3.5) F28(18.901,-3.5) F29(19.601,-3.5) F30(20.301,-3.5) F31(21.001,-3.5) F32(21.701,-3.5) F33(22.401,-3.5) F34(23.101,-3.5) F35(23.801,-3.5) F36(24.501,-3.5) F37(25.201,-3.5) F38(25.901,-3.5) F39(26.601,-3.5) F40(27.301,-3.5) F41(28.001,-3.5) F42(28.701,-3.5) F43(29.401,-3.5) F44(30.101,-3.5) F45(30.801,-3.5) F46(31.501,-3.5) F47(32.201,-3.5) F48(32.901,-3.5) F49(33.601,-3.5) F50(34.301,-3.5) F51(35.001,-3.5) F52(35.701,-3.5) G2(0.7,-4.2) G4(2.1,-4.2) G6(3.5,-4.2) G8(4.9,-4.2) G9(5.6,-4.2) G11(7,-4.2) G12(7.7,-4.2) G14(9.1,-4.2) G15(9.8,-4.2) G17(11.2,-4.2) G18(11.9,-4.2) G20(13.3,-4.2) G21(14,-4.2) G23(15.401,-4.2) G24(16.101,-4.2) G26(17.501,-4.2) G27(18.201,-4.2) G29(19.601,-4.2) G30(20.301,-4.2) G32(21.701,-4.2) G33(22.401,-4.2) G35(23.801,-4.2) G36(24.501,-4.2) G38(25.901,-4.2) G39(26.601,-4.2) G41(28.001,-4.2) G42(28.701,-4.2) G44(30.101,-4.2) G45(30.801,-4.2) G47(32.201,-4.2) G49(33.601,-4.2) G51(35.001,-4.2) H1(0,-4.9) H2(0.7,-4.9) H3(1.4,-4.9) H4(2.1,-4.9) H5(2.8,-4.9) H6(3.5,-4.9) H7(4.2,-4.9) H10(6.3,-4.9) H11(7,-4.9) H12(7.7,-4.9) H13(8.4,-4.9) H14(9.1,-4.9) H15(9.8,-4.9) H16(10.5,-4.9) H17(11.2,-4.9) H18(11.9,-4.9) H19(12.6,-4.9) H20(13.3,-4.9) H21(14,-4.9) H22(14.701,-4.9) H23(15.401,-4.9) H24(16.101,-4.9) H25(16.801,-4.9) H26(17.501,-4.9) H27(18.201,-4.9) H28(18.901,-4.9) H29(19.601,-4.9) H30(20.301,-4.9) H31(21.001,-4.9) H32(21.701,-4.9) H33(22.401,-4.9) H34(23.101,-4.9) H35(23.801,-4.9) H36(24.501,-4.9) H37(25.201,-4.9) H38(25.901,-4.9) H39(26.601,-4.9) H40(27.301,-4.9) H41(28.001,-4.9) H42(28.701,-4.9) H43(29.401,-4.9) H46(31.501,-4.9) H47(32.201,-4.9) H48(32.901,-4.9) H49(33.601,-4.9) H50(34.301,-4.9) H51(35.001,-4.9) H52(35.701,-4.9) J1(0,-5.6) J2(0.7,-5.6) J3(1.4,-5.6) J4(2.1,-5.6) J5(2.8,-5.6) J6(3.5,-5.6) J7(4.2,-5.6) J12(7.7,-5.6) J14(9.1,-5.6) J15(9.8,-5.6) J17(11.2,-5.6) J18(11.9,-5.6) J20(13.3,-5.6) J21(14,-5.6) J23(15.401,-5.6) J24(16.101,-5.6) J26(17.501,-5.6) J27(18.201,-5.6) J29(19.601,-5.6) J30(20.301,-5.6) J32(21.701,-5.6) J33(22.401,-5.6) J35(23.801,-5.6) J36(24.501,-5.6) J38(25.901,-5.6) J39(26.601,-5.6) J41(28.001,-5.6) J46(31.501,-5.6) J47(32.201,-5.6) J48(32.901,-5.6) J49(33.601,-5.6) J50(34.301,-5.6) J51(35.001,-5.6) J52(35.701,-5.6) K2(0.7,-6.3) K4(2.1,-6.3) K6(3.5,-6.3) K8(4.9,-6.3) K12(7.7,-6.3) K13(8.4,-6.3) K14(9.1,-6.3) K15(9.8,-6.3) K16(10.5,-6.3) K17(11.2,-6.3) K18(11.9,-6.3) K19(12.6,-6.3) K20(13.3,-6.3) K21(14,-6.3) K22(14.701,-6.3) K23(15.401,-6.3) K24(16.101,-6.3) K25(16.801,-6.3) K26(17.501,-6.3) K27(18.201,-6.3) K28(18.901,-6.3) K29(19.601,-6.3) K30(20.301,-6.3) K31(21.001,-6.3) K32(21.701,-6.3) K33(22.401,-6.3) K34(23.101,-6.3) K35(23.801,-6.3) K36(24.501,-6.3) K37(25.201,-6.3) K38(25.901,-6.3) K39(26.601,-6.3) K40(27.301,-6.3) K41(28.001,-6.3) K45(30.801,-6.3) K47(32.201,-6.3) K49(33.601,-6.3) K51(35.001,-6.3) L1(0,-7) L2(0.7,-7) L3(1.4,-7) L4(2.1,-7) L5(2.8,-7) L6(3.5,-7) L7(4.2,-7) L8(4.9,-7) L14(9.1,-7) L15(9.8,-7) L17(11.2,-7) L18(11.9,-7) L20(13.3,-7) L21(14,-7) L23(15.401,-7) L24(16.101,-7) L26(17.501,-7) L27(18.201,-7) L29(19.601,-7) L30(20.301,-7) L32(21.701,-7) L33(22.401,-7) L35(23.801,-7) L36(24.501,-7) L38(25.901,-7) L39(26.601,-7) L45(30.801,-7) L46(31.501,-7) L47(32.201,-7) L48(32.901,-7) L49(33.601,-7) L50(34.301,-7) L51(35.001,-7) L52(35.701,-7) M1(0,-7.7) M2(0.7,-7.7) M3(1.4,-7.7) M4(2.1,-7.7) M5(2.8,-7.7) M6(3.5,-7.7) M7(4.2,-7.7) M8(4.9,-7.7) M9(5.6,-7.7) M10(6.3,-7.7) M43(29.401,-7.7) M44(30.101,-7.7) M45(30.801,-7.7) M46(31.501,-7.7) M47(32.201,-7.7) M48(32.901,-7.7) M49(33.601,-7.7) M50(34.301,-7.7) M51(35.001,-7.7) M52(35.701,-7.7) N2(0.7,-8.4) N4(2.1,-8.4) N6(3.5,-8.4) N8(4.9,-8.4) N10(6.3,-8.4) N13(8.4,-8.4) N14(9.1,-8.4) N15(9.8,-8.4) N16(10.5,-8.4) N17(11.2,-8.4) N18(11.9,-8.4) N19(12.6,-8.4) N20(13.3,-8.4) N21(14,-8.4) N22(14.701,-8.4) N23(15.401,-8.4) N24(16.101,-8.4) N25(16.801,-8.4) N26(17.501,-8.4) N27(18.201,-8.4) N28(18.901,-8.4) N29(19.601,-8.4) N30(20.301,-8.4) N31(21.001,-8.4) N32(21.701,-8.4) N33(22.401,-8.4) N34(23.101,-8.4) N35(23.801,-8.4) N36(24.501,-8.4) N37(25.201,-8.4) N38(25.901,-8.4) N39(26.601,-8.4) N40(27.301,-8.4) N43(29.401,-8.4) N45(30.801,-8.4) N47(32.201,-8.4) N49(33.601,-8.4) N51(35.001,-8.4) P1(0,-9.1) P2(0.7,-9.1) P3(1.4,-9.1) P4(2.1,-9.1) P5(2.8,-9.1) P6(3.5,-9.1) P7(4.2,-9.1) P8(4.9,-9.1) P9(5.6,-9.1) P10(6.3,-9.1) P11(7,-9.1) P13(8.4,-9.1) P14(9.1,-9.1) P15(9.8,-9.1) P16(10.5,-9.1) P17(11.2,-9.1) P18(11.9,-9.1) P19(12.6,-9.1) P20(13.3,-9.1) P21(14,-9.1) P22(14.701,-9.1) P23(15.401,-9.1) P24(16.101,-9.1) P25(16.801,-9.1) P26(17.501,-9.1) P27(18.201,-9.1) P28(18.901,-9.1) P29(19.601,-9.1) P30(20.301,-9.1) P31(21.001,-9.1) P32(21.701,-9.1) P33(22.401,-9.1) P34(23.101,-9.1) P35(23.801,-9.1) P36(24.501,-9.1) P37(25.201,-9.1) P38(25.901,-9.1) P39(26.601,-9.1) P40(27.301,-9.1) P42(28.701,-9.1) P43(29.401,-9.1) P44(30.101,-9.1) P45(30.801,-9.1) P46(31.501,-9.1) P47(32.201,-9.1) P48(32.901,-9.1) P49(33.601,-9.1) P50(34.301,-9.1) P51(35.001,-9.1) P52(35.701,-9.1) R1(0,-9.8) R2(0.7,-9.8) R3(1.4,-9.8) R4(2.1,-9.8) R5(2.8,-9.8) R6(3.5,-9.8) R7(4.2,-9.8) R8(4.9,-9.8) R9(5.6,-9.8) R10(6.3,-9.8) R11(7,-9.8) R13(8.4,-9.8) R14(9.1,-9.8) R15(9.8,-9.8) R16(10.5,-9.8) R17(11.2,-9.8) R18(11.9,-9.8) R19(12.6,-9.8) R20(13.3,-9.8) R21(14,-9.8) R22(14.701,-9.8) R23(15.401,-9.8) R24(16.101,-9.8) R25(16.801,-9.8) R26(17.501,-9.8) R27(18.201,-9.8) R28(18.901,-9.8) R29(19.601,-9.8) R30(20.301,-9.8) R31(21.001,-9.8) R32(21.701,-9.8) R33(22.401,-9.8) R34(23.101,-9.8) R35(23.801,-9.8) R36(24.501,-9.8) R37(25.201,-9.8) R38(25.901,-9.8) R39(26.601,-9.8) R40(27.301,-9.8) R42(28.701,-9.8) R43(29.401,-9.8) R44(30.101,-9.8) R45(30.801,-9.8) R46(31.501,-9.8) R47(32.201,-9.8) R48(32.901,-9.8) R49(33.601,-9.8) R50(34.301,-9.8) R51(35.001,-9.8) R52(35.701,-9.8) T2(0.7,-10.5) T4(2.1,-10.5) T6(3.5,-10.5) T8(4.9,-10.5) T10(6.3,-10.5) T13(8.4,-10.5) T14(9.1,-10.5) T15(9.8,-10.5) T16(10.5,-10.5) T17(11.2,-10.5) T18(11.9,-10.5) T19(12.6,-10.5) T20(13.3,-10.5) T21(14,-10.5) T22(14.701,-10.5) T23(15.401,-10.5) T24(16.101,-10.5) T25(16.801,-10.5) T26(17.501,-10.5) T27(18.201,-10.5) T28(18.901,-10.5) T29(19.601,-10.5) T30(20.301,-10.5) T31(21.001,-10.5) T32(21.701,-10.5) T33(22.401,-10.5) T34(23.101,-10.5) T35(23.801,-10.5) T36(24.501,-10.5) T37(25.201,-10.5) T38(25.901,-10.5) T39(26.601,-10.5) T40(27.301,-10.5) T43(29.401,-10.5) T45(30.801,-10.5) T47(32.201,-10.5) T49(33.601,-10.5) T51(35.001,-10.5) U1(0,-11.2) U2(0.7,-11.2) U3(1.4,-11.2) U4(2.1,-11.2) U5(2.8,-11.2) U6(3.5,-11.2) U7(4.2,-11.2) U8(4.9,-11.2) U9(5.6,-11.2) U10(6.3,-11.2) U11(7,-11.2) U13(8.4,-11.2) U14(9.1,-11.2) U15(9.8,-11.2) U16(10.5,-11.2) U17(11.2,-11.2) U18(11.9,-11.2) U19(12.6,-11.2) U20(13.3,-11.2) U21(14,-11.2) U22(14.701,-11.2) U23(15.401,-11.2) U24(16.101,-11.2) U25(16.801,-11.2) U26(17.501,-11.2) U27(18.201,-11.2) U28(18.901,-11.2) U29(19.601,-11.2) U30(20.301,-11.2) U31(21.001,-11.2) U32(21.701,-11.2) U33(22.401,-11.2) U34(23.101,-11.2) U35(23.801,-11.2) U36(24.501,-11.2) U37(25.201,-11.2) U38(25.901,-11.2) U39(26.601,-11.2) U40(27.301,-11.2) U42(28.701,-11.2) U43(29.401,-11.2) U44(30.101,-11.2) U45(30.801,-11.2) U46(31.501,-11.2) U47(32.201,-11.2) U48(32.901,-11.2) U49(33.601,-11.2) U50(34.301,-11.2) U51(35.001,-11.2) U52(35.701,-11.2) V1(0,-11.9) V2(0.7,-11.9) V3(1.4,-11.9) V4(2.1,-11.9) V5(2.8,-11.9) V6(3.5,-11.9) V7(4.2,-11.9) V8(4.9,-11.9) V9(5.6,-11.9) V10(6.3,-11.9) V11(7,-11.9) V13(8.4,-11.9) V14(9.1,-11.9) V15(9.8,-11.9) V16(10.5,-11.9) V17(11.2,-11.9) V18(11.9,-11.9) V19(12.6,-11.9) V20(13.3,-11.9) V21(14,-11.9) V22(14.701,-11.9) V23(15.401,-11.9) V24(16.101,-11.9) V25(16.801,-11.9) V26(17.501,-11.9) V27(18.201,-11.9) V28(18.901,-11.9) V29(19.601,-11.9) V30(20.301,-11.9) V31(21.001,-11.9) V32(21.701,-11.9) V33(22.401,-11.9) V34(23.101,-11.9) V35(23.801,-11.9) V36(24.501,-11.9) V37(25.201,-11.9) V38(25.901,-11.9) V39(26.601,-11.9) V40(27.301,-11.9) V42(28.701,-11.9) V43(29.401,-11.9) V44(30.101,-11.9) V45(30.801,-11.9) V46(31.501,-11.9) V47(32.201,-11.9) V48(32.901,-11.9) V49(33.601,-11.9) V50(34.301,-11.9) V51(35.001,-11.9) V52(35.701,-11.9) W2(0.7,-12.6) W4(2.1,-12.6) W6(3.5,-12.6) W8(4.9,-12.6) W10(6.3,-12.6) W13(8.4,-12.6) W14(9.1,-12.6) W15(9.8,-12.6) W16(10.5,-12.6) W17(11.2,-12.6) W18(11.9,-12.6) W19(12.6,-12.6) W20(13.3,-12.6) W21(14,-12.6) W22(14.701,-12.6) W23(15.401,-12.6) W24(16.101,-12.6) W25(16.801,-12.6) W26(17.501,-12.6) W27(18.201,-12.6) W28(18.901,-12.6) W29(19.601,-12.6) W30(20.301,-12.6) W31(21.001,-12.6) W32(21.701,-12.6) W33(22.401,-12.6) W34(23.101,-12.6) W35(23.801,-12.6) W36(24.501,-12.6) W37(25.201,-12.6) W38(25.901,-12.6) W39(26.601,-12.6) W40(27.301,-12.6) W43(29.401,-12.6) W45(30.801,-12.6) W47(32.201,-12.6) W49(33.601,-12.6) W51(35.001,-12.6) Y1(0,-13.3) Y2(0.7,-13.3) Y3(1.4,-13.3) Y4(2.1,-13.3) Y5(2.8,-13.3) Y6(3.5,-13.3) Y7(4.2,-13.3) Y8(4.9,-13.3) Y9(5.6,-13.3) Y10(6.3,-13.3) Y11(7,-13.3) Y13(8.4,-13.3) Y14(9.1,-13.3) Y15(9.8,-13.3) Y16(10.5,-13.3) Y17(11.2,-13.3) Y18(11.9,-13.3) Y19(12.6,-13.3) Y20(13.3,-13.3) Y21(14,-13.3) Y22(14.701,-13.3) Y23(15.401,-13.3) Y24(16.101,-13.3) Y25(16.801,-13.3) Y26(17.501,-13.3) Y27(18.201,-13.3) Y28(18.901,-13.3) Y29(19.601,-13.3) Y30(20.301,-13.3) Y31(21.001,-13.3) Y32(21.701,-13.3) Y33(22.401,-13.3) Y34(23.101,-13.3) Y35(23.801,-13.3) Y36(24.501,-13.3) Y37(25.201,-13.3) Y38(25.901,-13.3) Y39(26.601,-13.3) Y40(27.301,-13.3) Y42(28.701,-13.3) Y43(29.401,-13.3) Y44(30.101,-13.3) Y45(30.801,-13.3) Y46(31.501,-13.3) Y47(32.201,-13.3) Y48(32.901,-13.3) Y49(33.601,-13.3) Y50(34.301,-13.3) Y51(35.001,-13.3) Y52(35.701,-13.3)
