# Allegro board LAH351PR10-0509.brd (continued)
## Nets (continued)
HDMI_C_TX_P2: CV1063.1 LV6.4 RV638.1 RX38.1
HDMI_CLKN: JHDMI.12 RV673.2
HDMI_CLKP: JHDMI.10 RV674.2
HDMI_CTRL_CLK: JHDMI.15 RV651.1
HDMI_CTRL_CLK_R: QV96.3 RV649.1 RV651.2
HDMI_CTRL_DAT: JHDMI.16 RV650.1
HDMI_CTRL_DAT_R: QV96.6 RV650.2 RV653.1
HDMI_DOWN: LX1.2 LX2.2 LX3.2 LX4.2 LX5.2 LX6.2 LX7.2 LX8.2 QX1.1
HDMI_HPD: CX2.1 JHDMI.19 RX6.2
HDMI_HPD_PCH: QX3.3 RX8.1 UH1.BD21 UX2.1
HDMI_L_CLKN: LV3.2 RV500.2 RV641.2 RV673.1
HDMI_L_CLKP: LV3.3 RV500.1 RV640.2 RV674.1
HDMI_L_TX_N0: LV4.2 RV27.1 RV501.2 RV643.2
HDMI_L_TX_N1: LV5.2 RV29.1 RV502.2 RV642.2
HDMI_L_TX_N2: LV6.2 RV33.1 RV503.2 RV645.2
HDMI_L_TX_P0: LV4.3 RV28.1 RV501.1 RV646.2
HDMI_L_TX_P1: LV5.3 RV30.1 RV502.1 RV639.2
HDMI_L_TX_P2: LV6.3 RV34.1 RV503.1 RV638.2
HDMI_TX_N0: JHDMI.9 RV27.2
HDMI_TX_N1: JHDMI.6 RV29.2
HDMI_TX_N2: JHDMI.3 RV33.2
HDMI_TX_P0: JHDMI.7 RV28.2
HDMI_TX_P1: JHDMI.4 RV30.2
HDMI_TX_P2: JHDMI.1 RV34.2
HPD_IFPA#: RG523.1 UG1.BG4
HPD_IFPB#: RG524.1 UG1.BG1
HT_EN: RE722.2 UE5.H13
I2C_0_SCL: RE71.1 RPC7.2 UH1.BC22
I2C_0_SCL_R: JTP15.6 JTP17.3 RE71.2
I2C_0_SDA: RE653.1 RPC7.1 UH1.BF23
I2C_0_SDA_R: JTP15.7 JTP17.2 RE653.2
I2C_CLK: RE2.2 RM1.2 UE1.42 UE8.25
I2C_DAT: RE1.2 RM2.2 UE1.43 UE8.26
I2C_INT: DK3.2 JPK.15 RE656.2 UE5.A1
I2CC_SCL: QG7.4 RG28.1 UG1.BG9
I2CC_SDA: QG7.1 RG29.1 UG1.BH9
IDLE_IN_SW: RG1504.1 UG1.BA3
IFP_IOVDD_7: UG1.BC18
IFP_IOVDD_8: UG1.BC20
IFPAB_RSET: RG1502.1 UG1.BD23
IFPCD_RSET: RG1499.1 UG1.BD20
IFPEF_RSET: RG1500.1 UG1.BD17
ILIM_1.0VS_VGAP: PR1103.1 PR1104.1 PU1101.10
ILIM_1PH: PCZ24.2 PRZ1.2 PUZ1.49
ILIM_2PH: PRZ50.1 PUZ1.32
ILIM_4PH: PRZ69.2 PUZ1.7
ILIM_VCCIO: PRH14.1 PRH15.1 PUH2.10
IMON1_NVVDD: PLV01.3 PRV23.2 PRV202.1
IMON2_NVVDD: PLV02.3 PRV10.2 PRV203.1
IMON3_NVVDD: PLV03.3 PRV16.2 PRV204.1
IMON4_NVVDD: PLV04.3 PRV27.2 PRV205.1
IMON5_NVVDD: PLV05.3 PRV15.2 PRV206.1
IMON6_NVVDD: PLV06.3 PRV7.2 PRV207.1
IMON7_NVVDD: PLV07.3 PRV11.2 PRV208.1
IMON8_NVVDD: PLV08.3 PRV14.2 PRV209.1
IMON_1PH: PCZ21.2 PRZ67.2 PUZ1.46
IMON_GPU: PCV8.1 PRV67.2 PUV1.25
IMVP_VR_ON: CE192.2 PRZ20.2 Q7.6 UE5.H5
INTRUDER#: RH531.1 UH1.BB44
ISEN1N_CHG: PRB2.3 PRB21.2
ISEN1P_CHG: PRB2.2 PRB8.2
ISH_GP1: UE5.M2 UH1.BD34
ISH_I2C0_SCL: JGYRO.4 UH1.AG45
ISH_I2C0_SDA: JGYRO.5 UH1.AH46
ISL95338_N003: PCV22.1 PRV105.2
ISL95338_SCL: PRV197.2 PUV3.22
ISL95338_SDA: PRV196.2 PUV3.21
IST_TRIG: TC13.1(TP-1) UC1.E3
JRTC1: PD4.2 PR2.2 QH98.2 RH1599.2
JTAG_TCLK: T10.1(TP-1) UG1.BK24
JTAG_TDI: T12.1(TP-1) UG1.BM23
JTAG_TDO: T13.1(TP-1) UG1.BM24
JTAG_TMS: T11.1(TP-1) UG1.BL23
JTAG_TRST#: RG518.1 T16.1(TP-1) UG1.BL24
LCD_BL_PWM: RG150.1 UG1.BD7
LCD_BLEN: RG525.1 UG1.BA5
LDO_EN: DK3.3 JPK.18 UE10.15
LG1_ISL95338_1: PQV01.8 PQV02.8 PUV3.9
LG2_ISL95338_1: PQV3.8 PQV4.8 PUV3.7
LG_+1VALWP: PQH02.4 PUH1.6
LG_CHG: PQB2.4 PUB1.21
LID_SW#: CE43.1 DE1.1 JIO2.F4 RE70.2 UE5.H1
LPC_GPU: PRV75.2 PRV79.1 PUV1.24
LX1_ISL95338_1: PLV09.1 PLV10.1 PQV01.2 PQV01.5 PQV01.6 PQV01.7 PQV02.2 PQV02.5 PQV02.6 PQV02.7 PRV89.1 PRV93.1 PUV3.10
LX1_NVVDD: PLV01.4 PRV110.1 PUV4.11 PUV4.12
LX2_ISL95338_1: PLV09.2 PLV10.2 PQV3.2 PQV3.5 PQV3.6 PQV3.7 PQV4.2 PQV4.5 PQV4.6 PQV4.7 PRV94.2 PRV224.1 PUV3.6
LX2_NVVDD: PLV02.4 PRV111.1 PUV5.11 PUV5.12
LX3_NVVDD: PLV03.4 PRV132.1 PUV6.11 PUV6.12
LX4_NVVDD: PLV04.4 PRV133.1 PUV7.11 PUV7.12
LX5_NVVDD: PLV05.4 PRV154.1 PUV9.11 PUV9.12
LX6_NVVDD: PLV06.4 PRV155.1 PUV8.11 PUV8.12
LX7_NVVDD: PLV07.4 PRV176.1 PUV10.11 PUV10.12
LX8_NVVDD: PLV08.4 PRV177.1 PUV11.11 PUV11.12
LX_1.0VS_VGAP: PC1109.2 PL1001.1 PR1101.1 PU1101.5 PU1101.15 PU1101.16
LX_3V: PC315.2 PL301.1 PR301.1 PU301.5 PU301.15 PU301.16
LX_5V: PC518.2 PL501.1 PR501.1 PU501.2 PU501.12
LX_+1.8VGS: PC1817.2 PL1802.1 PR1807.1 PU1802.5 PU1802.15 PU1802.16
LX_CHG: PCB8.2 PLB1.1 PQB1.1 PQB1.2 PQB1.3 PQB2.5 PRB3.1 PUB1.22
LX_VCCIO: PCH23.2 PLH02.1 PRH10.1 PUH2.5 PUH2.15 PUH2.16
ME_EN: RH16.1 UE5.C1
ME_SUS_PWR_ACK: RH506.1 UH1.BC37
MEM_VDD_CTL: PRW10.1 UG1.BH4
MEM_VREF_CTL: QG2.2 QG3.2 QG4.2 QG8.2 RG24.1 UG1.BD3
MIC_CLK: JEDP.26 JIO1.D2 RV679.1
MIC_DATA: JEDP.25 JIO1.D1
MODE_SEL: RG1565.1 UG37.26
N17_ID0: RH27.1 RH28.1 UH1.AR18
N17_ID1: RH25.1 RH26.1 UH1.BF14
NB_FGC6: RG21.1 UG1.BE5 UG41.2
NC_B4: RT45.1 RT86.2 UT1.B4
NC_B5: RT46.1 UT1.B5
NC_G2: RT47.1 UT1.G2
NRB_BIT: RH524.2 UH1.BE30
NTC_CHG: PRB30.1 PUB1.17
NTC_LA: PHV01.1 PRV210.2 PRV211.1
NTC_LB: PCV209.2 PCV210.2 PCV211.2 PHV01.2 PRV211.2 PRV212.2 PRV213.2 PRV214.2 PRV215.1 PRV216.1 PRV217.1 PRV218.1 PRV219.1 PRV220.1 PRV221.1 PRV222.1
NVVDD_1: PCV1.2 PLV01.2 PRV215.2
NVVDD_2: PCV14.2 PLV02.2 PRV216.2
NVVDD_3: PCV7.2 PLV03.2 PRV217.2
NVVDD_4: PCV3.2 PLV04.2 PRV218.2
NVVDD_5: PCV16.2 PLV05.2 PRV219.2
NVVDD_6: PCV11.2 PLV06.2 PRV220.2
NVVDD_7: PCV15.2 PLV07.2 PRV221.2
NVVDD_8: PCV9.2 PLV08.2 PRV222.2
NVVDD_B: PLW13.1 PLW14.1 PRV108.4
NVVDD_B+: PCV4.2 PCV48.1 PCV49.1 PCV50.1 PCV51.1 PCV52.1 PCV53.1 PCV54.1 PCV55.1 PCV56.1 PCV57.1 PCV58.1 PCV59.1 PCV68.1 PCV69.1 PCV70.1 PCV71.1 PCV74.1 PCV75.1 PCV76.1 PCV77.1 PCV82.1 PCV83.1 PCV84.1 PCV85.1 PCV86.1 PCV87.1 PCV88.1 PCV89.1 PCV90.1 PCV91.1 PCV92.1 PCV93.1 PCV102.1 PCV103.1 PCV104.1 PCV105.1 PCV112.1 PCV113.1 PCV114.1 PCV115.1 PCV116.1 PCV117.1 PCV118.1 PCV119.1 PCV120.1 PCV121.1 PCV122.1 PCV123.1 PCV132.1 PCV133.1 PCV134.1 PCV135.1 PCV142.1 PCV143.1 PCV144.1 PCV145.1 PCV146.1 PCV147.1 PCV148.1 PCV149.1 PCV150.1 PCV151.1 PCV152.1 PCV153.1 PCV162.1 PCV163.1 PCV164.1 PCV165.1 PCV214.1 PCV215.1 PCV216.1 PCV217.1 PCV218.1 PCV219.1 PCV220.1 PCV221.1 PCV222.1 PCV223.1 PCV224.1 PCV225.1 PCV226.1 PCV227.1 PCV228.1 PCV229.1 PCV230.1 PCV231.1 PCV232.1 PCV233.1 PCV234.1 PCV235.1 PCV236.1 PCV237.1 PLW13.2 PLW14.2 PRV82.1 PUV4.8 PUV4.9 PUV5.8 PUV5.9 PUV6.8 PUV6.9 PUV7.8 PUV7.9 PUV8.8 PUV8.9 PUV9.8 PUV9.9 PUV10.8 PUV10.9 PUV11.8 PUV11.9
NVVDD_EN: PRV198.2
NVVDD_EN_17123971: CG481.1 DG7.1 PQV1.2 PR1105.2 PRV30.2 QG508.2 RG549.2
NVVDD_ENP: RG1555.2 UG42.4
NVVDD_PGOOD: DG4.1 PR1106.2 PRV59.2 PUV1.38 QV3.2 RG1602.1 UG29.2 UG43.2 UG44.1
NVVDD_PSI#: PRV20.2 RG1580.2 RG1595.1
NVVDD_PWM_VID: PRV22.1 UG1.BD6
NVVDD_VCC_SENSE: PRV13.2 UG1.BK45
NVVDD_VSS_SENSE: PRV28.2 UG1.BL45
OC_EN#: RG1610.2 UE5.K9
OC_WARN#: RG522.1 RG1537.2 UG1.BB4
ON/OFF#: CE27.1 JIO2.D2 RE717.1 SW1.2 UE5.G5
OPCN_CHG: PCB18.2 PUB1.28
OSC24M_IN: RE18.2 UE1.5
OSC24M_IN_R: CE2.1 RE3.1 RE18.1 YE1.1
OSC24M_OUT: RE19.2 UE1.6
OSC24M_OUT_R: CE5.1 RE3.2 RE19.1 YE1.3
OVERT#: RG9.1 UG1.BG5 UG23.5
P_SYS: PRB23.1 PRZ62.1 PUZ1.24
PA_USB2_RBIAS: RT43.1 UT1.H19
PB_USB2_RBIAS: RT44.1 UT1.F19
PBTN_OUT#: CH174.1 RH2.2 UE5.F4 UH1.BE46
PCH_ACC1_INT1: QH100.3 R374.1 RH1039.1 UH1.AV34
PCH_ACC1_INT1_C: JGYRO.1 QH100.2 R374.2 RG1615.2
PCH_BATLOW#: RH515.1 RT14.2 UH1.BF44
PCH_CPU_BCLK_N: UC1.A32 UH1.C8
PCH_CPU_BCLK_P: UC1.B31 UH1.B8
PCH_CPU_PCIBCLK_N: UC1.C36 UH1.B6
PCH_CPU_PCIBCLK_P: UC1.D35 UH1.A6
PCH_DP3_CTRL_DATA: RH601.2 UH1.AR3
PCH_DP4_CTRL_DATA: RH602.2 UH1.AN40
PCH_DPWROK: RH90.2 RH1017.1 UH1.AW41
PCH_GYRO_INT2: QH99.3 R373.1 RH1040.1 UH1.AW32
PCH_GYRO_INT2_C: JGYRO.2 QH99.2 R373.2 RG1616.2
PCH_JTAG_TCK: JPCMC.32 RC35.1 UC1.BR28 UH1.AH4
PCH_LCD_TEST: RV682.1 UH1.AP48
PCH_PECI: RH73.1 UH1.AF2
PCH_PLTRST#: UG10.2 UH1.AV29 UH3.1 UH3.2 UM3.2
PCH_PWR_EN: C268.1 PR1811.2 PRH5.1 RE713.1 RH1016.1 U18.4
PCH_PWROK: CE44.1 DE3.2 RE75.1 UE5.N12 UH1.AY42
PCH_RTCRST#: CH53.1 CLRP1.1 QE5.6 RH84.2 UH1.BE47
PCH_RTCX1: CH45.1 RH70.1 UH1.BA49 YH1.1
PCH_RTCX2: CH46.1 RH70.2 UH1.BA48 YH1.2
PCH_SATADET#: RH512.1 UH1.AK48
PCH_SMBCLK: CH253.1 RH463.2 UH1.BE26
PCH_SMBDATA: CH252.1 RH462.2 UH1.BF26
PCH_SML1ALERT#: RH63.2 UH1.BD33
PCH_SPI_0_CLK: RH104.1 UH1.AW47
PCH_SPI_0_CLK_R: CH244.1 RH104.2 UH4.6
PCH_SPI_0_CS#: UH1.AY47 UH4.1
PCH_SPI_0_HOLD#: RH78.2 RPH5.4 UH1.BA46
PCH_SPI_0_HOLD#_R: RPH5.5 UH4.7
PCH_SPI_0_SI: RH1.2 RPH5.2 UH1.AU41
PCH_SPI_0_SI_R: RH489.1 RPH5.7 UH4.5
PCH_SPI_0_SO: RPH5.3 UH1.BA45
PCH_SPI_0_SO_R: RPH5.6 UH4.2
PCH_SPI_0_WP#: RC354.2 RH75.2 RPH5.1 UH1.AY48
PCH_SPI_0_WP#_R: RPH5.8 UH4.3
PCH_SRTCRST#: CH52.1 QE66.3 RH83.2 UH1.BD46
PCH_SYS_PWROK_XDP: RH489.2 RH493.2
PCH_TRIGGER: RH167.1 UH1.AK3
PCH_XDP_CLK_N: T49.1(TP-1) UH1.Y3
PCH_XDP_CLK_P: T50.1(TP-1) UH1.Y4
PCIE_PRX_C_DTX_N17: CT16.2 UT1.V22
PCIE_PRX_C_DTX_N18: CT2.2 UT1.P22
PCIE_PRX_C_DTX_N19: CT108.2 UT1.K22
PCIE_PRX_C_DTX_N20: CT110.2 UT1.F22
PCIE_PRX_C_DTX_P17: CT14.2 UT1.V23
PCIE_PRX_C_DTX_P18: CT12.2 UT1.P23
PCIE_PRX_C_DTX_P19: CT109.2 UT1.K23
PCIE_PRX_C_DTX_P20: CT111.2 UT1.F23
PCIE_PRX_DTX_N9: JSSD3.5 UH1.G36
PCIE_PRX_DTX_N10: JSSD3.17 UH1.K37
PCIE_PRX_DTX_N11: JSSD3.29 UH1.G38
PCIE_PRX_DTX_N12: JSSD3.43 UH1.H42
PCIE_PRX_DTX_N15: JIO1.H7 UH1.F44
PCIE_PRX_DTX_N16: JIO2.G3 UH1.L41
PCIE_PRX_DTX_N17: CT16.1 UH1.K43
PCIE_PRX_DTX_N18: CT2.1 UH1.P41
PCIE_PRX_DTX_N19: CT108.1 UH1.M44
PCIE_PRX_DTX_N20: CT110.1 UH1.R35
PCIE_PRX_DTX_N21: JSSD1.43 UH1.T43
PCIE_PRX_DTX_N22: JSSD1.29 UH1.U40
PCIE_PRX_DTX_N23: JSSD1.17 UH1.W43
PCIE_PRX_DTX_N24: JSSD1.5 UH1.Y40
PCIE_PRX_DTX_P9: JSSD3.7 UH1.F36
PCIE_PRX_DTX_P10: JSSD3.19 UH1.J37
PCIE_PRX_DTX_P11: JSSD3.31 UH1.F39
PCIE_PRX_DTX_P12: JSSD3.41 UH1.J41
PCIE_PRX_DTX_P15: JIO1.H6 UH1.E45
PCIE_PRX_DTX_P16: JIO2.G2 UH1.M40
PCIE_PRX_DTX_P17: CT14.1 UH1.K44
PCIE_PRX_DTX_P18: CT12.1 UH1.R40
PCIE_PRX_DTX_P19: CT109.1 UH1.N42
PCIE_PRX_DTX_P20: CT111.1 UH1.R37
PCIE_PRX_DTX_P21: JSSD1.41 UH1.R44
PCIE_PRX_DTX_P22: JSSD1.31 UH1.U41
PCIE_PRX_DTX_P23: JSSD1.19 UH1.W44
PCIE_PRX_DTX_P24: JSSD1.7 UH1.Y41
PCIE_PTX_C_DRX_N9: CH202.1 JSSD3.11
PCIE_PTX_C_DRX_N10: CH204.1 JSSD3.23
PCIE_PTX_C_DRX_N11: CH207.2 JSSD3.35
PCIE_PTX_C_DRX_N12: CH209.2 JSSD3.47
PCIE_PTX_C_DRX_N17: CH218.1 UT1.Y22
PCIE_PTX_C_DRX_N18: CH220.1 UT1.T22
PCIE_PTX_C_DRX_N19: CH222.1 UT1.M22
PCIE_PTX_C_DRX_N20: CH224.1 UT1.H22
PCIE_PTX_C_DRX_N21: CH210.1 JSSD1.47
PCIE_PTX_C_DRX_N22: CH212.1 JSSD1.35
PCIE_PTX_C_DRX_N23: CH214.2 JSSD1.23
PCIE_PTX_C_DRX_N24: CH216.2 JSSD1.11
PCIE_PTX_C_DRX_P9: CH203.1 JSSD3.13
PCIE_PTX_C_DRX_P10: CH205.1 JSSD3.25
PCIE_PTX_C_DRX_P11: CH206.2 JSSD3.37
PCIE_PTX_C_DRX_P12: CH208.2 JSSD3.49
PCIE_PTX_C_DRX_P17: CH219.1 UT1.Y23
PCIE_PTX_C_DRX_P18: CH221.1 UT1.T23
PCIE_PTX_C_DRX_P19: CH223.1 UT1.M23
PCIE_PTX_C_DRX_P20: CH225.1 UT1.H23
PCIE_PTX_C_DRX_P21: CH211.1 JSSD1.49
PCIE_PTX_C_DRX_P22: CH213.1 JSSD1.37
PCIE_PTX_C_DRX_P23: CH215.2 JSSD1.25
PCIE_PTX_C_DRX_P24: CH217.2 JSSD1.13
PCIE_PTX_DRX_N9: CH202.2 UH1.C34
PCIE_PTX_DRX_N10: CH204.2 UH1.C35
PCIE_PTX_DRX_N11: CH207.1 UH1.B36
PCIE_PTX_DRX_N12: CH209.1 UH1.D38
PCIE_PTX_DRX_N15: JIO1.G3 UH1.B40
PCIE_PTX_DRX_N16: JIO2.H7 UH1.B41
PCIE_PTX_DRX_N17: CH218.2 UH1.A42
PCIE_PTX_DRX_N18: CH220.2 UH1.C42
PCIE_PTX_DRX_N19: CH222.2 UH1.C44
PCIE_PTX_DRX_N20: CH224.2 UH1.A44
PCIE_PTX_DRX_N21: CH210.2 UH1.G47
PCIE_PTX_DRX_N22: CH212.2 UH1.H47
PCIE_PTX_DRX_N23: CH214.1 UH1.G49
PCIE_PTX_DRX_N24: CH216.1 UH1.G46
PCIE_PTX_DRX_P9: CH203.2 UH1.D34
PCIE_PTX_DRX_P10: CH205.2 UH1.B35
PCIE_PTX_DRX_P11: CH206.1 UH1.C36
PCIE_PTX_DRX_P12: CH208.1 UH1.E37
PCIE_PTX_DRX_P15: JIO1.G2 UH1.C40
PCIE_PTX_DRX_P16: JIO2.H6 UH1.C41
PCIE_PTX_DRX_P17: CH219.2 UH1.B42
PCIE_PTX_DRX_P18: CH221.2 UH1.D42
PCIE_PTX_DRX_P19: CH223.2 UH1.D43
PCIE_PTX_DRX_P20: CH225.2 UH1.B44
PCIE_PTX_DRX_P21: CH211.2 UH1.F46
PCIE_PTX_DRX_P22: CH213.2 UH1.H48
PCIE_PTX_DRX_P23: CH215.1 UH1.G48
PCIE_PTX_DRX_P24: CH217.1 UH1.G45
PCIE_RBIAS: RT3.1 UT1.N16
PCIE_RCOMPN: RH193.1 UH1.B12
PCIE_RCOMPP: RH193.2 UH1.A13
PCIE_WAKE#: JIO1.B8 RH4.1 UE5.A13
PCIRST#: JIO1.B3 JIO2.F3 JSSD1.50 JSSD3.50 RE681.1 RH199.1 RT1.2 UH3.4 UT3.1
PCIRST_R#: CE34.1 RE681.2 UE5.M5
PD_EE_CLK: RT101.2 UT4.A3
PD_EE_CS_N: RT100.2 UT4.B3
PD_EE_DI: RT98.2 UT4.B4
PD_EE_DO: RT99.2 UT4.A4
PD_IRQ#: RT107.2 UE5.B4 UT4.B6
PD_RESET: RT109.1 UE10.8
PD_UART: RT62.1 UT4.E2 UT4.F2
PEG_CRX_C_GTX_N0: CC51.1 UG1.BH26
PEG_CRX_C_GTX_N1: CC43.1 UG1.BE26
PEG_CRX_C_GTX_N2: CC44.1 UG1.BG27
PEG_CRX_C_GTX_N3: CC41.1 UG1.BH29
PEG_CRX_C_GTX_N4: CC53.1 UG1.BE29
PEG_CRX_C_GTX_N5: CC40.1 UG1.BG30
PEG_CRX_C_GTX_N6: CC55.1 UG1.BH32
PEG_CRX_C_GTX_N7: CC46.1 UG1.BE32
PEG_CRX_C_GTX_P0: CC50.1 UG1.BG26
PEG_CRX_C_GTX_P1: CC48.1 UG1.BF26
PEG_CRX_C_GTX_P2: CC45.1 UG1.BF27
PEG_CRX_C_GTX_P3: CC49.1 UG1.BG29
PEG_CRX_C_GTX_P4: CC47.1 UG1.BF29
PEG_CRX_C_GTX_P5: CC52.1 UG1.BF30
PEG_CRX_C_GTX_P6: CC42.1 UG1.BG32
PEG_CRX_C_GTX_P7: CC54.1 UG1.BF32
PEG_CRX_C_RD_GTX_N8: CM69.2 UM8.4
PEG_CRX_C_RD_GTX_N9: CM66.2 UM8.8
PEG_CRX_C_RD_GTX_N10: CM62.2 UM8.6
PEG_CRX_C_RD_GTX_N11: CM65.2 UM8.2
PEG_CRX_C_RD_GTX_P8: CM67.2 UM8.3
PEG_CRX_C_RD_GTX_P9: CM63.2 UM8.7
PEG_CRX_C_RD_GTX_P10: CM68.2 UM8.5
PEG_CRX_C_RD_GTX_P11: CM64.2 UM8.1
PEG_CRX_GTX_N0: CC51.2 UC1.E10
PEG_CRX_GTX_N1: CC43.2 UC1.E11
PEG_CRX_GTX_N2: CC44.2 UC1.E12
PEG_CRX_GTX_N3: CC41.2 UC1.E13
PEG_CRX_GTX_N4: CC53.2 UC1.E14
PEG_CRX_GTX_N5: CC40.2 UC1.E15
PEG_CRX_GTX_N6: CC55.2 UC1.E16
PEG_CRX_GTX_N7: CC46.2 UC1.E17
PEG_CRX_GTX_N8: CM69.1 UC1.F18
PEG_CRX_GTX_N9: CM66.1 UC1.D19
PEG_CRX_GTX_N10: CM62.1 UC1.F20
PEG_CRX_GTX_N11: CM65.1 UC1.D21
PEG_CRX_GTX_P0: CC50.2 UC1.F10
PEG_CRX_GTX_P1: CC48.2 UC1.D11
PEG_CRX_GTX_P2: CC45.2 UC1.F12
PEG_CRX_GTX_P3: CC49.2 UC1.D13
PEG_CRX_GTX_P4: CC47.2 UC1.F14
PEG_CRX_GTX_P5: CC52.2 UC1.D15
PEG_CRX_GTX_P6: CC42.2 UC1.F16
PEG_CRX_GTX_P7: CC54.2 UC1.D17
PEG_CRX_GTX_P8: CM67.1 UC1.E18
PEG_CRX_GTX_P9: CM63.1 UC1.E19
PEG_CRX_GTX_P10: CM68.1 UC1.E20
PEG_CRX_GTX_P11: CM64.1 UC1.E21
PEG_CRX_RD_GTX_N8: JCDRA.16 UM8.42
PEG_CRX_RD_GTX_N9: JCDRA.19 UM8.37
PEG_CRX_RD_GTX_N10: JCDRA.25 UM8.39
PEG_CRX_RD_GTX_N11: JCDRA.31 UM8.44
PEG_CRX_RD_GTX_P8: JCDRA.15 UM8.43
PEG_CRX_RD_GTX_P9: JCDRA.18 UM8.38
PEG_CRX_RD_GTX_P10: JCDRA.24 UM8.40
PEG_CRX_RD_GTX_P11: JCDRA.30 UM8.45
PEG_CTX_C_GRX_N0: CC1.2 UG1.BK27
PEG_CTX_C_GRX_N1: CC2.2 UG1.BL29
PEG_CTX_C_GRX_N2: CC3.2 UG1.BM30
PEG_CTX_C_GRX_N3: CC4.2 UG1.BK30
PEG_CTX_C_GRX_N4: CC5.2 UG1.BL32
PEG_CTX_C_GRX_N5: CC6.2 UG1.BM33
PEG_CTX_C_GRX_N6: CC7.2 UG1.BK33
PEG_CTX_C_GRX_N7: CC8.2 UG1.BL35
PEG_CTX_C_GRX_N8: CC9.2 JCDRA.4
PEG_CTX_C_GRX_N9: CC10.2 JCDRA.7
PEG_CTX_C_GRX_N10: CC11.2 JCDRA.10
PEG_CTX_C_GRX_N11: CC12.2 JCDRA.13
PEG_CTX_C_GRX_P0: CC13.2 UG1.BL27
PEG_CTX_C_GRX_P1: CC14.2 UG1.BK29
PEG_CTX_C_GRX_P2: CC15.2 UG1.BM29
PEG_CTX_C_GRX_P3: CC16.2 UG1.BL30
PEG_CTX_C_GRX_P4: CC17.2 UG1.BK32
PEG_CTX_C_GRX_P5: CC18.2 UG1.BM32
PEG_CTX_C_GRX_P6: CC19.2 UG1.BL33
PEG_CTX_C_GRX_P7: CC20.2 UG1.BK35
PEG_CTX_C_GRX_P8: CC21.2 JCDRA.3
PEG_CTX_C_GRX_P9: CC22.2 JCDRA.6
PEG_CTX_C_GRX_P10: CC23.2 JCDRA.9
PEG_CTX_C_GRX_P11: CC24.2 JCDRA.12
PEG_CTX_GRX_N0: CC1.1 UC1.B10
PEG_CTX_GRX_N1: CC2.1 UC1.B11
PEG_CTX_GRX_N2: CC3.1 UC1.B12
PEG_CTX_GRX_N3: CC4.1 UC1.B13
PEG_CTX_GRX_N4: CC5.1 UC1.B14
PEG_CTX_GRX_N5: CC6.1 UC1.B15
PEG_CTX_GRX_N6: CC7.1 UC1.B16
PEG_CTX_GRX_N7: CC8.1 UC1.B17
PEG_CTX_GRX_N8: CC9.1 UC1.C18
PEG_CTX_GRX_N9: CC10.1 UC1.A19
PEG_CTX_GRX_N10: CC11.1 UC1.C20
PEG_CTX_GRX_N11: CC12.1 UC1.A21
PEG_CTX_GRX_P0: CC13.1 UC1.C10
PEG_CTX_GRX_P1: CC14.1 UC1.A11
PEG_CTX_GRX_P2: CC15.1 UC1.C12
PEG_CTX_GRX_P3: CC16.1 UC1.A13
PEG_CTX_GRX_P4: CC17.1 UC1.C14
PEG_CTX_GRX_P5: CC18.1 UC1.A15
PEG_CTX_GRX_P6: CC19.1 UC1.C16
PEG_CTX_GRX_P7: CC20.1 UC1.A17
PEG_CTX_GRX_P8: CC21.1 UC1.B18
PEG_CTX_GRX_P9: CC22.1 UC1.B19
PEG_CTX_GRX_P10: CC23.1 UC1.B20
PEG_CTX_GRX_P11: CC24.1 UC1.B21
PEG_RCOMP: RC2.2 UC1.G2
PEX_RST#: RG3.2 RG1522.1 UG10.1 UH1.BB16
PEX_TERMP: RG23.2 UG1.BL44
PEX_VDD_ENP: CG7107.1 PC1113.1 PR1105.1 PR1106.1 PR1109.1 PU1101.9 QG524.2 RG1521.2
PEX_VDD_RC_ENP: CG7094.1 DG10.1 RG1512.2 UG47.1
PEX_WAKE#: T14.1(TP-1) UG1.BK44
PGOOD_1.2V: PRM10.2 PUM1.10
PLTRST_CPU#: CH195.1 UC1.BP35 UH1.AG5
PM_SLP_S3#: PQB18.2 Q8.2 QE1.5 RE679.1 UH1.BF42
PM_SLP_S3_H: Q7.2 Q7.5 Q8.5 Q8.6 R307.2
PM_SLP_S3_R#: CE41.1 RE679.2 UE5.J5
PM_SLP_S4#: PR2501.1 Q9.2 RE680.1 UH1.BE42
PM_SLP_S4_H: Q9.5 Q9.6 R325.2
PM_SLP_S4_R#: RE680.2 UE5.B6
PM_SLP_S5#: QE4.5 RE678.1 UH1.BC42
PM_SLP_S5_R#: CE45.1 RE678.2 UE5.F1
POK: DE2.1 DE3.1 PR304.2 PR509.2 PU301.7 PU501.4
POWER_LED: QE4.6 QE8.2 RE28.2
PROC_DETECT#: RH519.1 UH1.AP41
PROC_SELECT#: RE716.2 UC1.BN1
PROCHOT#_CHG: PRB17.2 PUB1.5
PROG_CHG: PRB37.1 PUB1.9
PROG_ISL95338_1: PRV104.2 PUV3.27
PS_ID: PR3.1 PR4.2 UE5.K6
PSI_FBVDDQ: PRW3.1 PRW24.2 PUW1.3 RG1584.2 RG1596.1
PSI_GPU: PRV18.2 PRV20.1 PRV26.2 PUV1.37
PSID: PJPDC1.11 PL13.1
PSID-1: PQ1.2 PR6.1 PR9.2
PSID-2: PQ1.1 PQ4.2 PR8.2
PSID-3: PQ4.3 PR4.1
PSID-4: PD1.3 PL13.2 PQ4.1 PR6.2
PSYS_CHG: PRB23.2 PRB33.1 PUB1.8
PTP_LID_CLOSE#: JTP15.3 JTP17.6 RE33.2 UE10.17
PWM1_1PH/ICCMAX1: PRZ70.1 PUA1.1 PUZ1.44
PWM1_2PH/ICCMAX2: PRZ65.1 PUG01.1 PUZ1.23
PWM1_4PH/ICCMAX4: PRZ48.1 PUZ1.18 PUZ4.7
PWM1_A: PUZ3.1 PUZ4.14
PWM1_B: PUZ2.1 PUZ4.15
PWM1_FBVDDQ: PRW12.2 PUW2.1
PWM1_FBVDDQ_R: PRW12.1 PUW1.20
PWM2_2PH/ROSC1: PRZ77.1 PUZ1.22
PWM2_4PH/ADDR: PRZ2.1 PUZ1.19 PUZ7.7
PWM2_A: PUZ6.1 PUZ7.14
PWM2_B: PUZ5.1 PUZ7.15
PWM2_FBVDDQ: PRW11.2 PUW3.1
PWM2_FBVDDQ_R: PRW11.1 PUW1.19
PWM3_4PH/VBOOT: PRZ63.1 PUZ1.20 PUZ10.7
PWM3_A: PUZ8.1 PUZ10.14
PWM3_B: PUZ9.1 PUZ10.15
PWM4_4PH/ROSC_MPH: PRZ78.1 PUZ1.21
PWR_B#: JIO2.A10 QE13.3 RE154.2 RE160.1
PWR_B_7313#: QE13.4 UE8.14
PWR_B_EC: QE13.2 RE1616.1 UE5.G9
PWR_G#: JIO2.H10 QE21.3 RE155.1 RE156.2
PWR_G_7313#: QE21.4 UE8.11
PWR_LED#: QE4.2 UE5.A3
PWR_R#: JIO2.A9 QE22.3 RE157.1 RE158.2
PWR_R_7313#: QE22.4 UE8.10
PWR_R_EC: QE22.2 RE1615.1 UE5.E13
PWR_SRC_ON: CV15.2 QV1.3 RV9.2 RV12.1
PWRSHARE_EN_EC#: JIO1.A1 UE5.F12
QPCP_CHG: PCB18.1 PUB1.27
RASTER_SYNC1: RG527.1 UG1.BG3
REF_ISL95338_1: PCV41.1 PUV3.29
REFADJ_GPU: PRV81.1 PUV1.40
REFIN_FBVDDQ: PCW7.1 PRW4.1 PRW22.2 PRW29.1 PUW1.6
REFIN_GPU: PRV2.1 PRV69.1 PUV1.1
REFOUT_FBVDDQ: PCW1.1 PRW60.1 PUW1.12
REFOUT_GPU: PRV213.1 PUV1.23
REMOTE1+: C2500.1 C2502.1 Q2407.1 Q2407.2 U2407.2
REMOTE1-: C2500.2 C2502.2 Q2407.3 R184.1
REMOTE2+: C2504.1 C2505.1 Q2408.1 Q2408.2 U2407.4
REMOTE2-: C2504.2 C2505.2 Q2408.3 R184.2 U2407.3
REMOTE3+: C2510.1 C2511.1 Q2411.1 Q2411.2 U2407.5
REMOTE3-: C2510.2 C2511.2 Q2411.3 R185.2
RESET_N: RT102.1 UT4.F11
RF_+1VALWP: PRH6.1 PUH1.5
ROM_CS#: RG75.1 UG1.BJ4
ROM_CS#_R: RG74.2 RG75.2 UG34.1
ROM_SCLK: RG100.1 UG1.BK3
ROM_SI: RG77.2 RG84.1 RG87.2 UG1.BK2
ROM_SO: RG76.1 RG85.1 RG88.2 UG1.BK4
RPD_G1: RT64.1 UT4.K9
RPD_G2: RT65.1 UT4.K10
RTC_CELL: QE58.2 RE662.1 UE10.22
RTC_DET: RE724.2 UH1.BE21
RTD3_CIO_PWR_EN: RT16.2 UH1.AE43
RTD3_CIO_PWR_EN_R: RT16.1 RT36.2 RT727.1 UT1.F1
RTD3_USB_PWR_EN: RT12.2 UH1.BF21
RTD3_USB_PWR_EN_R: RT12.1 RT37.1 UT1.D4
SA_SW: PLG02.1 PRA2.1 PUA1.11 PUA1.12
SATA_GP1: JSSD3.69 R364.1 UH1.AJ43
SATA_GP4: JSSD1.69 R363.1 UH1.AM46
SCL_CHG: PRB16.2 PUB1.4
SCL_GPU: PRV37.1 PRV52.2 PUV1.35 QG7.3
SD_RCOMP_1P8: RH214.1 UH1.BE5
SD_RCOMP_3P3: RH215.1 UH1.BE4
SDA_CHG: PRB20.2 PUB1.3
SDA_GPU: PRV31.1 PRV53.2 PUV1.34 QG7.6
SENSE_VCCIO: PRH12.1 PRH16.2 PRH20.2
SH_IN_N3: RG1571.2 UG37.13
SH_IN_N4: RG1573.2 UG37.16
SH_IN_P3: RG1570.2 UG37.12
SH_IN_P4: RG1572.2 UG37.15
SH_O1: CG7120.1 RG1563.2 UG37.32
SH_O2: CG7121.1 RG1564.2 UG37.7
SKIP: RG135.1 UG37.25
SLP_S3: QE1.3 RE15.2 UE1.12
SLP_S5: QE4.3 RE16.2 UE1.11
SM_PG_CTRL: PRM7.2 RH525.2 UC2.4
SMBALERT#: RH95.2 UH1.BE25
SML0ALERT#: RH1035.2 UH1.BF24
SML0CLK: CH249.1 RH501.2 UH1.BF25 UM4.11
SML0DATA: CH248.1 RH502.2 UH1.BE24 UM4.10
SML1CLK: CH251.1 QH5.6 RH460.2 UH1.BF27
SML1DATA: CH250.1 QH5.3 RH461.2 UH1.BE27
SMOD1: PRV117.1 PUV4.2
SMOD2: PRV126.1 PUV5.2
SMOD3: PRV151.1 PUV6.2
SMOD4: PRV139.1 PUV7.2
SMOD5: PRV172.1 PUV9.2
SMOD6: PRV170.1 PUV8.2
SMOD7: PRV193.1 PUV10.2
SMOD8: PRV187.1 PUV11.2
SNB1_NVVDD: PCV63.1 PRV110.2
SNB2_NVVDD: PCV62.1 PRV111.2
SNB3_NVVDD: PCV96.1 PRV132.2
SNB4_NVVDD: PCV97.1 PRV133.2
SNB5_NVVDD: PCV127.1 PRV154.2
SNB6_NVVDD: PCV126.1 PRV155.2
SNB7_NVVDD: PCV156.1 PRV176.2
SNB8_NVVDD: PCV157.1 PRV177.2
SNB_1.0VS_VGAP: PC1112.1 PR1101.2
SNB_1.2V: PCM15.1 PRM1.2
SNB_+1.8VGS: PC1820.1 PR1807.2
SNB_+1VALWP: PCH8.1 PRH1.2
SNB_VCCIO: PCH22.1 PRH10.2
SPI_CLK: RE11.2 UE1.15
SPI_CS#: RE12.2 UE1.14 UE2.1
SPI_MISO: RE10.2 UE1.16
SPI_MOSI: RE9.2 UE1.17
SPK_SEL: JIO1.E2 RE201.2 UE5.J9
STRAP0: RG78.1 RG90.2 UG1.BL3
STRAP1: RG79.1 RG91.2 UG1.BL4
STRAP2: RG80.1 RG92.2 UG1.BM4
STRAP3: DG8.2 RG81.1 RG93.2 UG1.BM5
STRAP3_PCH: DG8.1 UH1.M45
STRAP4: RG82.1 RG94.2 UG1.BK5
STRAP5: DG9.2 RG83.1 RG95.2 RG1495.2 UG1.BJ5
STRAP5_PCH: DG9.1 UH1.L48
SUSACK#: RH1016.2 UH1.BE35
SUSCLK: JIO2.F1 JSSD1.68 JSSD3.68 UH1.BE45
SUSP#: JIO1.F2 PRH13.2 PRM6.2 Q8.3 R174.1 R182.1 RT15.2 U16.4 U20.4 UE5.G4 UZ21.3 UZ45.3
SUSP#_R: RT15.1 RT30.2 UT1.D2
SW1_2PH: PLG01.2 PRZ15.2 PRZ59.2
SW1_FBVDDQ: PRW2.2 PRW40.2
SW1_FBVDDQ_R: PLW01.2 PRW40.1 PRW58.1
SW2_FBVDDQ: PRW1.2 PRW51.2
SW2_FBVDDQ_R: PLW02.2 PRW51.1 PRW59.1
SW_1.2V: PCM12.2 PLM01.2 PQM01.1 PQM01.2 PQM01.3 PQM02.5 PRM1.1 PUM1.16
SW_1PH: PLG02.2 PRZ11.2
SW_+1VALWP: PCH5.2 PLH01.1 PQH01.1 PQH01.2 PQH01.3 PQH02.5 PRH1.1 PUH1.8
SWAPRDY_IN: RG526.1 UG1.BB6
SWTRAP: RE684.2 RE685.1 UE5.A9
SYS_PWROK: CE46.1 UE5.B7 UH1.AU3
SYS_RESET#: CH175.1 RH5.2 RH571.1 UH1.AU2
SYS_SWCLK: JELC2.4 UE1.37
SYS_SWDIO: JELC2.2 UE1.34
SYSON: CE191.2 PRM5.1 Q9.3 U19.4 UE5.B2
TBT_A_AUX_N: CT44.2 UT1.W15
TBT_A_AUX_N_C: CT44.1 RT70.2 UT4.J2
TBT_A_AUX_P: CT43.2 UT1.Y15
TBT_A_AUX_P_C: CT43.1 RT73.1 UT4.J1
TBT_A_CC1: CT112.1 DT11.1 JUSBC.B5 UT4.L9
TBT_A_CC2: CT113.1 DT12.1 JUSBC.A5 UT4.L10
TBT_A_SBU1: DT13.1 JUSBC.B8 UT4.K8
TBT_A_SBU2: DT14.1 JUSBC.A8 UT4.L8
TBT_A_TRX_DTX_N0: DT5.1 JUSBC.A10 UT1.A21
TBT_A_TRX_DTX_N1: DT9.1 JUSBC.B10 UT1.B15
TBT_A_TRX_DTX_P0: DT4.1 JUSBC.A11 UT1.B21
TBT_A_TRX_DTX_P1: DT8.1 JUSBC.B11 UT1.A15
TBT_A_TTX_C_DRX_N0: CT42.1 DT3.1 JUSBC.B3
TBT_A_TTX_C_DRX_N1: CT40.1 DT7.1 JUSBC.A3
TBT_A_TTX_C_DRX_P0: CT41.1 DT2.1 JUSBC.B2
TBT_A_TTX_C_DRX_P1: CT39.1 DT6.1 JUSBC.A2
TBT_A_TTX_DRX_N0: CT42.2 UT1.B19
TBT_A_TTX_DRX_N1: CT40.2 UT1.B17
TBT_A_TTX_DRX_P0: CT41.2 UT1.A19
TBT_A_TTX_DRX_P1: CT39.2 UT1.A17
TBT_A_USB20_L_NB: DT10.4 DT10.7 JUSBC.A7 LT3.3
TBT_A_USB20_L_NT: DT10.1 DT10.9 JUSBC.B7 LT2.3
TBT_A_USB20_L_PB: DT10.5 DT10.6 JUSBC.A6 LT3.2
TBT_A_USB20_L_PT: DT10.2 DT10.8 JUSBC.B6 LT2.2
TBT_A_USB20_N: RT112.1 UT1.D20
TBT_A_USB20_NB: LT3.4 UT4.L7
TBT_A_USB20_NT: LT2.4 UT4.L6
TBT_A_USB20_P: RT113.1 UT1.E20
TBT_A_USB20_PB: LT3.1 UT4.K7
TBT_A_USB20_PT: LT2.1 UT4.K6
TBT_CIO_PLUG_EVENT#: RT29.2 UH1.AV21 UT1.W2
TBT_EE_CLK: CH247.1 RT52.2 RT101.1 UT2.6
TBT_EE_CLK_R: RT52.1 UT1.AB4
TBT_EE_CS_N: RT50.2 RT100.1 UT1.AC3 UT2.1
TBT_EE_DI: RT98.1 UT1.AB3 UT2.5
TBT_EE_DO: RT49.2 RT99.1 UT1.AC4 UT2.2
TBT_EE_WP_N: RT48.2 UT1.V1 UT2.3
TBT_FORCE_PWR: RT13.2 UH1.Y47
TBT_FORCE_PWR_R: RT13.1 RT35.1 RT94.2 UT1.H4
TBT_HOLD_N: RT51.2 UT2.7
TBT_I2C_SCL: RT27.2 RT721.1 UT1.U2
TBT_I2C_SCL_R: RT721.2 UT4.D2
TBT_I2C_SDA: RT26.2 RT720.1 UT1.U1
TBT_I2C_SDA_R: RT720.2 UT4.D1
TBT_PCIE_WAKE#: RT10.2 UE5.M1
TBT_PCIE_WAKE_N: RT10.1 RT28.2 RT694.1 UT1.W1
TBT_RBIAS: RT25.1 UT1.H6
TBT_RESET_N: RT23.1 RT80.1 RT102.2 UT1.F4
TBT_RESET_N_EC: RT23.2 UE10.19
TBT_RSENSE: RT25.2 UT1.J6
TBT_RST#_R: RT1.1 RT693.1 RT723.2 UT1.L4 UT3.4
TBT_RTD3_RST#: RT695.2 UH1.AM48 UT3.2
TBT_S5_OFF#: CT123.1 UE10.21 UT8.4
TBT_SRC_CFG1: RT11.1 UT1.AA1
TBT_SRC_HPD: RT4.1 UT1.G1
TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
TBT_TCK: RT7.2 UT1.T4
TBT_TDI: RT9.2 UT1.Y4
TBT_TDO: RT6.2 UT1.W4
TBT_TEST_EN: RT17.1 UT1.E1
TBT_TEST_PWG: RT18.1 UT1.AB5
TBT_TMS: RT8.2 UT1.V4
TBT_TMU_CLK_OUT: RT34.1 T2.1(TP-1) UT1.V2
TBT_XTAL_25_IN: RT116.1 UT1.D22
TBT_XTAL_25_OUT: RT117.1 UT1.D23
TBTA_DEBUG1: RT71.1 UT4.L2
TBTA_DEBUG2: RT72.1 UT4.K2
TBTA_DIG_AUD_N: RT69.1 UT4.K3
TBTA_DIG_AUD_P: RT68.1 UT4.L3
TBTA_HPD: RT41.1 UT1.M4 UT4.C10
TBTA_I2C_INT: RT32.2 RT722.1 UT1.J4
TBTA_I2C_INT_R: RT722.2 UT4.C1
TBTA_I2C_SCL1_R: RT60.2 UT4.B5
TBTA_I2C_SDA1_R: RT59.2 UT4.A5
TBTA_LDO_BMC: CT98.1 UT4.E1
TBTA_LSRX: RT42.1 UT1.A4 UT4.K4
TBTA_LSTX: RT21.2 RT40.1 UT1.A5 UT4.L4
TBTA_MRESET: RT63.1 UT4.E11
TBTA_ROSC: RT75.1 UT4.G2
TBTB_I2C_INT: RT33.2 UT1.E2
THERM_ALERT#: RG504.2 UG1.BJ3
THERMDA: UT1.AB23 UT1.AC23
TOBII_INT#: JTOBII.6 RE651.2 RE709.1
TOBII_PWR_EN#: CE79.1 RE652.2 UE5.H12 UE12.4
TON_1.2V: PRM18.2 PUM1.9
TP_CLK: RE100.2 RE654.1 UE5.A5
TP_CLK_R: JTP15.1 JTP17.8 RE654.2
TP_DATA: RE101.2 RE655.1 UE5.B5
TP_DATA_R: JTP15.2 JTP17.7 RE655.2
TP_EN: CT114.1 QT2.2 UE5.D9 UT5.3
TP_INT#: JTP15.4 JTP17.5 RE661.2 UE5.M6 UH1.BE15
TRIP_+1VALWP: PRH8.2 PUH1.2
TRON_BOT_B_DRV#: JPTRON.10 UE8.9
TRON_BOT_G_DRV#: JPTRON.9 UE8.8
TRON_BOT_R_DRV#: JPTRON.8 UE8.6
TRON_TOP_B_DRV#: JPTRON.4 UE8.5
TRON_TOP_G_DRV#: JPTRON.3 UE8.4
TRON_TOP_R_DRV#: JPTRON.2 UE8.3
TSENSE_2PH: PCZ5.1 PRZ21.1 PUZ1.25
TSENSE_4PH: PCZ3.1 PRZ23.1 PUZ1.14
TSENSE_GPU: PRV223.1 PUV1.33
UART_2_PRXD_DTXD: JWDB.3 RC62.1 UH1.BD20
UART_2_PTXD_DRXD: JWDB.2 JWDB1.3 RC63.1 UH1.BE20
UD1_ISL95338_1: PC2510.1 PC2511.1 PC2520.1 PC2521.1 PCV26.1 PCV30.1 PCV31.1 PCV33.1 PCV43.1 PCV238.1 PCV239.1 PCV240.1 PCV241.1 PLW12.2 PQV01.3 PQV01.4 PQV01.9 PQV02.3 PQV02.4 PQV02.9 PRV90.1 PRV92.1 PUV3.14 PUV3.15
UG1_ISL95338_1: PQV01.1 PQV02.1 PUV3.11
UG2_ISL95338_1: PQV3.1 PQV4.1 PUV3.5
UG_+1VALWP: PQH01.4 PUH1.9
UG_CHG: PRB13.1 PUB1.23
UG_CHG_R: PQB1.4 PRB13.2
USB2_COMP: RH109.1 UH1.F4
USB3_PRX_C_DTX_N8: CI38.2 JCDRA.36
USB3_PRX_C_DTX_P8: CI39.2 JCDRA.37
USB3_PRX_DTX_N5: JIO2.B6 UH1.J13
USB3_PRX_DTX_N6: JIO2.A4 UH1.F14
USB3_PRX_DTX_N7: JIO1.H4 UH1.G17
USB3_PRX_DTX_N8: CI38.1 UH1.R21
USB3_PRX_DTX_P5: JIO2.B5 UH1.K13
USB3_PRX_DTX_P6: JIO2.A3 UH1.G14
USB3_PRX_DTX_P7: JIO1.H3 UH1.F16
USB3_PRX_DTX_P8: CI39.1 UH1.P21
USB3_PTX_DRX_N5: JIO2.B3 UH1.C15
USB3_PTX_DRX_N6: JIO2.G9 UH1.C16
USB3_PTX_DRX_N7: JIO1.A7 UH1.A17
USB3_PTX_DRX_N8: JCDRA.42 UH1.B18
USB3_PTX_DRX_P5: JIO2.B2 UH1.B15
USB3_PTX_DRX_P6: JIO2.G8 UH1.C17
USB3_PTX_DRX_P7: JIO1.A6 UH1.B17
USB3_PTX_DRX_P8: JCDRA.43 UH1.C18
USB20_N1: JIO1.A4 UH1.J3
USB20_N2: JIO2.A6 UH1.N13
USB20_N3: LM1.1 UH1.K4
USB20_N3_R: JCDRA.40 LM1.2
USB20_N4: UE1.32 UH1.M10
USB20_N7: LV2.1 UH1.L4
USB20_N7_R: DV4.3 JEDP.17 LV2.2
USB20_N8: JIO2.B8 UH1.G4
USB20_N9: LE3.4 RE647.1 UH1.M6
USB20_N9_R: JTOBII.3 LE3.3 RE647.2
USB20_N10: LE7.4 RE200.1 UH1.H3
USB20_N10_R: DK1.2 JPK.10 LE7.3 RE200.2
USB20_N11: RT114.1 UH1.R10
USB20_N11_R: RT112.2 RT114.2 UT4.K5
USB20_N14: JIO2.H4 UH1.E5
USB20_P1: JIO1.A3 UH1.J2
USB20_P2: JIO2.A7 UH1.N15
USB20_P3: LM1.4 UH1.K3
USB20_P3_R: JCDRA.39 LM1.3
USB20_P4: UE1.33 UH1.L9
USB20_P7: LV2.4 UH1.L3
USB20_P7_R: DV4.2 JEDP.18 LV2.3
USB20_P8: JIO2.B9 UH1.G5
USB20_P9: LE3.1 RE648.1 UH1.N8
USB20_P9_R: JTOBII.4 LE3.2 RE648.2
USB20_P10: LE7.1 RE202.1 UH1.H2
USB20_P10_R: DK1.3 JPK.11 LE7.2 RE202.2
USB20_P11: RT115.1 UH1.P9
USB20_P11_R: RT113.2 RT115.2 UT4.L5
USB20_P14: JIO2.H3 UH1.F6
USB_DVDD1: RG1505.1 UG1.BB15
USB_DVDD2: RG1506.1 UG1.BC15
USB_HVDD1: RG1507.1 UG1.AW10
USB_HVDD2: RG1508.1 UG1.AW11
USB_OC0#: JIO1.B9 RH1019.1 UH1.AH36
USB_OC1#: JIO2.C1 RH1020.1 UH1.AL40
USB_PWR_EN1: JIO2.A1 RE645.1 UE5.G10
USB_VDDP: RG1509.1 UG1.BE12
USBCHG_DET#: CU27.2 CU28.1 DU6.2 JIO1.B6 RU4.2
USBCHG_DET_D: PD502.3 RU6.1 UU5.4
USBCHG_DET_EC#: CU29.1 DU6.1 RU6.2 UE5.D8
VCIN0_PH1: PH01.1 PR24.1 PR25.1 UE5.C2
VCIN1_AC_IN: CE189.2 DH1.1 PRB31.2 PRB34.1 PUB1.2 QE3.5 UE5.F5
VCIN1_ADP_PROCHOT: PC13.2 PR23.1 PR26.2 UE5.D2
VCIN_ BATT_TEMP: CE190.2 PC14.1 PCB27.1 PD3.2 PR16.1 PR22.2 PRB28.2 UE5.B13
VCOUT0_MAIN_PWR_ON#: PR504.1 UE5.E4
VCOUT1_PROCHOT#: RE84.2 RE85.2 UE5.E2
VDOP_CHG: PCB23.1 PRB9.2 PUB1.20
VGA_EN: RM14.2 RM87.1 UM8.26
VGA_SMB_CK2: QG6.4 RG17.1 UG1.BJ8
VGA_SMB_DA2: QG6.1 RG18.1 UG1.BH8
VID_GPU: PRV22.2 PUV1.39
VOUT1_FBVDDQ: PCW4.2 PCW8.1 PRW8.2 PRW18.2 PRW39.2
VOUT1_FBVDDQ_R: PCW41.2 PLW01.3 PRW39.1
VOUT2_FBVDDQ: PCW2.2 PCW9.1 PRW14.2 PRW17.2 PRW50.2
VOUT2_FBVDDQ_R: PCW43.2 PLW02.3 PRW50.1
VOUT_ISL95338_1: PRV97.1 PUV3.31
VOUT_S: PCV6.2 PRV13.1 PRV34.1 PRV40.1 PRV45.1
VOUTS_ISL95338_1: PRV95.1 PUV3.3
VR_PWRGD: CE194.2 PCZ251.2 PRZ40.2 PUZ1.45 UE5.D1
VR_SVID_ALERT#: PRZ6.2 PRZ17.1 RH152.2 RH153.1
VR_SVID_CLK: PRZ7.2 PRZ10.2 UC1.BH32
VR_SVID_DATA: PRZ5.2 PRZ35.1 RH151.2 UC1.BH29
VREF_FBVDDQ: PCW6.1 PRW22.1 PRW32.1 PUW1.7
VROM_SEL: RH588.2 RH589.2
VSN_1PH: PCZ31.2 PRZ27.2 PUZ1.51
VSN_2PH: PCZ32.1 PRZ51.1 PUZ1.37
VSN_4PH: PCZ33.2 PRZ52.2 PUZ1.2
VSP_1PH: PCZ28.2 PRZ148.2 PUZ1.52
VSP_2PH: PCZ29.1 PRZ19.1 PUZ1.38
VSP_4PH: PCZ25.2 PRZ18.2 PUZ1.1
VTTREF_1.2V: PCM16.1 PUM1.4
WAKE#: RH4.2 RH453.1 UH1.BB47
WAKE_PCH#: RH545.1 UH1.BG44
WL_OFF#: JIO2.H1 RH520.2 UH1.AP24
XCLK_BIASREF: RH71.2 RH590.2 UH1.T3
XDP_HOOK0: JPCMC.27 RC355.1
XDP_ITP_PMODE: JPCMC.26 RC353.2 UH1.AL3
XDP_PRDY#: JPCMC.34 UC1.BP27 UH1.AM5
XDP_PREQ#: JPCMC.33 RH156.2 UC1.BL30 UH1.AL2
XDP_SPI_IO2: JPCMC.24 RC354.1
XDP_SPI_SI: JPCMC.25 RC9.2 RH1.1
XDP_TCK: JPCMC.31 RC348.1 UH1.AJ3
XDP_TDI: JPCMC.29 RH495.2 UC1.BL32 UH1.AH2
XDP_TDO: JPCMC.35 RH496.2 UC1.BT28 UH1.AH3
XDP_TMS: JPCMC.30 RH494.2 UC1.BP28 UH1.AJ4
XMP1: PRM8.2 UH1.BE34
XMP1-1: PCM1.1 PQM11.2 PRM8.1 PRM11.1
XMP1-2: PQM11.6 PRM17.2
XMP2: PRM9.2 UH1.BA33
XMP2-1: PCM3.1 PQM11.5 PRM9.1 PRM12.1
XMP2-2: PQM11.3 PRM16.2
XTAL24_IN: RH91.2 UH1.U10
XTAL24_IN_R: CH47.1 RH72.1 RH91.1 YH2.1
XTAL24_OUT: RH92.2 UH1.U9
XTAL24_OUT_R: CH48.1 RH72.2 RH92.1 YH2.3
XTALIN: CG75.2 RG99.1 UG1.BL6 YG1.1
XTALOUT: CG76.2 RG99.2 UG1.BM6 YG1.3
XTALOUTBUFF_R: RG98.1 RG1497.1 UG1.BK6
N16611725: PRV88.2 PRV95.2 PRV101.1
N16855291: PQV1.5 PQV1.6 PRV50.2
N17123965: PCV12.2 PRV36.1 PRV45.2 PUV1.31
N17123967: PCV18.2 PRV72.1 PUV1.2
N17123991: PCV20.1 PRV2.2 PRV72.2 PRV81.2
N17124033: PCV10.2 PRV9.1 PRV12.1
N17124270: PCV5.1 PCV21.1 PRV24.1 PRV36.2
N17124417: PRV12.2 PRV32.1
N17124541: PCV12.1 PRV34.2
N17125752: PRV6.1 PRV69.2
N17956500: RX9.1 UX3.3
N17957050: RX3.2 UX3.4
N18370426: RT111.2 UT5.1 UT5.2 UT5.4
N20112847: CT37.1 RT116.2 YT2.1
N20112857: CT38.1 RT117.2 YT2.3
N20124859: CT153.1 CT154.1 CT155.1 LT4.1 UT1.R13
N20649294: CE20.1 RE11.1 UE2.6
N20764785: RH580.1 UH1.F3
N20764786: RH581.1 UH1.G3
N20764806: RH89.2 UH1.BB36
N20816753: PCG09.2 PUG01.7
N20816775: PCG07.1 PRG01.2 PUG01.3
N20816793: PLG01.3 PRG03.1
N20816821: PCA4.2 PUA1.7
N20816832: PCA1.1 PRA3.2 PUA1.3
N20905330: RT22.1 UT4.A6 UT4.A7 UT4.A8 UT4.B7
N20905578: CT104.1 UT4.H7
N20905857: RT83.2 UT4.F1
N20999302: RM72.1 UM8.27
N20999314: RM61.2 UM8.52
N20999316: RM64.1 RM66.1 UM8.48
N21000707: RM21.2 RM96.2 UM4.1
N21000709: CM99.1 RM28.1 RM29.1
N21000711: CM98.1 RM27.1 RM38.1
N21000719: CM16.1 CM17.1 RM18.2 UM4.20
N21000750: RM25.2 UM4.18
N21000786: RM28.2 UM4.13
N21000788: RM27.2 UM4.14
N21000830: QM1.2 QM2.6 RM92.2
N21000850: QM2.3 QM3.2 RM94.2
N21000877: RM20.2 UM4.4
N21002214: RE14.2 UE2.3
N21002224: RE9.1 UE2.5
N21002246: RE13.2 UE2.7
N21002352: RE10.1 UE2.2
N21002397: RE20.1 UE9.3
N21003330: R181.2 U2407.7
N21003701: DF1.1 JFAN1.3 RF3.1
N21003743: DF2.1 JFAN2.3 RF6.1
N21223576: RH153.2 UC1.BH31
N21223582: RH158.2 UC1.BR30
N21256667: RE166.2 UE8.24
N21256669: RE167.1 UE8.30
N22050858: QG510.2 RG1.1
N22050873: RG1.2 UG29.4
N22051434: RG26.1 T15.1(TP-1) UG1.BK23
N22051882: RG19.1 UG1.BG8
N22051884: RG20.1 UG1.BF8
N22053416: T18.1(TP-1) UG1.BE4
N22053437: T21.1(TP-1) UG1.BE2
N22055987: RG533.2 RG568.2 UG23.2 UG23.3
N22091215: T195.1(TP-1) UH1.AR32
N22235239: QV97.5 UX1.4
N22948336: QG503.5 QG503.6 RG509.2
N22948350: QG520.5 QG520.6 RG511.2
N22948360: QG520.3 RG512.2
N22948364: QG505.5 QG505.6 RG513.2
N22948383: QG505.3 RG514.2
N22948619: QG508.5 QG508.6 RG543.2
N22948623: QG508.3 RG544.2
N23088914: RG537.1 RG562.1 UG10.4
N23260607: RH592.2 UC1.A36
N23260608: RH593.2 UC1.A37
N23261947: T144.1(TP-1) UC1.BP13
N23395517: T22.1(TP-1) UG1.BD4
N23396708: T24.1(TP-1) UG1.BB3
N23495582: CG7099.1 UG45.12
N23495606: CG7097.1 UG45.10
N23527376: CD402.1 RG1517.2 RG1544.2 UG26.2
N23527433: RG545.1 UG26.4
N23782168: DG4.2 QG521.4 RG506.2
N23782192: QG502.2 RG553.2
N23782194: RG554.1 UG22.4
N23782196: QG521.5 RG554.2
N23782217: QG502.6 RG516.2 UG22.2
N23865685: CG7160.2 QG525.1 RG1538.2 RG1601.2 RG1610.1 RG1613.2 UG37.28
N23865687: RG1539.1 RG1542.2 RG1543.2 UG37.9
N23865710: CG7115.1 RG1540.2 RG1542.1 UG37.3
N23865723: CG7116.1 RG1541.2 RG1543.1 RG1575.2 RG1576.2 UG37.6
N24130479: RG1575.1 UG37.11
N24130488: RG1576.1 UG37.14
N24131017: T25.1(TP-1) UG1.BB1
N24138892: RH6.1 RH7.1 UH1.BE48 UH1.BE49
N24261593: RE161.1 UE12.3
N24262217: CV1071.1 RV679.2
N24324320: QV3.1 RX39.2 UV3.15
N24377091: QV97.2 UX2.4
N24377100: QX3.2 RX6.1
N24542080: RE712.2 UE5.L2
N24545351: RE694.2 UE5.N6
N24548199: RE713.2 UE5.F2
N24551989: CE63.2 RE530.2 UE10.3
N24660253: C2522.1 J6.2 U18.1
N24660259: R367.1 U18.3
N24698323: CG896.1 CG907.1 CG908.1 CG909.1 CG910.1 CG911.1 CG6501.1 LG8.2 UG1.AF11 UG1.BB24 UG1.BC12 UG1.BD12 UG1.U42
N24698546: RG1496.1 RG1498.1 UG1.BJ6
N24698588: CG6825.1 RG1498.2
N24830768: C3.1 UZ21.6
N24874551: RG103.1 UG13.J14
N24874553: RG104.1 UG13.K14
N24875363: RG575.1 UG14.J14
N24875365: RG576.1 UG14.K14
N24887788: CG718.1 CG722.1 CG723.1 CG726.1 CG727.1
N24904795: RG105.1 UG15.J14
N24904797: RG106.1 UG15.K14
N24912644: CG511.1 CG512.1 CG513.1 CG514.1 CG515.1
N24912933: RG101.1 UG11.J14
N24912966: RG102.1 UG11.K14
N24913312: RG573.1 UG12.J14
N24913316: RG574.1 UG12.K14
N24913638: QG2.1 RG111.1
N24913936: QG3.1 RG122.1
N24922475: QG4.1 RG133.1
N24922696: RG577.1 UG16.J14
N24922697: RG578.1 UG16.K14
N24923465: QG8.1 RG156.1
N24924452: RG107.1 UG17.J14
N24924454: RG108.1 UG17.K14
N24924464: RG579.1 UG18.J14
N24924466: RG580.1 UG18.K14
N24929376: QG500.6 RG530.2 RG540.2
N24930799: CG7141.1 QX4.2 RG1579.2
N24930869: QX4.1 RG1580.1
N24930890: CG7142.1 QX5.2 RG1583.2
N24930951: QX5.1 RG1584.1
N24932900: QG516.1 RG1495.1
N24947235: RG1513.1 UG44.4
N24947359: CG7159.1 RG1520.2 UG47.2
N24947407: RG1521.1 UG47.4
N24947415: RG1519.2 UG42.1
N24947426: RG1518.2 UG40.1
N24947523: RG1510.1 UG40.4
N24947574: RG1511.1 UG41.4
N24947768: DG10.2 RG1512.1 RG1602.2 UG43.4
N25145265: QV2.1 RV12.2
N25226064: RT132.1 UT8.3
N25436710: T194.1(TP-1) UC1.A33
N25441457: CD291.2 RD159.1
N25463251: CD324.2 RD229.1
N25485982: CU27.1 DU8.2 RU5.2 UU5.2
N25487721: CE51.1 QE2.2 RE85.1
N25523565: PCV35.2 PRV83.1 PRV225.1 PUV3.2
N25523567: PCV34.2 PRV84.1 PRV225.2 PUV3.1
N25585283: DV13.1 RV653.2
N25585284: DV12.1 RV649.2
N25585535: CZ121.1 UZ45.6
N25774296: PD4.3 PR11.2
N25774388: PQ6.6 PR34.1
N25774390: PQ6.5 PR29.1 PR31.2
N25774400: PC15.2 PQ6.2 PR33.2
N25774403: PC15.1 PQ6.3 PR32.2
N25775574: PCB19.1 PRB25.2
N25775600: PCB33.1 PRB22.1
N25775652: PRB18.1 PRB30.2
N25775725: PCB7.1 PQB15.4 PRB15.2
N25775727: PCB7.2 PLB1.2 PQB15.1 PQB15.2 PQB15.3 PRB2.1
N25775783: PRB6.1 PRB10.2
N25775785: PRB7.1 PRB10.3
N25775797: PDB1.1 PRB4.2
N25775817: PQB17.2 PQB18.1
N25775832: PCB3.2 PCB34.2 PQB12.4 PQB14.4 PQB16.1 PRB5.2 PRB40.1
N25775833: PCB3.1 PQB11.1 PQB11.2 PQB11.3 PQB12.1 PQB12.2 PQB12.3 PQB13.1 PQB13.2 PQB13.3 PQB14.1 PQB14.2 PQB14.3 PQB16.3 PRB1.2 PRB41.1
N25775848: PQB16.2 PRB1.1 PRB32.2
N25775859: PQB11.4 PQB13.4 PRB5.1
N25775862: PQB12.5 PQB14.5 PRB10.1
N25777484: PC511.1 PD501.2 PR503.2 PR505.2 PR507.1 PR508.2
N25777547: PC313.2 PR303.1
N25777570: PC309.1 PJP303.1 PU301.13
N25777574: PC516.2 PR506.1
N25777686: PC512.2 PJP503.1 PU501.9
N25780614: PCH26.2 PRH17.1
N25781231: PC2507.1 PR2506.2 PU2501.4
N25782005: PC1111.2 PR1107.1
N25782631: PC1819.2 PR1812.1
N25783159: PQW1.5 PQW1.6 PRW23.2
N25783177: PCW3.1 PQW2.2 PRW10.2
N25783179: PQW2.3 PRW4.2
N25783181: PQW2.5 PQW2.6 PRW21.2
N25783214: PCW13.1 PRW31.2
N25783219: PCW10.2 PCW13.2 PRW16.1 PRW56.2
N25783233: PCW11.1 PRW20.2
N25783234: PCW11.2 PCW12.1 PRW7.1 PRW13.1 PRW19.2
N25882913: QE13.6 RE160.2
N25882914: QE21.6 RE155.2
N25882915: QE22.6 RE157.2
N25890186: RT694.2 UH1.T47
N25926180: JHDMI.13 RV655.2
N26140980: RH1021.2 UH1.R6
N26223082: PD502.1 PR508.1
N26229867: RH598.1 UH1.AF19 UH1.AF20
N26231028: CH36.1 T146.1(TP-1) UH1.BG5
N26232649: T145.1(TP-1) UH1.AJ22 UH1.AJ23 UH1.AK22 UH1.AK23
N26327146: T197.1(TP-1) UE5.E7
N26383140: RV684.2 UV4.4
N26383142: RV685.1 UV4.5
N26383331: RV683.1 UV4.3
N26440602: RT724.2 UT1.Y1
N26440604: RT725.2 UT1.Y2
N26793914: PRZ155.2 PUZ1.26
N26990754: PCW16.1 PRW37.2 PUW2.3
N26991157: PCW30.1 PRW47.2 PUW3.3
N26991610: PCW22.1 PRW34.2
N27100126: PHZ01.2 PRZ49.1
N27100217: PHZ02.2 PRZ44.2 PRZ64.1
N27100816: PHZ05.2 PRZ54.1 PRZ76.2
N27278094: RV671.1 UV3.9
N27278095: RV672.1 UV3.12
N27425503: PLW01.1 PRW35.1 PUW2.11 PUW2.12
N27662445: PRW42.2 PUW2.2
N27669103: PRW52.2 PUW3.2
N27693415: PCZ60.2 PUZ2.7
N27693535: PCZ93.2 PUZ6.7
N27693577: PCZ92.2 PUZ5.7
N27693645: PRW43.2 PUW2.17
N27693691: PRW53.2 PUW3.17
N27693887: PCZ91.1 PRZ121.1 PRZ123.2 PUZ7.12
N27694207: PCZ90.2 PRZ122.1 PRZ124.1 PUZ7.10
N27694554: PCZ122.2 PUZ8.7
N27694593: PCZ121.2 PUZ9.7
N27694977: PCZ120.1 PRZ145.1 PRZ147.2 PUZ10.12
N27695609: PCZ119.2 PRZ144.1 PRZ146.1 PUZ10.10
N27696433: PCZ57.1 PRZ99.1 PRZ100.2 PUZ4.12
N27696489: PCZ58.2 PRZ98.1 PRZ101.1 PUZ4.10
N27712207: PCW41.1 PCW42.1 PRW58.2
N27712576: PCW43.1 PCW44.1 PRW59.2
N28556236: C2527.2 RD185.2 RD186.2
N28556759: C2528.2 RD201.2 RD225.2
N28600394: PCZ40.1 PRZ3.2 PUZ1.16
N28600396: PCZ30.2 PRZ39.2 PUZ1.15
N28600408: PCZ23.1 PRZ68.1 PUZ1.36
N28600440: PCZ36.1 PRZ71.2
N28600447: PCZ19.1 PRZ66.2 PUZ1.3
N28600456: PRZ20.1 PUZ1.43
N28600519: PCZ34.1 PRZ72.2
N28600523: PCZ25.1 PCZ33.1 PRZ25.2 PRZ52.1
N28600544: PCZ38.2 PRZ53.1
N28600564: PCZ29.2 PCZ32.2 PRZ22.1 PRZ51.2
N28600574: PCZ26.2 PCZ31.1 PRZ26.2 PRZ27.1
N28600606: PCZ22.1 PRZ9.2
N28600607: PCZ20.1 PRZ8.2
N28600611: PHZ04.1 PRZ23.2 PRZ75.1
N28600613: PHZ03.1 PRZ21.2 PRZ74.1
N28600615: PCZ26.1 PCZ28.1 PRZ24.2 PRZ148.1
N28600645: PRZ37.2 PUZ1.27
N28888311: PCZ59.2 PUZ3.7
N28888326: PCZ61.1 PRZ84.2 PUZ3.3
N28888419: PCZ62.1 PRZ83.2 PUZ2.3
N28891269: PRZ90.2 PRZ91.2 PUZ4.2
N28891277: PCZ65.1 PRZ85.1 PUZ4.1 PUZ4.16
N28891279: PRZ97.2 PUZ4.5
N28891309: PRZ96.2 PUZ4.4
N28898532: PCZ97.1 PRZ107.2 PUZ6.3
N28898587: PCZ94.1 PRZ106.2 PUZ5.3
N28898659: PRZ113.2 PRZ116.2 PUZ7.2
N28898663: PCZ98.1 PRZ108.1 PUZ7.1 PUZ7.16
N28898664: PRZ120.2 PUZ7.5
N28898679: PRZ115.2 PUZ7.4
N28905293: PCZ125.1 PRZ129.2 PUZ8.3
N28905329: PCZ123.1 PRZ130.2 PUZ9.3
N28905381: PRZ135.2 PRZ138.2 PUZ10.2
N28905385: PCZ127.1 PRZ131.1 PUZ10.1 PUZ10.16
N28905386: PRZ143.2 PUZ10.5
N28905401: PRZ139.2 PUZ10.4
N29082093: PCV60.1 PUV4.7
N29085512: RD194.1 UD6.F9
N29085514: RD235.2 UD6.E9
N29085519: RD248.1 RD249.1 UD6.M9
N29085573: PCV61.1 PUV5.7
N29090433: PCV94.2 PUV7.7
N29091042: PCV95.2 PUV6.7
N29096065: PCV124.2 PUV8.7
N29096332: PCV125.2 PUV9.7
N29102115: PCV155.2 PUV11.7
N29102370: PCV154.2 PUV10.7
N29673235: PC14.2 PQ5.2 PR28.1
N29676897: PCB24.1 PRB3.2
N29677561: PCV40.1 PRV89.2
N29702846: LX8.1 RX38.2
N29702855: LX7.1 RX37.2
N29702861: LX6.1 RX36.2
N29702867: LX5.1 RX35.2
N29702873: LX4.1 RX34.2
N29702889: LX3.1 RX33.2
N29702919: LX2.1 RX32.2
N29702925: LX1.1 RX31.2
N29733255: QG503.3 RG510.2
N29913076: QH98.1 RE724.1 RH1600.1
N29990483: PCV212.1 PRV224.2
N30025424: QG522.5 QG523.6 RG1604.2
N30025428: QG522.3 RG1605.2
N30025618: QG523.5 QG524.6 RG1606.2
N30025622: QG523.3 RG1607.2
N30156278: JRTC1.1 PR2.1
N30605331: PD501.1 PR504.2
N30818241: RD195.1 UD5.F9
N30820408: RD196.1 UD7.F9
N30820514: RD197.1 UD8.F9
N32205396: QH99.5 QH99.6 R369.2 R372.1
N32206391: QH100.5 QH100.6 R370.2 R371.1
N32296413: PCZ66.1 PRZ81.2
N32879277: PCZ67.1 PRZ82.2
N32879345: PCZ100.1 PRZ105.2
N32879406: PCZ99.1 PRZ104.2
N32879443: PCZ128.1 PRZ128.2
N32879490: PCZ129.1 PRZ127.2
N32879537: PCG10.1 PRG04.2
N32879582: PCA9.1 PRA2.2
N32883714: PRW44.1 PUW3.5
N32883717: PCW37.1 PUW3.7
N32888909: PCW38.1 PRW45.2
N34307891: PCV21.2 PRV73.1
N35372714: PRV25.2 PRV67.1
N37205985: RH519.2 UC1.BR33
N37206101: RH154.2 UC1.H13
N37206112: RH155.2 UC1.BP31
N37239953: RH192.2 UC1.J23
N37239957: RH167.2 UC1.H23
N37345395: T135.1(TP-1) UH1.AL35
N37890445: CT115.1 QT2.5 RT90.1
N37890455: QT2.3 RT89.2
N37890462: QT2.6 RT88.2 RT90.2
N37890499: CT117.1 UT5.6
N38701284: DE1.2 RE8.2 UE1.25
N38702841: RE651.1 UE1.20
N38704058: RE6.1 UE1.31
N38704074: RE7.1 UE1.30
N40259586: RT108.1 RT109.2 UT4.D6
N46084233: QX2.2 RX2.1
N123247790: C2507.1 U17.10
N123252636: C2506.1 U17.12
N140856784: RD157.1 UD1.F9
N140856890: RD158.1 UD2.F9
N140858392: RD164.1 UD3.F9
N140858498: RD163.1 UD4.F9
N148537289: RD231.2 UD2.E9
N148539009: RD230.2 UD1.E9
N148539686: RD232.2 UD3.E9
N148539959: RD233.2 UD4.E9
N148540239: RD234.2 UD5.E9
N148541018: RD236.2 UD7.E9
N148541530: RD237.2 UD8.E9
N148566755: RD238.1 RD239.1 UD1.M9
N148569917: RD240.1 RD241.1 UD2.M9
N148572207: RD242.1 RD243.1 UD3.M9
N148574907: RD244.1 RD245.1 UD4.M9
N148577773: RD246.1 RD247.1 UD5.M9
N148580948: RD250.1 RD251.1 UD7.M9
N148582662: RD252.1 RD253.1 UD8.M9
N249404770: T122.1(TP-1) UT4.G10
N249407320: T121.1(TP-1) UT4.E10
N249408950: T62.1(TP-1) UT4.F4
N249410070: T64.1(TP-1) UT4.B2
N249410630: T63.1(TP-1) UT4.G4
N249410910: T65.1(TP-1) UT4.C2
N2494119425: T114.1(TP-1) UT4.D10
N2494119426: T120.1(TP-1) UT4.G11
N2494119430: T70.1(TP-1) UT4.D7
N3269959812: PC510.2 PU501.10

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; JEDP 15 31 37; JELC2 6 7 8; JHDMI 14; JIO2 C2 C3 E1 E2 F2; JPK 6 19 20; JPTRON 6 12; JSSD1 6 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JSSD3 6 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; PD1 2; PD3 3; PJPDC1 12; PU301 12; PU1101 8; PU1802 8; PU2501 5; PUA1 6 13 17 19; PUG01 6 13 17 19; PUH2 8; PUV3 23 26 30; PUV4 6 13 16; PUV5 6 13 16; PUV6 6 13 16; PUV7 6 13 16; PUV8 6 13 16; PUV9 6 13 16; PUV10 6 13 16; PUV11 6 13 16; PUW1 4 5 18; PUW2 6 13 16; PUW3 6 13 16; PUZ2 6 13 17 19; PUZ3 6 13 17 19; PUZ5 6 13 17 19; PUZ6 6 13 17 19; PUZ8 6 13 17 19; PUZ9 6 13 17 19; QE5 3 4 5; QE66 1 2 6; QG500 3 4 5; QG502 3 4 5; QG521 1 2 6; QG522 1 2 6; QG524 3 4 5; RE718 1; RE719 1; RE720 1; RE721 1; RE722 1; RP2 4 5; RP3 7; RP5 7 8; RPC7 3 4; U2407 8 11; UC1 A23 A25 A27 AA14 AD2 AD4 AE1 AE2 AE4 AE5 AE7 AE8 AE9 AE10 AE11 AE29 AF10 AJ8 AJ10 AJ11 AK1 AK2 AK3 AL1 AL2 AL3 AM7 AM8 AM10 AM11 AP14 AP29 AT2 AT3 AT5 AT7 AT10 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B2 B22 B23 B24 B25 B27 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ28 BK28 BL31 BL34 BM31 BN33 BN35 BP1 BR1 BR2 BR27 BR31 BR35 BT2 BT27 BT30 C1 C22 C24 C30 C33 C34 C38 D1 D23 D25 D34 E1 E2 E22 E23 E24 E25 E30 E33 F22 F24 F30 F33 G3 G13 H24 J3 J24 N29 R14; UC2 1; UD1 T7; UD2 T7; UD3 T7; UD4 T7; UD5 T7; UD6 T7; UD7 T7; UD8 T7; UE1 2 3 4 10 26 27 28 29 38 39 40 41 45 46; UE5 A2 A10 B3 B9 B10 D7 E1 J2 K2 K8 L1 L13 M13 N2 N8; UE8 12 13 19 20 21 22 28 29; UE10 9 11 13 16; UG1 AA44 AC9 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AT1 AT2 AT3 AT6 AT7 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 BA1 BA2 BA6 BA7 BA8 BB7 BB8 BD24 BE11 BE23 BE35 BE38 BF11 BF12 BF21 BF23 BF24 BF33 BF35 BF36 BF38 BF39 BG2 BG6 BG11 BG12 BG21 BG23 BG24 BG33 BG35 BG36 BG38 BG39 BG41 BH1 BH3 BH6 BH11 BH12 BH23 BH35 BH38 BH41 BJ1 BJ2 BK11 BK12 BK14 BK15 BK17 BK18 BK20 BK21 BK36 BK38 BK39 BK41 BK42 BL11 BL12 BL14 BL15 BL17 BL18 BL20 BL21 BL36 BL38 BL39 BL41 BL42 BM8 BM9 BM11 BM12 BM14 BM15 BM17 BM18 BM20 BM21 BM35 BM36 BM38 BM39 BM41 BM42 BM44 BM45 J14 J23 J35 J41 P9; UG11 F5 F10 G5 M5 N5 N10; UG12 F5 F10 G5 M5 N5 N10; UG13 F5 F10 G5 M5 N5 N10; UG14 F5 F10 G5 M5 N5 N10; UG15 F5 F10 G5 M5 N5 N10; UG16 F5 F10 G5 M5 N5 N10; UG17 F5 F10 G5 M5 N5 N10; UG18 F5 F10 G5 M5 N5 N10; UG37 8 10 17 18 21 31; UH1 A22 A25 AA1 AA45 AB48 AC6 AC7 AC9 AC11 AC14 AC15 AC39 AC41 AC43 AC44 AD47 AD48 AE9 AE11 AE14 AE15 AE39 AE41 AE44 AE48 AF47 AF48 AH14 AH15 AH40 AH41 AH47 AH48 AJ44 AJ46 AJ47 AK47 AL9 AL15 AL41 AL47 AL48 AM7 AM43 AM45 AM47 AN4 AN35 AN37 AN46 AN47 AP2 AP3 AP9 AP21 AP29 AP47 AR2 AR13 AR35 AR37 AR42 AR48 AT5 AT10 AT40 AT49 AU4 AU24 AU46 AU47 AV6 AV7 AV13 AV16 AV18 AV43 AV47 AW2 AW3 AW15 AW18 AW21 AW26 AW48 AY3 B9 B10 B14 B19 B21 B23 B24 B25 B26 B27 B38 BA2 BA3 BA17 BA36 BB3 BB4 BB6 BB24 BB34 BC1 BC5 BC17 BC28 BC33 BD4 BD7 BD8 BD12 BD16 BD17 BD39 BD42 BE3 BE6 BE8 BE12 BE16 BE18 BE19 BE23 BE29 BE32 BE33 BE36 BE40 BF6 BF10 BF15 BF17 BF18 BF19 BF32 BF33 BF36 BF40 BF41 BG6 C3 C9 C10 C11 C14 C19 C20 C21 C23 C24 C26 C27 C38 C39 C45 C46 C47 D4 D11 D20 D21 D29 D39 D46 E28 F7 F9 F11 F20 F24 F26 G1 G2 G12 G20 G24 G26 J15 J18 J21 J24 K6 K7 K16 K18 K21 K29 K46 K47 L2 L24 L26 L46 L47 M1 M26 M29 N2 N3 N18 N32 N47 N48 P24 P47 P48 R13 R15 R18 R24 R32 R46 R47 T1 T2 T45 T46 T48 U2 U3 U13 U35 U37 U47 U48 V2 V3 V47 V48 W46 W47 Y2 Y14 Y15 Y35 Y36 Y46 Y48; UM4 7 8; UM8 10 11 12 13 15 16 17 18 21 22 23 28 29 30 31 32 33 34 35; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 J1 J2 L1 L2 N1 N2 R1 R2 V18 W16 W19 Y16 Y19; UT4 A9 B9; UU5 1; UV3 11 14

## Via types
v1: diameter 0.254, hole 0.102, TOP to GND2, 4629 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 900 vias
v3: diameter 0.406, hole 0.203, GND2 to GND4, 4347 vias
v4: diameter 0.254, hole 0.102, GND4 to BOTTOM, 2489 vias
v5: diameter 0.457, hole 0.203, TOP to BOTTOM, 3951 vias
v6: diameter 0.254, hole 0.102, GND4 to IN4, 535 vias
v7: diameter 0.254, hole 0.102, IN4 to BOTTOM, 422 vias
v8: diameter 0.254, hole 0.102, TOP to IN1, 1272 vias
v9: diameter 0.254, hole 0.102, IN3 to GND4, 175 vias
v10: diameter 0.406, hole 0.203, TOP to BOTTOM, 168 vias
v11: diameter 0.254, hole 0.102, IN1 to GND2, 521 vias
v12: diameter 0.254, hole 0.102, GND2 to IN2, 205 vias
v13: diameter 0.508, hole 0.254, TOP to BOTTOM, 90 vias
v14: diameter 0.254, hole 0.102, TOP to GND1, 855 vias
v15: diameter 0.254, hole 0.102, GND1 to GND2, 186 vias
v16: diameter 0.254, hole 0.102, GND4 to GND5, 206 vias
v17: diameter 0.254, hole 0.102, IN4 to GND5, 2 vias
v18: diameter 0.254, hole 0.102, GND5 to BOTTOM, 783 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8VS_PGOOD: length 4.1
  TOP w0.254: PU1802.7 46.26,6.15 46.01,5.9 46.01,5.3 46.26,5.05 v5(46.67,5.05)
  BOTTOM w0.081: v2(45.05,5.04) 45.44,4.65 PR1813.2
  BOTTOM w0.254: v5(46.67,5.05) 46.27,4.65 PR1813.2
1V8_AON_EN: length 13.4
  IN3 w0.058: v9(69.84,97.32) 69.84,97.31 69.17,96.64 69.17,96.52 68.97,96.33 68.86,96.33 67.42,94.9 67.42,93.11 v9(67.31,92.99)
  GND4 w0.081: v9(67.31,92.99) v4(67.31,92.56)
  GND4 w0.508: v4(69.98,97.61) 69.98,97.44 69.85,97.31 69.85,97.32 v9(69.84,97.32)
  BOTTOM w0.081: v4(67.31,92.56) 66.88,92.99 UG45.3 ; UG46.4 71.54,94.78 RG1516.1 70.55,95.8 QG503.2 70.55,97.04 v4(69.98,97.61)
  BOTTOM w0.127: v2(73.36,95.42) 72.72,94.78 UG46.4
1V8_ENP: length 3.5
  TOP w0.254: PR1811.1 PR1815.1 47.57,2.63 PC1821.1 47.33,3.7 PU1802.9
1V8_MAIN_AON_EN: length 4.2
  BOTTOM w0.081: RG1510.2 CG7089.1 v2(72.83,91.34) 73.71,91.34 74.47,90.58 UG39.1
1V8_MAIN_EN: length 204.6
  TOP w0.081: QG520.2 8.64,5.87 9,6.24 9,7.1 v1(8.31,7.8) 5.37,7.8 RG1544.1 ; UG1.BE1 54.1,83.15 55.35,81.9 v6(55.35,80.72)
  IN1 w0.058: v1(58.27,76.84) 58.27,64.9 59.89,63.27 65.86,63.27 67.01,62.13 68.48,62.13 v4(69.16,61.45)
  GND2 w0.081: v1(8.31,7.8) 8.28,7.77 v12(7.75,7.77)
  IN2 w0.058: v3(58.27,76.84) 55.35,79.76 v6(55.35,80.72) ; v4(69.16,61.45) 69.11,61.39 69.11,59.79 66.39,57.07 20,57.07 17.46,54.53 15.3,54.53 13.95,53.18 13.95,49.31 13.47,48.82 13.47,38.92 12.53,37.98 12.53,35.61 12.09,35.17 12.09,31.09 10,28.99 10,23.43 8.97,22.4 8.97,19.86 6.02,16.91 6.02,10.25 6.48,9.79 6.48,9.63 7.75,8.36 v12(7.75,7.77)
  IN4 w0.058: v6(55.35,80.72) 55.35,82.07 v7(56.16,82.88) ; v7(66.87,89) 66.87,84.79 67.33,84.33 67.33,82.41 67.99,81.75 67.99,80.6 67.99,80.32 69.67,78.63 69.67,77.5 68.96,76.79 68.35,76.79 v7(66.17,78.97)
  BOTTOM w0.081: v4(69.16,61.45) 69.24,61.45 69.82,60.86 69.82,58.83 70.23,58.42 70.76,58.42 v2(71.06,58.13) 71.7,58.13 73.66,60.1 74.47,60.1 74.49,60.08 74.71,60.08 74.73,60.1 75.03,60.1 75.18,59.95 75.18,59.49 74.8,59.11 74.8,56.26 75.11,55.96 RG549.1 75.64,55.57 DG7.2 DG3.2 ; v7(56.16,82.88) 58.12,82.88 62.03,78.97 v7(66.17,78.97)
  BOTTOM w0.254: RG1557.1 65.41,90.46 v7(66.87,89) 69.66,89 UG42.2 70.82,88.91 71.63,88.1 UG40.2
1V8_MAIN_ENP: length 17.7
  IN4 w0.058: v7(76.68,93.68) 73,97.37 v7(73,99.64)
  BOTTOM w0.081: v7(73,99.64) v2(72.65,99.99) 72.53,100.1 69.82,100.1 69.01,99.29 RG1556.1 ; v7(76.68,93.68) 76.68,90.17 75.77,89.26 UG39.4
1V8_MAIN_ENR: length 11.2
  IN3 w0.254: v9(68.45,97.31) 66.95,95.81 66.95,93.68 66.73,93.45 66.73,92.75 66.37,92.4 v9(65.61,92.4)
  GND4 w0.254: v4(68.83,97.58) 68.57,97.31 v9(68.45,97.31) ; v9(65.61,92.4) 65.44,92.56 v4(65.41,92.56)
  BOTTOM w0.081: v2(67.79,99.27) 68.68,98.38 RG1556.2
  BOTTOM w0.203: UG45.5 66.08,93.24 v4(65.41,92.56)
  BOTTOM w0.254: v4(68.83,97.58) RG1556.2
3V3_SYS_EN: length 21.4
  TOP w0.127: v10(11.34,15.7) 10.83,15.19 CG240.1
  TOP w0.203: 8.76,13.81 3.49,13.81 v5(3.37,13.93)
  TOP w0.254: QG505.2 3.98,17.41 v5(3.92,17.48)
  IN1 w0.254: v5(3.37,13.93) 3.37,13.17 3.35,13.16 3.35,8.71 5.77,6.3 v8(6.86,6.3)
  BOTTOM w0.254: v5(3.37,13.93) 3.37,17.08 3.76,17.48 v5(3.92,17.48)
3V_ELC_ON: length 75.7
  IN4 w0.058: v7(130,14.1) 129.42,13.52 126.03,13.52 125.89,13.67 125.88,13.67 125.76,13.79 122.89,13.79 122.43,13.34 110.7,13.34 110.45,13.09 109.06,13.09 108.81,13.34 99.04,13.34 98.81,13.57 92.2,13.57 85.05,6.41 82.91,6.41 v7(82.02,5.52)
  BOTTOM w0.076: 84.2,18.39 83.27,18.39 82.58,17.69 82.58,11.34 82.78,11.14 82.78,10.57
  BOTTOM w0.081: 84.2,18.39 84.44,18.39 RE83.1 85.71,17.12 UE10.18 ; v7(82.02,5.52) 81.84,5.7 81.84,7.24 82.42,7.82 82.42,9.13 82.78,9.49 82.78,10.57 ; UE9.4 135.19,13.68 134.75,13.24 132.92,13.24 v2(132.37,13.78) 132.05,14.1 v7(130,14.1)
3V_FB: length 5
  TOP w0.254: PU301.10 v5(61.8,25.57)
  BOTTOM w0.081: PC313.1 58.95,24.42 v2(58.9,24.37)
  BOTTOM w0.254: v5(61.8,25.57) 61.53,25.3 PR305.1 60.85,24.44 PR307.2 PC313.1
3V_SN:
  vias: v2(65.29,25.71)
3VS: length 3
  TOP w0.081: v5(69.11,9.98) 67.36,9.98 v10(66.51,10.84)
3VS_GATE: length 2.3
  BOTTOM w0.203: U17.5 68.41,13.87 68.39,13.89 R174.2 C258.1
5V_FB: length 3.6
  TOP w0.254: PU501.7 52.09,23.71 PR511.2 PC516.1 PR510.1
5V_SN: length 1
  BOTTOM w0.081: PC513.1 v2(51.88,19.71)
5VCC: length 33.2
  TOP w0.203: PUV1.12 72.77,25.93 72.48,25.64 71.92,25.64 v5(71.75,25.81)
  TOP w0.254: PRV75.1 v4(81.89,26.95)
  BOTTOM w0.254: PRV5.2 69.51,21.3 70.05,20.75 78.23,20.75 81,23.52 v2(81,23.76) 81,24.17 82.51,25.68 82.51,26.33 v4(81.89,26.95) 81.89,27.28 80.63,28.54 PRV3.2
  BOTTOM w0.508: PRV5.2 69.51,24.55 70.08,25.12 72.97,25.12 73.28,25.43 PCV19.1 72.59,26.24 72.16,25.81 v5(71.75,25.81)
5VS: length 0.9
  TOP w0.127: v5(65.3,11.83) v10(64.39,11.83)
5VS_GATE: length 1.4
  BOTTOM w0.203: R182.2 67.61,14.45 U17.3
+0.6V_B_VREFDQ: length 5.7
  TOP w0.254: UC1.BR13 136.55,92.42 137.35,92.42
  TOP w0.508: CD324.1 RD228.1 138.81,89.94 138.13,90.62 138.13,91.66 138.11,91.66 137.35,92.42
+0.6V_DDR_B_VREFDQ: length 112.6
  TOP w0.081: v1(95.17,62.81) 95.17,63.58 v2(95.31,63.72)
  TOP w0.254: UD8.M1 96.34,62.25 95.77,62.81 v1(95.17,62.81)
  TOP w0.305: UD7.M1 106.55,62.25 v5(106.52,62.21) 106.51,62.21 106.2,61.9 CD323.1
  IN1 w0.254: v8(140.09,89.94) 140.09,86.86 142.3,84.65 146.52,84.65 148.34,82.83 148.34,77.88 144.72,74.26 144.72,67.4 143,65.69 143,64.29 143.29,64 143.29,62.89 143.6,62.58 143.6,57.8 142.34,56.54 132.72,56.54 132.21,57.05 130.61,57.05 130.1,56.54 125.16,56.54 124.89,56.82 123.49,56.82 123,57.3 118.3,57.3 117.35,58.26 117.35,59.66 117.6,59.92 117.6,60.77 v11(117.85,61.01)
  GND2 w0.254: v3(117.85,61.43) v11(117.85,61.01) ; v1(95.17,62.81) v12(95.65,62.81)
  IN2 w0.254: v3(115.32,62.51) 115.06,62.77 115.06,63.97 114.72,64.32 114.72,64.34 114.47,64.58 114.45,64.58 114.4,64.63 113.08,64.63 113.01,64.57 112.67,64.57 112.42,64.81 112.42,64.86 112.17,65.12 108.65,65.12 107.48,63.95 107.08,63.95 106.83,63.7 106.83,63.3 106.52,62.99 v5(106.52,62.21) 105.08,63.65 104.42,63.65 104.19,63.88 103.66,63.88 102.3,65.24 98,65.24 97.77,65.47 97.43,65.47 97.2,65.24 96.58,65.24 96.2,64.86 96.2,63.59 95.65,63.03 v12(95.65,62.81)
  GND4 w0.254: v4(115.32,62.07) v3(115.32,62.51) ; v4(117.85,61.9) v3(117.85,61.43)
  BOTTOM w0.254: v5(106.52,62.21) 105.98,62.75 CD320.1 104.89,62.75 104.39,62.25 UD6.M1
  BOTTOM w0.305: CD321.1 115.48,61.9 v4(115.32,62.07) 115.13,62.25 UD5.M1
  BOTTOM w0.508: v4(117.85,61.9) RD227.1 CD321.1
