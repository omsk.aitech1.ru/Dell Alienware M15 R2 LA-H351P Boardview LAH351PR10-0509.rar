# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CORE_V3N: length 59.6
  TOP w0.254: PUZ7.9 133.31,135.52 v4(133.38,135.59) ; PLZ03.3 101.71,120.98 v5(102.17,121.44)
  IN1 w0.152: v5(102.17,121.44) 102.23,121.5 104.24,121.5 106.3,123.57 106.3,134.6 108.21,136.51 115.64,136.51 115.8,136.35 123.29,136.35 123.79,136.86 131.65,136.86 132.92,135.59 v4(133.38,135.59)
  IN4 w0.254: v4(133.38,135.59) 133.73,135.94 136.11,135.94 137.82,134.24 139.97,134.24 v4(141.1,135.36)
  BOTTOM w0.254: PCZ106.2 133.41,135.55 v4(133.38,135.59)
CORE_V3P: length 56.6
  TOP w0.254: PLZ03.2 101.71,121.74 v5(101.47,121.5) ; v1(139.7,135.92) PRZ55.1
  IN1 w0.152: v5(101.47,121.5) 101.47,121.22 101.83,120.87 102.43,120.87 102.68,121.12 104.39,121.12 106.68,123.41 106.68,134.44 108.47,136.24 115.38,136.24 115.65,135.97 123.44,135.97 123.95,136.48 131.6,136.48 v8(132.47,135.6) 132.47,135.59 132.85,135.21 133.58,135.21 133.91,135.54 133.91,135.71 134.82,136.63 138.99,136.63 v1(139.7,135.92)
CORE_V4N: length 52.7
  TOP w0.254: v1(131.11,136.12) 131.11,136.1 130.7,135.68 v4(130.7,135.6) 130.7,135.19 130.94,134.95 131.32,134.95 131.62,134.65 132.14,134.65 132.31,134.48 PUZ7.11 ; PLZ04.3 109.47,121.12 v5(109.35,121.25)
  IN1 w0.152: v1(131.11,136.12) 124.31,136.12 121.83,133.63 115.35,133.63 114.58,132.86 114.58,123.02 113,121.44 111.32,121.44 111,121.76 109.86,121.76 v5(109.35,121.25)
  GND2 w0.081: v4(130.7,135.6) 131.11,136.02 v1(131.11,136.12)
  IN4 w0.254: v4(130.7,135.6) 131.42,136.32 137.17,136.32 137.67,135.82 137.67,135.13 138.21,134.59 139.64,134.59 140.08,135.04 v4(140.08,135.36)
  BOTTOM w0.203: PCZ253.1 140.08,136.2 v4(140.08,135.36)
CORE_V4P: length 46.3
  TOP w0.254: PLZ04.2 109.47,121.95 v5(110.17,121.25) ; v8(130.26,134.05) 129.7,133.49 PRZ123.1 ; v8(138.37,135.92) PRZ58.1
  IN1 w0.152: v8(138.37,135.92) 138.01,136.27 135.48,136.27 134.06,134.85 131.06,134.85 v8(130.26,134.05) 128.57,135.74 124.47,135.74 121.98,133.25 115.51,133.25 114.96,132.7 114.96,123.01 113.01,121.06 110.36,121.06 v5(110.17,121.25)
CORE_V5N: length 35.5
  TOP w0.254: v4(135.78,127.54) 136.02,127.54 136.33,127.22 136.33,125.88 136.26,125.81 v5(136.26,125.62) PUZ10.9 ; PLZ05.3 v5(118.24,129.25)
  IN1 w0.152: v4(135.78,127.54) 134.95,128.36 134.95,130.61 135.94,131.6 135.94,133.58 v4(135.57,133.95) 135.41,134.11 134.12,134.11 131.36,134.11 130.56,133.31 129.88,133.31 128.87,134.32 124.92,134.32 119.98,129.38 118.36,129.38 v5(118.24,129.25)
  BOTTOM w0.254: PRZ132.1 135.57,134.66 v4(135.57,133.95) ; PCZ135.2 136.02,125.38 v5(136.26,125.62)
CORE_V5P: length 35.1
  TOP w0.081: PRZ57.1 v2(134.58,137.04)
  TOP w0.254: PRZ57.1 135.7,137 v8(135.7,135.92) ; PLZ05.2 v5(118.24,129.89)
  IN1 w0.152: v8(135.78,126.71) 135.83,126.71 136.33,127.22 136.33,134.84 135.7,135.47 v8(135.7,135.92) 134.28,134.5 131.2,134.5 130.4,133.7 130.04,133.7 129.03,134.7 124.76,134.7 119.82,129.76 118.36,129.76 v5(118.24,129.89)
CORE_V6N: length 38.5
  TOP w0.254: v5(118.52,120.58) 118.28,120.83 PLZ06.3 ; PUZ10.11 135.26,125 v5(134.95,125.31)
  IN1 w0.152: v4(137.22,135.33) 137.22,125.54 136.81,125.12 135.14,125.12 v5(134.95,125.31) 134.95,124.94 134.62,124.6 v4(132.33,124.6) 132.32,124.61 v8(131.37,124.61) 131.17,124.82 121.49,124.82 118.65,121.98 118.65,120.71 v5(118.52,120.58)
  BOTTOM w0.254: v4(132.33,124.6) v2(133.73,124.6) 134.95,124.6 PCZ134.1 135,125.26 v5(134.95,125.31)
CORE_V6P: length 34.4
  TOP w0.254: PRZ61.1 137.07,135.94 v8(137.1,135.92) ; PLZ06.2 119.23,120.83 118.49,121.57 v5(118.24,121.57)
  IN1 w0.152: v5(118.24,121.57) 118.3,121.63 118.3,122.03 121.47,125.2 131.06,125.2 v8(131.37,125.5) 131.88,125.5 132.51,126.14 136.46,126.14 136.8,126.48 136.8,135.63 v8(137.1,135.92)
CPU_24MHZ_N: length 69.7
  TOP w0.089: v5(95.06,50.89) 95.25,50.7 95.25,49.8 95.28,49.77 95.28,49.57 95.36,49.48 95.36,49.32 95.39,49.29 95.39,48.77 95.65,48.51 95.65,47.75 95.67,47.72 95.67,47.19 UH1.C6
  TOP w0.107: UC1.D31 98.14,107.11 98.45,106.8 v5(98.47,106.8)
  IN2 w0.058: v5(98.47,106.8) 98.67,106.58 98.69,106.56 98.69,106.48 98.62,106.41 98.62,99.96 99.49,99.09 100.57,99.09 101.16,98.5 101.16,95.16 100.76,94.76 100.76,93.21 102,91.97 102,89.21 99.36,86.57 98.12,86.57 97.8,86.89 96.25,86.89 95.57,86.21 95.57,84.7 94.8,83.92 94.8,82.33 94.79,82.32 94.79,82.3
  IN2 w0.076: v5(95.06,50.89) 95.25,51.08 95.25,54 96.27,55.02 96.27,58.22 94.79,59.7 94.79,68.49 94.36,68.93 94.36,80.37 94.82,80.83 94.82,82.23 94.79,82.26 94.79,82.3
CPU_24MHZ_P: length 70.3
  TOP w0.089: v5(95.64,50.89) 95.45,50.7 95.45,49.65 95.54,49.56 95.54,49.39 95.57,49.36 95.57,48.84 95.85,48.56 95.85,47.83 95.88,47.81 95.88,47.38 95.98,47.27 95.98,46.91 95.89,46.82 UH1.D7
  TOP w0.107: UC1.E31 98.79,107.11 v5(99.12,106.78)
  IN2 w0.058: v5(99.12,106.78) 98.88,106.55 98.87,106.4 98.81,106.33 98.81,100.04 99.57,99.28 100.65,99.28 101.35,98.58 101.35,95.09 100.94,94.69 100.94,93.28 102.18,92.05 102.18,89.13 99.44,86.39 98.04,86.39 97.73,86.71 96.33,86.71 95.76,86.13 95.76,84.62 94.99,83.85 94.99,82.35 95.02,82.32 95.02,82.3
  IN2 w0.076: v5(95.64,50.89) 95.45,51.08 95.45,53.92 96.47,54.93 96.47,58.31 95,59.78 95,68.58 94.56,69.01 94.56,80.28 95.02,80.74 95.02,82.3
CPU_DDC1CLK: length 17.3
  TOP w0.089: v8(90.49,23.59) 90.42,23.52 89.99,23.52 RH604.2
  IN1 w0.089: v8(90.49,23.59) 90.59,23.48 91.13,23.48 91.17,23.45 93.21,23.45 93.42,23.66 93.42,26.27 95.26,28.11 95.26,30.77 96.71,32.22 96.71,32.86 97.39,33.54 v8(99.14,33.54)
CPU_DDC1CLK_T: length 1.1
  TOP w0.081: v2(83.13,138.29) 83.12,138.29 82.81,138.6 v4(82.74,138.6)
  TOP w0.089: RT127.1 82.65,138.6 v4(82.74,138.6)
CPU_DDC1DATA: length 13.2
  TOP w0.089: v8(90.49,23.21) 90.37,23.32 89.92,23.32 89.91,23.31 89.9,23.31 RH605.2
  IN1 w0.089: v8(96.29,31.33) 96.07,31.33 95.44,30.7 95.44,28.04 93.6,26.2 93.6,23.59 93.28,23.27 91.09,23.27 91.06,23.31 90.59,23.31 v8(90.49,23.21)
CPU_DDC1DATA_T: length 3.8
  IN1 w0.076: v4(83.68,140.79) 83.85,140.96 86.14,140.96 v8(86.69,140.42)
  BOTTOM w0.081: v4(83.68,140.79) 83.68,140.91 UT1.R4
CPU_DDC2CLK: length 13.9
  TOP w0.089: UH1.AN13 99.14,32.47 v8(99.14,33)
  IN1 w0.089: v5(94.36,24.81) 94.52,24.65 95.3,24.65 95.73,25.08 95.73,29.71 97.04,31.03 97.04,32.93 97.45,33.34 98.35,33.34 98.54,33.15 98.54,33.04 98.63,32.95 99.09,32.95 v8(99.14,33)
  BOTTOM w0.107: RH607.2 94.62,25.07 v5(94.36,24.81)
CPU_DDC2CLK_T: length 1.5
  TOP w0.081: v4(81.75,139.03) 81.25,139.03 81.08,139.21 v2(80.89,139.21)
  BOTTOM w0.081: UT1.Y8 81.75,138.91 v4(81.75,139.03)
CPU_DDC2DATA: length 13.9
  TOP w0.107: UH1.AL10 97.62,32.9 v8(97.67,32.84)
  IN1 w0.089: v8(97.67,32.84) 97.69,32.86 98.27,32.86 98.36,32.95 98.36,33.07 98.27,33.16 97.52,33.16 97.22,32.86 97.22,30.95 95.91,29.64 95.91,25 95.38,24.48 94.61,24.48 v5(94.36,24.23)
  BOTTOM w0.107: v5(94.36,24.23) 94.39,24.19 RH606.2
CPU_DDC2DATA_T: length 4.3
  IN1 w0.076: v4(83.06,141.46) 83.26,141.25 86.49,141.25 v8(86.69,141.05)
  BOTTOM w0.081: v4(83.06,141.46) 83.06,141.46 83.06,141.52 UT1.N4
CPU_DISPA_BCLK: length 92.8
  TOP w0.081: v8(90.42,79.17) 90.07,78.82 v2(90.07,77.18) 90.07,74.49 88.69,73.12 83.79,73.12 83.45,72.78 83.45,70.8 81.38,68.72 81.38,60.58 80.64,59.84 80.64,54.9 82.56,52.98 82.56,52.75 82.56,45.18 84.31,43.42 84.31,39.53 86.57,37.27 86.57,37.04 86.57,37.04 86.57,32.52 86.8,32.29 88.38,32.29 RH38.1
  TOP w0.089: UC1.G27 100.09,104.08 v5(99.71,104.46)
  IN1 w0.097: v5(99.71,104.46) 100.56,104.46 100.98,104.04 100.98,94.98 100.64,94.64 96.62,94.64 96.24,94.26 96.24,88.38 95.83,87.97 95.83,85.51 93.53,83.21 91.88,83.21 90.75,82.08 90.75,79.5 v8(90.42,79.17)
CPU_DISPA_BCLK_R: length 4.7
  TOP w0.089: 93.19,32.5 93.79,32.5 UH1.AM3
  TOP w0.122: 93.19,32.5 92.13,32.5 92.12,32.49 92.11,32.5 92.05,32.5 91.97,32.43 90.98,32.43 90.93,32.37 90.68,32.37 90.34,32.03 RH38.2
CPU_DISPA_SDI: length 90.8
  TOP w0.081: RC66.2 92.66,106.9 v2(91.78,106.02) 91.56,105.8 90.01,105.8 90.01,105.81 89.99,105.81 89.99,105.81 86.67,105.81 v1(86.59,105.73)
  TOP w0.122: UH1.AN3 94.13,32.29 92.22,32.29 91.92,31.99 v5(91.41,31.99)
  GND2 w0.081: v1(86.59,105.73) 86.32,105.46 v3(86.32,105.12)
  IN3 w0.058: v3(86.32,105.12) 86.55,104.89 86.56,104.89 87.5,103.95 87.5,91.46 88.43,90.54 88.43,87.37 89.16,86.63 89.16,85.04 85.45,81.33 85.45,66.51 84.87,65.93 84.87,54.83 84.39,54.36 84.39,46.66 85.45,45.61 85.45,40.6 89.15,36.89 89.15,33.17 90.69,31.63 91.17,31.63 91.41,31.88 v5(91.41,31.99)
CPU_DISPA_SDI_R: length 7.4
  TOP w0.081: RC66.1 v8(93.93,107.38)
  IN1 w0.058: v8(93.93,107.38) 94.25,107.06 96.6,107.06 97.56,106.1 99.48,106.1 99.94,105.64 v8(100.09,105.64)
CPU_DISPA_SDO: length 89.5
  TOP w0.076: UC1.G25 100.47,102.87 v5(100.47,102.88)
  TOP w0.081: RH39.1 88.25,32.82 88.22,32.79 87.01,32.79 86.76,33.05 86.76,37.19 86.76,37.34 84.5,39.6 84.5,43.5 82.74,45.25 82.74,52.68 82.74,52.68 82.74,52.83 82.74,52.83 82.74,53.05 80.82,54.97 80.82,59.71 81.56,60.45 81.56,60.8 81.56,68.65 83.64,70.72 83.64,70.87 83.64,72.59 83.97,72.93 88.76,72.93 90.42,74.59 v2(90.42,75.48) v8(90.42,78.77)
  IN1 w0.097: v8(90.42,78.77) 90.12,79.07 90.12,81.89 91.74,83.51 93.55,83.51 95.64,85.6 95.64,88.05 95.98,88.39 95.98,95.6 96.56,96.17 100.14,96.17 100.79,96.82 100.79,102.56 v5(100.47,102.88)
CPU_DISPA_SDO_R: length 4.5
  TOP w0.081: 90.32,32.8 90.3,32.82
  TOP w0.089: UH1.AM2 93.48,32.94 93.24,33.19 92.34,33.19 91.95,32.79 90.63,32.79 v2(90.48,32.64) 90.32,32.8
  TOP w0.102: 90.3,32.82 RH39.2
CPU_DP1_AUXN: length 42.3
  IN1 w0.058: v8(98.79,104.06) 98.61,104.06 98.55,104.12 98.55,104.55 96.21,106.89 91.49,106.89 89.92,108.47
  IN1 w0.076: 89.92,108.47 89.47,108.91 89.47,109.25 88.51,110.21 85.04,110.21 77.65,117.61 77.65,120.8 76.86,121.58 76.86,131.47 76.48,131.85 76.48,131.97 v8(76.69,132.19)
CPU_DP1_AUXN_C: length 10.3
  TOP w0.089: v4(80.14,139.25) 80.31,139.08 80.48,139.08 80.72,138.83 80.72,138.34 80.33,137.95 80.33,136.53 79.4,135.61 79.4,135.44 79.41,135.43 79.41,134.89 79.4,134.87 79.4,134.46 78.76,133.82 v13(77.8,133.82) 76.88,133.82 76.62,133.56 76.62,132.84 CT26.2 RT76.1
CPU_DP1_AUXP: length 42.4
  IN1 w0.058: 89.92,108.2 91.41,106.71 96.13,106.71 98.37,104.47 98.37,104.12 98.31,104.06 v8(98.14,104.06)
  IN1 w0.076: v8(76.06,132.19) 76.28,131.97 76.28,131.77 76.66,131.39 76.66,121.5 77.44,120.71 77.44,117.52 84.96,110.01 88.42,110.01 89.27,109.16 89.27,108.83 89.78,108.32 89.79,108.32 89.84,108.27 89.85,108.27 89.92,108.2
CPU_DP1_AUXP_C: length 10.3
  TOP w0.089: v4(80.14,138.6) 80.11,138.63 80.11,138.79 80.19,138.88 80.39,138.88 80.52,138.75 80.52,138.43 80.12,138.03 80.12,136.62 79.2,135.69 v13(79.2,135.16) 79.2,134.55 78.68,134.03 78.08,134.03 78.07,134.04 77.53,134.04 77.52,134.03 76.79,134.03 76.42,133.65 76.42,133.1 76.08,132.77 CT25.2 RT78.1
CPU_DP1_HPD: length 144.2
  TOP w0.089: v4(84.09,138.36) 84.09,138.04 84.18,137.95 RT38.1
  TOP w0.122: UH1.AT6 95.5,31.51 95.38,31.63 v5(95.36,31.63)
  IN4 w0.076: 90.32,32.66 89.14,33.84 89.14,34.54 86.81,36.87 86.24,36.87 81.58,41.53 81,41.53 80.38,42.15 80.38,42.72 78.29,44.82 78.29,49.74 78.63,50.08 78.63,54.27 77.27,55.63 77.27,62.99 76.2,64.06 76.2,66.1 65.3,77 65.3,91.34 63.31,93.33 63.31,96.43 63.42,96.55 63.42,109.99 65.03,111.59 65.03,113.85 65.03,114.83 67.04,116.84 67.04,121.56 66.18,122.42 66.18,134.47 66.88,135.17 69.97,135.17 69.98,135.17 70.11,135.17 72.7,137.76 72.7,138.9 73.12,139.32 74.08,139.32 74.54,139.78 78.59,139.78 78.69,139.67 78.82,139.54 82.56,139.54 83.13,138.97 83.48,138.97 v4(84.09,138.36)
  IN4 w0.089: 90.32,32.66 90.32,32 90.78,31.54 93.99,31.54 94.09,31.63 v5(95.36,31.63)
CPU_DP1_N0: length 42.8
  TOP w0.076: UC1.K37 101.98,110.73 101.98,110.49 101.9,110.41 101.73,110.41 101.66,110.49 101.66,111.86 101.81,112.02 101.81,112.41 101.89,112.49 102.03,112.49 102.11,112.41 v8(102.11,112.23)
  IN1 w0.058: 101.1,115.46 101.11,115.45 101.11,115.44 102.29,114.26 102.29,113.32 102.61,113 102.61,112.55 102.37,112.31 102.18,112.31 v8(102.11,112.23)
  IN1 w0.076: 101.1,115.46 99.82,116.74 86.8,116.74 84.75,118.8 84.75,122.47 82.32,124.89 82.32,133.5 82.82,133.99 82.82,134.98 82.98,135.15 v4(83.04,135.15)
CPU_DP1_N0_C: length 2.7
  BOTTOM w0.081: CT7.2 82.8,135.98 82.8,136.18 81.92,137.06 81.92,137.18 82.01,137.27 82.01,137.56 81.94,137.63 81.85,137.63 81.79,137.57 UT1.AC7
CPU_DP1_N1: length 44.5
  IN1 w0.058: 99.39,115.46 99.41,115.46 99.42,115.45 100.36,115.45 101.92,113.89 101.92,112.93 101.35,112.36 101.35,110.34 101.72,109.96 101.72,109.23 101.42,108.94 101.27,108.94 v8(101.15,108.81)
  IN1 w0.076: 99.39,115.46 95.58,115.46 94.88,116.16 84.99,116.16 82.8,118.34 82.8,122.75 81.74,123.81 81.74,131.17 81.2,131.7 81.2,133.4 81.72,133.92 81.72,134.97 v4(81.9,135.15)
CPU_DP1_N1_C: length 2.7
  BOTTOM w0.081: CT9.2 81.73,135.9 81.73,136.13 80.97,136.89 80.97,137.13 81.11,137.27 81.11,137.59 81.06,137.63 80.95,137.63 80.87,137.55 UT1.AC9
CPU_DP1_N2: length 43.1
  TOP w0.076: v8(100.75,114.14) 100.64,114.03 100.64,114.03 100.37,114.03 100.12,113.79 v13(100.12,113.48) 100.12,112.79 100.26,112.65 100.26,111.05 100.09,110.88 100.09,110.65 100.09,110.39 UC1.H36
  IN1 w0.058: 99.51,114.8 99.51,114.79 100.45,113.85 100.76,113.85 100.82,113.91 100.82,114.07 v8(100.75,114.14)
  IN1 w0.076: 99.51,114.8 99.44,114.87 95.15,114.87 94.45,115.57 84.75,115.57 81.57,118.75 81.57,122.77 81.15,123.19 81.15,130.58 80.59,131.14 80.59,134.98 v4(80.76,135.15)
CPU_DP1_N2_C: length 2.5
  BOTTOM w0.081: UT1.AC11 79.95,137.55 80,137.6 80.11,137.6 80.17,137.54 80.17,137.22 80.07,137.12 80.07,136.64 80.46,136.25 80.46,136.03 CT23.2
CPU_DP1_N3: length 43
  TOP w0.076: v8(101.47,113.57) 100.88,112.97 100.88,112.6 101,112.47 101,111.92 100.87,111.78 100.8,111.78 100.72,111.71 100.72,111.49 100.8,111.41 UC1.J38
  IN1 w0.058: v8(101.47,113.57) 101.47,113.52 101.29,113.33 100.92,113.33 100.77,113.18 100.33,113.18 99.86,113.65 94.97,113.65 94.34,114.28
  IN1 w0.076: 94.34,114.28 93.66,114.96 89.94,114.96 89.93,114.97 84.52,114.97 80.57,118.92 80.57,130.1 79.78,130.89 79.78,133.51 79.38,133.92 79.38,134.91 v4(79.61,135.15)
CPU_DP1_N3_C: length 2.5
  BOTTOM w0.081: UT1.AC13 79.03,137.6 79.06,137.63 79.18,137.63 79.27,137.55 79.27,137.27 79.13,137.14 79.13,136.56 79.44,136.26 79.44,135.9 CT24.2
CPU_DP1_P0: length 42.8
  TOP w0.076: v8(102.11,112.74) 101.72,112.74 101.64,112.66 101.64,112.09 101.48,111.94 101.48,110.42 101.67,110.23 UC1.K36
  IN1 w0.058: v8(102.11,112.74) 102.11,112.55 102.17,112.49 102.3,112.49 102.43,112.62 102.43,112.92 102.11,113.24 102.11,114.18 100.93,115.36 100.92,115.36
  IN1 w0.076: v4(82.47,135.15) 82.61,135 82.61,134.08 82.12,133.58 82.12,124.81 84.54,122.38 84.54,118.71 86.72,116.54 99.74,116.54 100.92,115.36
CPU_DP1_P0_C: length 2.7
  BOTTOM w0.081: CT6.2 82.6,135.86 82.6,136.1 81.72,136.98 81.72,137.12 81.57,137.27 81.57,137.68 UT1.AB7
CPU_DP1_P1: length 44.5
  IN1 w0.058: v8(101.15,109.46) 101.15,109.18 101.21,109.12 101.35,109.12 101.54,109.31 101.54,109.88 101.16,110.26 101.16,112.44 101.73,113.01 101.73,113.81 100.28,115.26 99.42,115.26 99.41,115.26 99.39,115.26
  IN1 w0.076: v4(81.33,135.15) 81.52,134.95 81.52,134 81,133.48 81,131.62 81.53,131.08 81.53,123.73 82.6,122.66 82.6,118.26 84.91,115.95 94.8,115.95 95.5,115.26 99.39,115.26
CPU_DP1_P1_C: length 2.7
  BOTTOM w0.081: CT8.2 81.53,135.93 81.53,136.05 80.77,136.81 80.77,137.06 80.64,137.19 80.64,137.68 UT1.AB9
CPU_DP1_P2: length 43.1
  TOP w0.076: UC1.H37 100.36,110.48 100.44,110.41 100.57,110.41 100.7,110.53 100.7,110.83 100.48,111.04 100.45,111.07 100.45,112.73 100.31,112.87 100.31,113.16 100.33,113.18 100.33,113.73 100.44,113.84 100.56,113.84 100.75,113.65 v8(100.75,113.6)
  IN1 w0.058: 99.41,114.61 99.42,114.6 99.44,114.6 100.37,113.67 100.68,113.67 v8(100.75,113.6)
  IN1 w0.076: 99.41,114.61 99.35,114.67 95.06,114.67 94.37,115.37 84.66,115.37 81.43,118.6 81.37,118.66 81.37,122.69 80.95,123.11 80.95,130.5 80.39,131.06 80.39,134.94 v4(80.19,135.15)
CPU_DP1_P2_C: length 2.5
  BOTTOM w0.081: CT10.2 80.26,135.81 80.26,136.17 79.88,136.56 79.88,137.07 79.73,137.22 79.73,137.61 79.95,137.82 UT1.AB11
CPU_DP1_P3: length 43.1
  TOP w0.076: v8(101.46,113.15) 101.45,113.15 101.05,112.75 101.05,112.67 101.18,112.55 101.18,110.79 UC1.J37
  IN1 w0.058: 94.05,114.28 94.2,114.13 94.22,114.13 94.26,114.09 94.27,114.09 94.9,113.46 99.78,113.46 100.25,112.99 100.84,112.99 101,113.15 v8(101.46,113.15)
  IN1 w0.076: 94.05,114.28 93.58,114.76 89.86,114.76 89.85,114.77 84.44,114.77 80.37,118.84 80.37,130.02 79.58,130.8 79.58,133.43 79.17,133.84 79.17,135.02 v4(79.04,135.15)
CPU_DP1_P3_C: length 2.5
  BOTTOM w0.081: CT11.2 79.25,135.93 79.25,136.17 78.94,136.48 78.94,137.05 78.81,137.18 78.81,137.68 UT1.AB13
CPU_DP2_AUXN: length 45.5
  IN1 w0.058: v8(98.79,103.28) 98.93,103.28 98.98,103.34 98.98,103.45 98.9,103.53 96.46,103.53 94.23,105.76 89.94,105.76 89.93,105.75 89.92,105.75
  IN1 w0.076: v8(74.15,133.39) 74.23,133.39 74.39,133.23 74.39,133.04 75.36,132.07 75.36,131.82 76.07,131.11 76.07,121.26 76.86,120.47 76.86,117.28 85.15,108.99 85.85,108.99 89.1,105.75 89.92,105.75
CPU_DP2_AUXN_C: length 10.3
  TOP w0.089: v4(79.49,139.25) 79.49,139.22 79.31,139.04 79.13,139.04 78.92,138.83 78.92,138.37 79.3,137.99 79.3,137.02 v13(78.63,136.35) 77.49,135.21 76.15,135.21 76.14,135.23 75.6,135.23 75.59,135.21 74.58,135.21 74.37,135.01 74.37,134.5 74.15,134.29 CT36.2 RT77.1
CPU_DP2_AUXP: length 45.5
  IN1 w0.058: 89.92,105.95 89.93,105.95 89.94,105.94 94.31,105.94 96.53,103.72 98.98,103.72 99.17,103.53 99.17,103.35 99.24,103.28 v8(99.44,103.28)
  IN1 w0.076: v8(74.79,133.39) 74.75,133.39 74.59,133.23 74.59,133.12 75.56,132.15 75.56,131.9 76.28,131.19 76.28,121.34 77.06,120.55 77.06,117.37 85.23,109.2 85.94,109.2 89.18,105.95 89.92,105.95
CPU_DP2_AUXP_C: length 10
  TOP w0.089: v4(79.49,138.6) 79.49,138.66 79.31,138.84 79.21,138.84 79.12,138.75 79.12,138.46 79.5,138.08 79.5,136.93 78.97,136.4 78.97,136.39 78.59,136 78.57,136 77.58,135.01 v13(75.87,135.01) 74.66,135.01 74.57,134.92 74.57,134.5 74.79,134.29 CT35.2 RT79.1
CPU_DP2_HPD: length 143.1
  TOP w0.107: UH1.AN10 v5(97.62,31.6)
  IN4 w0.076: 90.32,32.91 89.57,33.66 89.57,34.36 86.89,37.05 86.31,37.05 78.46,44.89 78.46,49.67 78.8,50.01 78.8,54.35 77.44,55.7 77.44,63.07 76.38,64.14 76.38,66.17 65.48,77.07 65.48,91.41 65.14,91.75 65.14,92.86 65.25,92.98 65.25,94.29 63.6,95.94 63.6,109.91 65.21,111.52 65.21,114.04 65.21,114.76 67.22,116.77 67.22,121.63 66.35,122.49 66.35,134.4 66.95,135 69.9,135 69.9,135 70.19,135 72.88,137.69 72.88,138.83 73.19,139.14 74.15,139.14 74.61,139.6 78.51,139.6 79.06,139.05 79.06,138.55 79.38,138.23 v4(81.65,138.23)
  IN4 w0.089: 90.32,32.91 90.85,32.38 95.25,32.38 95.57,32.06 96.3,32.06 96.76,31.6 v5(97.62,31.6)
  BOTTOM w0.081: v4(81.65,138.23) 81.72,138.23 UT1.Y6
CPU_DP2_N0: length 45.2
  IN1 w0.058: 93.47,114.28 94.72,113.03 99.65,113.03 100.39,112.29 100.39,110.33 100.86,109.86 100.86,108.54 100.61,108.3 100.46,108.3 100.36,108.2 v8(100.36,108.16)
  IN1 w0.076: 93.47,114.28 93.42,114.33 89.99,114.33 89.98,114.32 89.94,114.32 89.94,114.33 89.93,114.33 89.92,114.34 84.33,114.34 79.98,118.68 79.98,121.77 79.6,122.15 79.6,123.8 79.98,124.18 79.98,129.64 79.2,130.43 79.2,133.12 78.31,134.01 78.31,134.98 v4(78.47,135.15)
CPU_DP2_N0_C: length 2.4
  BOTTOM w0.081: CT28.2 78.3,135.9 78.3,136.63 78.21,136.73 78.21,137.1 78.35,137.24 78.35,137.57 78.27,137.65 78.19,137.65 78.11,137.57 UT1.AC15
CPU_DP2_N1: length 43.1
  IN1 w0.058: v8(99.86,111.41) 99.86,111.21 99.8,111.15 99.67,111.15 99.6,111.22 99.6,111.53 99.7,111.63 99.7,112.18 99.35,112.52 98.58,112.52 97.88,111.82 95.15,111.82 93.91,113.06 89.94,113.06 89.93,113.07 89.92,113.07
  IN1 w0.076: v4(77.33,135.15) 77.09,134.91 77.09,134.27 78.61,132.75 78.61,129.91 79.38,129.14 79.38,124.54 78.99,124.16 78.99,121.93 79.4,121.52 79.4,118.44 84.08,113.76 86.65,113.76 87.33,113.07 89.92,113.07
CPU_DP2_N1_C: length 2.4
  BOTTOM w0.081: UT1.AC17 77.19,137.56 77.27,137.64 77.33,137.64 77.41,137.57 77.41,137.24 77.25,137.08 77.25,136.53 77.16,136.45 77.16,135.89 CT30.2
CPU_DP2_N2: length 44.2
  IN1 w0.058: v8(99.58,109.46) 99.63,109.46 99.75,109.34 99.75,109.26 99.67,109.18 99.32,109.18 99.25,109.24 99.25,109.69 99.44,109.88 99.44,110.56 98.75,111.25 95.06,111.25 93.95,112.36 89.94,112.36 89.93,112.37 89.92,112.37
  IN1 w0.076: v4(76.19,135.15) 76.02,134.98 76.02,134.44 78.03,132.44 78.03,122.07 78.82,121.28 78.82,118.2 83.88,113.13 85.98,113.13 86.74,112.37 89.92,112.37
CPU_DP2_N2_C: length 2.6
  BOTTOM w0.081: CT32.2 76.01,135.91 76.01,136.3 76.39,136.68 76.39,137.06 76.51,137.18 76.51,137.57 76.43,137.65 76.35,137.65 76.27,137.57 UT1.AC19
CPU_DP2_N3: length 43.6
  TOP w0.081: UC1.E36 98.79,110.26 98.95,110.42 v8(98.96,110.42)
  IN1 w0.058: 89.92,111.79 89.93,111.79 89.94,111.78 93.91,111.78 95.61,110.08 96.57,110.08 97.32,110.83 98.55,110.83 98.96,110.42 v8(98.96,110.42)
  IN1 w0.076: v4(75.04,135.15) 74.92,135.02 74.92,134.41 75.29,134.04 75.59,134.04 77.44,132.18 77.44,121.83 78.23,121.04 78.23,117.96 83.68,112.51 85.57,112.51 86.3,111.79 89.92,111.79
CPU_DP2_N3_C: length 2.6
  BOTTOM w0.081: UT1.AC21 75.35,137.55 75.43,137.63 75.51,137.63 75.59,137.55 75.59,137.2 75.43,137.04 75.43,136.61 74.87,136.04 74.87,135.91 CT34.2
CPU_DP2_P0: length 45.2
  IN1 w0.058: 89.92,114.14 89.98,114.14 89.99,114.15 93.34,114.15 94.64,112.84 99.58,112.84 100.21,112.21 100.21,110.25 100.67,109.79 100.67,108.62 100.53,108.48 100.39,108.48 100.33,108.54 100.33,108.78 v8(100.36,108.81)
  IN1 w0.076: v4(77.9,135.15) 78.11,134.94 78.11,133.93 78.99,133.04 78.99,130.35 79.78,129.56 79.78,124.27 79.4,123.89 79.4,122.06 79.78,121.68 79.78,118.6 84.24,114.14 89.92,114.14
CPU_DP2_P0_C: length 2.4
  BOTTOM w0.081: CT27.2 78.11,135.94 78.11,136.55 78.01,136.65 78.01,137.07 77.89,137.19 77.89,137.68 UT1.AB15
CPU_DP2_P1: length 43.1
  IN1 w0.058: 89.92,112.87 89.93,112.87 89.94,112.88 93.84,112.88 95.08,111.64 97.96,111.64 98.66,112.34 99.27,112.34 99.51,112.1 99.51,111.71 99.42,111.61 99.42,110.93 v8(99.58,110.76)
  IN1 w0.076: v4(76.76,135.15) 76.89,135.02 76.89,134.19 78.41,132.66 78.41,129.82 79.17,129.06 79.17,124.62 78.79,124.24 78.79,121.85 79.2,121.44 79.2,118.36 84,113.55 86.56,113.55 87.25,112.87 89.92,112.87
CPU_DP2_P1_C: length 2.4
  BOTTOM w0.081: UT1.AB17 76.97,137.68 76.97,137.12 77.05,137.04 77.05,136.61 76.97,136.53 76.97,135.94 CT29.2
CPU_DP2_P2: length 44.2
  IN1 w0.058: v8(99.58,108.81) 99.58,108.94 99.52,108.99 99.24,108.99 99.07,109.17 99.07,109.77 99.25,109.95 99.25,110.48 98.67,111.06 94.99,111.06 93.87,112.18 89.94,112.18 89.93,112.17 89.92,112.17
  IN1 w0.076: v4(75.61,135.15) 75.82,134.94 75.82,134.36 77.83,132.35 77.83,121.98 78.61,121.2 78.61,118.11 83.8,112.93 85.89,112.93 86.66,112.17 89.92,112.17
CPU_DP2_P2_C: length 2.6
  BOTTOM w0.081: UT1.AB19 76.05,137.68 76.05,137.19 76.19,137.04 76.19,136.76 75.81,136.38 75.81,135.93 CT31.2
CPU_DP2_P3: length 43.7
  TOP w0.081: UC1.E37 v8(98.55,110.45)
  IN1 w0.058: 89.92,111.58 89.93,111.58 89.94,111.59 93.84,111.59 95.53,109.9 96.65,109.9 97.4,110.64 98.48,110.64 98.55,110.57 v8(98.55,110.45)
  IN1 w0.076: 89.92,111.58 86.21,111.58 85.49,112.31 83.59,112.31 78.03,117.87 78.03,120.95 77.24,121.74 77.24,132.1 75.51,133.84 75.21,133.84 74.71,134.33 74.71,134.97 74.53,135.15 v4(74.47,135.15)
CPU_DP2_P3_C: length 2.6
  BOTTOM w0.081: UT1.AB21 75.13,137.68 75.13,137.18 75.23,137.07 75.23,136.69 74.67,136.13 74.67,135.93 CT33.2
CPU_FAN_FB: length 5.6
  TOP w0.076: UE5.M11 82.91,16.61 84.2,16.61
  TOP w0.081: 84.2,16.61 84.98,16.61 85.15,16.79 85.15,17.36 RF1.1 85.72,18.44 85.28,18.89 DF1.2
CPU_FAN_PWM: length 134.7
  TOP w0.076: UE5.M10 82.92,16.12 84.2,16.12
  TOP w0.081: v6(85.76,16.22) 85.66,16.12 84.2,16.12 ; v5(14.72,49.14) v2(14.72,48.66)
  IN2 w0.058: v4(14.86,52.14) 14.86,49.28 v5(14.72,49.14) 13.79,48.21 13.79,38.79 13.43,38.43 13.43,30.71 10.32,27.59 10.32,23.07 9.99,22.75 9.99,16.27 10.7,15.56 10.7,13.43 12.23,11.91 12.23,8.67 15.05,5.84 28.78,5.84 32.73,9.79 40.14,9.79 v6(41.58,11.23)
  IN4 w0.058: 81.2,10.57 81.2,10.47 81.18,10.44 ; 80.95,10.21 80.94,10.2 80.93,10.2 80.53,9.81 78.41,9.81 77.7,9.1 76.43,9.1 76.24,9.29 75.82,9.29 75.52,8.99 73.61,8.99 73.3,9.3 73.12,9.3 72.96,9.46 70.67,9.46 70.35,9.13 68.54,9.13 68.38,9.3 43.51,9.3 v6(41.58,11.23) ; v6(85.76,16.22) 85.04,16.22 84.44,15.62
  IN4 w0.076: 81.2,10.57 81.2,12.48 80.42,13.26 80.42,13.57 80.49,13.64 81.33,13.64 81.48,13.5 82.72,13.5 84.44,15.21 84.44,15.62 ; 81.18,10.44 80.95,10.21
CPU_TRIGGER: length 81
  TOP w0.089: v1(91.98,34.44) 92.48,33.95 93.21,33.95 93.33,34.07 UH1.AK2
  GND2 w0.089: v1(91.98,34.44) v3(91.98,34.8)
  IN3 w0.058: v9(89.32,89.64) 89.23,89.54 89.23,87.71 90,86.94 90,84.7 86.25,80.96 86.25,55.08 85.19,54.02 85.19,46.99 86.25,45.94 86.25,40.93 90.28,36.9 90.28,35.17 90.91,34.55 91.69,34.55 91.94,34.8 v3(91.98,34.8)
  GND4 w0.081: v9(89.32,89.64) 89.61,89.64 89.66,89.69 v6(89.79,89.69)
  IN4 w0.058: v6(89.79,89.69) 89.94,89.84 90.76,89.84 93.04,92.13 93.04,96.27 94.69,97.91 94.69,100.17 95.76,101.25 v7(97.02,101.25)
  BOTTOM w0.081: v2(97.8,100.14) 97.8,100.42 97.02,101.21 v7(97.02,101.25)
CPU_XDP_TRST#: length 253.8
  TOP w0.076: v5(137.9,106.96) 137.58,106.65 136.33,106.65 136.17,106.49 135.81,106.49 UC1.BP30
  TOP w0.081: 143.67,141.72 142.33,143.06 RH497.2 ; 143.67,141.72 v8(143.68,141.72) ; 143.67,141.72 145.03,140.35 JPCMC.28
  TOP w0.122: UH1.AM4 94.49,32.96 94.82,33.3 95.27,33.3 v5(95.3,33.27)
  IN1 w0.058: v8(143.68,141.72) 143.68,139.48 v5(144.96,138.2)
  IN2 w0.058: v6(70.48,115.38) 70.65,115.22 80.66,115.22 v3(80.84,115.39)
  IN3 w0.058: v3(80.84,115.39) 80.84,115.63 81.01,115.8 81.01,116.34 80.79,116.55 80.79,131.65 83.33,134.19 85.73,134.19 86.5,134.95 88.25,134.95 90.45,137.15 96.56,137.15 97.72,138.31 104.4,138.31 106.04,136.68 107.57,136.68 108.27,137.37 120.34,137.37 121.07,138.1 144.86,138.1 v5(144.96,138.2) 145.38,137.78 146.22,137.78 147.19,136.81 148.11,136.81 150.79,134.13 150.79,132.84 150.46,132.51 150.46,131.16 149.95,130.65 149.95,121.22 146.31,117.59 145.72,117.59 144.63,116.5 144.63,112.73 144.63,112.73 144.63,112.47 143.16,111.01 142.91,111.01 142.91,111.01 142.77,111.01 142.77,111.01 140.57,111.01 140.16,110.59 v9(139.45,110.59)
  GND4 w0.081: v9(139.45,110.59) v6(139.17,110.59)
  IN4 w0.058: v6(70.48,115.38) 69.49,114.39 67.37,114.39 65.85,112.87 65.85,111.25 64.31,109.7 64.31,99.91 67.41,96.81 67.41,93.08 67.74,92.76 67.74,88.14 68.03,87.85 68.03,82.61 68.63,82.01 68.63,80.6 70.31,78.91 70.31,75.45 70.58,75.18 70.58,72.89 77.03,66.45 77.03,64.48 78.09,63.41 78.09,55.97 79.45,54.62 79.45,49.74 79.11,49.4 79.11,45.16 86.51,37.77 88.12,37.77 89.02,36.87 89.02,35.91 90.32,34.61
  IN4 w0.081: v6(139.17,110.59) 139.17,110.15 137.9,108.88 v5(137.9,106.96)
  IN4 w0.089: v5(95.3,33.27) 95.12,33.1 91.82,33.1 90.32,34.61
  BOTTOM w0.089: v10(96.34,33.2) 96.27,33.27 v5(95.3,33.27)
CS_1.2V: length 4
  TOP w0.081: v2(151.71,46.66) 151.17,47.21 150.23,47.21 149.9,46.88 PRM13.2
  TOP w0.203: PUM1.13 149.32,47.28 PRM13.2
CSCOMP_2PH: length 32.8
  TOP w0.152: PHZ02.1 141.47,97.17 v5(141.6,97.31)
  TOP w0.203: PRZ50.2 v1(142.56,121.07) 142.48,121 PCZ37.1 141.54,121.01 PCZ16.1 142.05,122.44 142.05,123.65 142.52,124.12 PUZ1.31
  GND2 w0.152: v1(142.56,121.07) v12(142.37,120.88)
  IN2 w0.152: v5(141.6,97.31) 141.6,98.96 143.13,100.48 143.13,102.14 142.81,102.45 142.81,117.69 141.86,118.65 141.86,120.37 v12(142.37,120.88)
  BOTTOM w0.081: v5(141.6,97.31) 141.6,97.39 141.3,97.69 v2(141.07,97.69)
CSCOMP_4PH: length 82
  TOP w0.203: PUZ1.8 142.92,132.23 142.75,132.4 142.75,132.88 v4(142.05,133.58) PRZ69.1 ; PHZ05.1 v5(82.98,125.83)
  IN1 w0.152: v5(82.98,125.83) 83.36,126.22 83.36,127.78 83.26,127.88 83.26,132.34 87.28,136.36 87.37,136.36 88.91,136.36 90.1,137.54 92.16,137.54 92.88,138.25 97.35,138.25 98.21,139.12 110.06,139.12 110.63,138.55 136.53,138.55 136.94,138.13 142.41,138.13 142.82,137.72 142.82,137.72 143.41,137.14 143.41,134.14 142.85,133.58 v4(142.05,133.58)
  BOTTOM w0.081: v5(82.98,125.83) 82.97,125.83 v2(82.44,125.3)
  BOTTOM w0.203: v4(142.05,133.58) PRZ76.1
CSIN_CHG: length 4.7
  BOTTOM w0.254: PRB7.2 46.7,23.06 PCB2.2 ; PCB2.2 45.69,22.16 PCB32.1 ; PCB2.2 46.9,21.96 46.89,21.94 46.89,21.3 46.41,20.83 46.41,20.5 46.31,20.39 PUB1.31
CSIP_CHG: length 4.9
  BOTTOM w0.254: PCB2.1 48.16,22.16 PCB20.1 ; PCB2.1 47.24,21.8 47.24,21.16 v13(47.05,20.96) 46.77,20.68 46.77,20.35 46.71,20.28 PUB1.32 ; PCB2.1 47.61,23.02 PRB6.2
CSN_1PH: length 38.2
  TOP w0.152: PHZ01.1 145.34,109.96 145.98,109.31 145.98,108.17 v5(145.8,107.98) PLG02.3
  IN4 w0.152: v7(146.93,135.66) 146.93,134.37 148.03,133.26 148.03,127.33 149.22,126.14 149.22,122.3 143.64,116.72 143.64,108.74 144.4,107.98 v5(145.8,107.98)
  BOTTOM w0.081: v7(146.93,135.66) 146.24,135.66 v2(145.97,135.93)
CSN_1PH_R: length 13.6
  TOP w0.203: PUZ1.48 146.79,128.65 146.81,128.68 v8(147,128.68)
  TOP w0.254: PCZ35.1 149.28,134.84 PCZ13.1 148.4,135.17 147.9,135.66 v1(147.68,135.66)
  IN1 w0.254: v8(147,128.68) 146.74,128.94 146.74,133.38 147.1,133.75 147.1,135.09 v1(147.68,135.66)
  GND2 w0.254: v3(148.39,135.21) 148.01,135.59 147.75,135.59 v1(147.68,135.66)
  GND4 w0.254: v4(148.64,135.66) 148.39,135.41 v3(148.39,135.21)
  BOTTOM w0.081: PRZ4.2 147.84,135.14 147.98,135 v2(147.98,134.64)
  BOTTOM w0.254: v4(148.64,135.66) PRZ4.2
CSN_FBVDDQ: length 8.5
  TOP w0.254: PUW1.13 8.96,52.67 v2(8.99,52.64) 9.52,52.1 v8(9.89,52.1)
  IN1 w0.254: v8(12.97,56.54) 12.09,56.54 11.43,55.88 11.43,54.19 10.45,53.22 10.45,52.94 10.45,52.65 10.15,52.35 10.14,52.35 v8(9.89,52.1)
CSNSUM_GPU: length 3.5
  TOP w0.203: PUV1.21 76.82,27.1 77.03,26.9 77.03,26.69 77.74,25.98 v5(77.79,25.98) v2(77.79,25.47) 77.79,25.38 PRV214.1
CSON_CHG: length 6.7
  BOTTOM w0.254: PUB1.14 44.71,15.16 44.66,15.11 44.66,14.53 44.25,14.11 44,14.11 42.98,13.09 v13(42.98,12.28) 42.98,11.83 42.7,11.55 42.33,11.55 PCB4.2 41.17,11.25 PRB21.1
CSOP_CHG: length 5.9
  BOTTOM w0.254: PUB1.15 44.31,14.67 44.1,14.47 43.85,14.47 v13(43.39,14) 42.61,13.22 42.61,12.17 42.5,12.05 42.15,12.05 PCB4.1 41.96,12.09 PRB8.1
CSP1_2PH: length 4
  TOP w0.203: PCZ2.2 140.27,123.34 v5(140.46,123.53) 141.32,124.39 PUZ1.28
  BOTTOM w0.081: v5(140.46,123.53) 139.97,123.53 v2(139.84,123.4)
  BOTTOM w0.254: v5(140.46,123.53) 141.03,122.95 PRZ59.1
CSP1_4PH: length 11.9
  TOP w0.203: PUZ1.11 141.72,131.41 v5(141.09,132.04) 141.09,132.61 PCZ7.2
  TOP w0.254: PRZ60.2 141.94,138.46 v1(141.1,138.46) PRZ56.2
  GND2 w0.254: v12(141.09,137.95) 141.09,138.45 v1(141.1,138.46)
  IN2 w0.254: v5(141.09,132.04) v12(141.09,137.95)
  BOTTOM w0.081: v5(141.09,132.04) 141.09,131.44 140.96,131.31 v2(140.96,131.16)
  BOTTOM w0.254: PRZ45.2 140.97,132.54 141.09,132.42 141.09,132.18 v5(141.09,132.04)
CSP1_FBVDDQ: length 6.1
  TOP w0.254: PUW1.16 7.07,54.56 7.32,54.81 7.67,54.81 7.99,55.13 PRW2.1 8.75,55.86 PCW4.1 8.79,55.3 8.57,55.08 8.57,54.32 v2(8.9,53.99) PRW18.1
CSP1_GPU: length 5.2
  TOP w0.203: PUV1.20 75.97,25.73 76.26,25.43 76.85,25.43 PCV1.1 77.28,23.98 77.28,23.22 PRV23.1
CSP2_4PH: length 13.2
  TOP w0.203: PUZ1.12 141.32,131.31 141.03,131.6 140.67,131.6 140.46,131.8 v5(140.46,132.04) 140.14,132.36 PCZ6.2
  TOP w0.254: PRZ58.2 PRZ55.2 v1(139.7,138.46)
  GND2 w0.254: v12(140.26,138.2) 139.95,138.2 v1(139.7,138.46)
  IN2 w0.254: v5(140.46,132.04) 140.61,132.2 140.61,137.85 v12(140.26,138.2)
  BOTTOM w0.081: v5(140.46,132.04) 140.46,132.02 140.12,131.68 139.87,131.68 v2(139.62,131.43)
  BOTTOM w0.254: PCZ6.2 140.14,132.36 v5(140.46,132.04)
CSP2_FBVDDQ: length 8.2
  TOP w0.081: PRW1.1 13.49,55.72 v2(13.89,55.31)
  TOP w0.254: PUW1.15 11.52,53.47 PRW17.1 PCW2.1 12.7,54.63 PRW26.2 PRW1.1
CSP2_GPU: length 4.6
  TOP w0.203: PRV10.1 76.26,23.22 76.26,23.98 PCV14.1 76.15,25.11 76.07,25.11 75.56,25.62 75.57,25.62 PUV1.19
CSP3_4PH: length 13.9
  TOP w0.203: PCZ1.2 139.26,132.31 v5(139.62,131.95) 139.7,131.87 139.7,131.71 140.49,130.93 PUZ1.13
  TOP w0.254: PRZ57.2 PRZ61.2 v1(137.07,138.43)
  GND2 w0.254: v12(137.55,137.95) v1(137.07,138.43)
  IN2 w0.254: v5(139.62,131.95) 139.62,135.89 v12(137.55,137.95)
  BOTTOM w0.081: v2(138.32,132.67) PRZ41.2
  BOTTOM w0.254: PRZ41.2 139.32,132.3 139.62,132 v5(139.62,131.95)
CSP3_FBVDDQ: length 2.2
  TOP w0.254: PRW25.2 9.41,52.86 9.2,53.07 PUW1.14
CSP3_GPU: length 4.3
  TOP w0.203: PRV16.1 75.25,23.22 75.25,23.98 PCV7.1 75.76,24.62 75.17,25.2 PUV1.18
CSP4_GPU: length 4.1
  TOP w0.203: PUV1.17 74.77,24.52 PCV3.1 74.23,23.98 74.23,23.22 PRV27.1
CSP5_GPU: length 4.3
  TOP w0.203: PRV15.1 73.22,23.22 73.22,23.98 PCV16.1 74.37,25.13 PUV1.16
CSP6_GPU: length 4.7
  TOP w0.203: PRV7.1 72.2,23.22 72.2,23.98 PCV11.1 72.85,24.49 73.97,25.61 PUV1.15
CSP7_GPU: length 5.2
  TOP w0.203: PUV1.14 73.57,25.72 72.83,24.98 72.19,24.98 PCV15.1 71.18,23.98 71.18,23.22 PRV11.1
CSP8_GPU: length 5.8
  TOP w0.203: PRV14.1 70.17,23.22 70.17,23.98 PCV9.1 71.3,25.11 71.82,25.11 72.01,25.3 72.64,25.3 73.17,25.82 PUV1.13
CSP_1PH: length 43.5
  TOP w0.152: v5(146.88,110.39) 147.28,110.39 147.41,110.52 PRZ11.1
  TOP w0.203: PRZ49.2 147.59,133.92 PCZ13.2 148.41,133.94 v1(149.29,133.94) ; PUZ1.47 146.95,128.25 v8(147.02,128.32)
  TOP w0.254: v8(146.38,133.35) 146.41,133.38 147.05,133.38 147.57,133.91 PRZ49.2
  IN1 w0.254: v8(146.38,133.35) 146.38,128.76 146.81,128.32 v8(147.02,128.32)
  GND2 w0.254: v1(149.29,133.94) v3(149.29,134.36)
  GND4 w0.254: v3(149.29,134.36) v6(149.73,134.36)
  IN4 w0.152: v5(146.88,110.39) 146.88,110.71 146.56,111.03 145.16,111.03 144.84,111.34 144.84,116.42 149.94,121.52 149.94,128.34 149.02,129.25 149.02,133.64 v6(149.73,134.36)
  BOTTOM w0.081: v5(146.88,110.39) v2(146.88,109.6)
CSPSUM_GPU: length 20
  TOP w0.203: PUV1.22 77.18,27.5 77.41,27.28 77.41,26.92 v5(77.79,26.54) 78.76,26.54 PRV210.1
  TOP w0.254: PCV210.1 PRV210.1
  IN4 w0.254: v7(75.76,22.72) 76.35,23.32 76.35,26.01 76.88,26.54 v5(77.79,26.54)
  BOTTOM w0.081: v2(77.29,25.64) 77.29,26.08 77.76,26.54 v5(77.79,26.54)
  BOTTOM w0.203: v5(77.79,26.54) 78.69,26.54 PRV212.1 PCV209.1
  BOTTOM w0.254: PRV204.2 PRV205.2 PRV206.2 PRV207.2 PRV208.2 PRV209.2 ; PRV204.2 v7(75.76,22.72) ; PRV204.2 PRV203.2 PRV202.2
CSREF_2PH: length 40.3
  TOP w0.203: PCZ2.1 140.27,122.01 140.84,122.58 140.84,123.28 v5(141.1,123.54) 141.1,123.74 141.72,124.36 PUZ1.29
  IN4 w0.152: v5(141.1,123.54) 141.54,123.09 141.54,118.91 142.3,118.15 142.3,99.41 147.19,94.52 v5(147.19,93.75)
  BOTTOM w0.254: PRG03.2 146.43,95.27 v2(146.57,95.13) 147.19,94.5 v5(147.19,93.75) ; PCZ12.1 141.99,124.42 v5(141.1,123.54)
CSREF_4PH: length 16.4
  TOP w0.203: PCZ7.1 141.53,133.09 141.53,132.31 v5(141.8,132.04) 141.8,131.82 142.12,131.49 PUZ1.10
  TOP w0.254: PCZ1.1 PCZ6.1 PCZ7.1
  BOTTOM w0.081: v2(136.27,133.25) PRZ132.2
  BOTTOM w0.254: PRZ41.1 PCZ6.1 PRZ45.1 ; PCZ11.2 142.11,131.45 141.8,131.77 v5(141.8,132.04) 141.48,132.36 141.48,133.07 PRZ45.1 ; PRZ45.1 141.1,133.71 PRZ110.2 PRZ109.2 PRZ86.2 PRZ87.2 138.15,134.42 PRZ133.2 136.3,134.42 PRZ132.2
CSSN_B+: length 20.1
  TOP w0.081: v6(11.57,37.4) 11.34,37.18 v2(11.34,37.02)
  TOP w0.254: PRV109.3 16.69,34.6 16.43,34.34 13.9,34.34 13.53,34.71 13.53,36.09 12.22,37.4 v6(11.57,37.4)
  IN4 w0.254: v6(11.57,37.4) 9.45,39.52 2.02,39.52 v6(1.7,39.84)
CSSN_NVVDD: length 23.8
  TOP w0.254: RG66.1 1.64,35.74 1.64,36.02 v5(1.4,36.26)
  IN4 w0.254: v7(17.01,38.5) 17.01,35.3 16.28,34.57 13.82,34.57 12.67,35.71 8,35.71 7.3,35.02 3.75,35.02 3.17,34.44 1.78,34.44 1.4,34.83 v5(1.4,36.26)
  BOTTOM w0.081: v7(17.01,38.5) v2(17.01,39.82)
CSSP_B+: length 28.3
  TOP w0.254: PRV109.2 14.29,33.26 13.12,34.43 13.12,35.8 12.34,36.58 v6(11.57,36.58)
  IN1 w0.254: v8(1.7,29.05) 1.97,29.05 2.48,29.56 2.48,35.97 1.33,37.11 1.33,38.65 v6(1.7,39.02)
  IN4 w0.254: v6(1.7,39.02) 9.13,39.02 v6(11.57,36.58)
CSSP_NVVDD: length 15.2
  IN1 w0.254: v8(1.7,33.17) 2.12,33.59 2.12,34.43 v1(1.73,34.83)
  GND2 w0.254: v1(1.73,34.83) v3(2.16,34.83)
  GND4 w0.254: v3(2.16,34.83) v6(2.54,34.83)
  IN4 w0.254: v7(12.71,36.1) 7.82,36.1 7.24,35.52 3.24,35.52 v6(2.54,34.83)
  BOTTOM w0.081: v7(12.71,36.1) 12.71,35.97 v2(13.83,34.85)
CSSUM_2PH: length 8.1
  TOP w0.203: PRZ64.2 PCZ37.2 140.97,121.33 140.97,122.28 PCZ16.2 141.54,123.75 142.12,124.33 PUZ1.30
  TOP w0.254: v5(139.94,120.09) 140.63,120.09 PRZ64.2
  BOTTOM w0.081: v5(139.94,120.09) v2(139.94,119.12)
  BOTTOM w0.254: PRZ15.1 v5(139.94,120.09)
CSSUM_4PH: length 14.7
  TOP w0.203: PUZ1.9 142.52,131.82 142.41,131.93 v5(142.41,131.96) 142.37,131.99 142.37,132.1 142.05,132.43 PCZ27.2
  TOP w0.254: v4(142.94,134.44) 142.94,134.52 PRZ12.1 PRZ13.1 PRZ16.1 PRZ14.1 PRZ154.1 PRZ153.1
  IN1 w0.254: v4(142.94,134.44) 142.58,134.09 141.99,134.09 141.66,133.76 141.66,133.23 142.41,132.48 v5(142.41,131.96)
  BOTTOM w0.081: v5(142.41,131.96) 142.7,131.66 v2(143.04,131.66)
  BOTTOM w0.254: PCZ27.2 142.37,132.34 142.37,131.99 v5(142.41,131.96)
CTL1: length 77.8
  IN1 w0.058: 76.58,17.49 76.38,17.69 73.72,17.69 72.02,16 72.02,15.06 70.72,13.77 70.72,12.39 67.12,8.79 16.14,8.79 15.97,8.62 13.59,6.24 v5(13.59,5.87)
  IN1 w0.076: v8(78.67,16.87) 78.02,16.87 77.77,16.62 77.56,16.62 77.42,16.76 77.42,16.87 77.41,16.87 77.41,16.97 77.27,17.11 76.96,17.11 76.58,17.49
  IN3 w0.058: v9(10.81,8.3) 10.91,8.3 11.34,7.86 11.5,7.86 13.49,5.87 v5(13.59,5.87)
  GND4 w0.081: v4(10.66,8.74) 10.81,8.59 v9(10.81,8.3)
  BOTTOM w0.081: v2(12.73,5.08) 13.13,5.49 13.13,5.58 13.42,5.87 v5(13.59,5.87)
CTL2: length 80.2
  TOP w0.081: v2(12.03,5.78) 12.47,6.23 v5(12.62,6.23)
  IN1 w0.058: 76.58,18.37 73.79,18.37 71.61,16.19 71.61,15.92 70.4,14.72 70.4,12.55 66.97,9.11 16.01,9.11 15.65,8.75 14.79,7.89 14.11,7.89 12.62,6.4 v5(12.62,6.23)
  IN1 w0.076: v8(81.17,17.37) 81.17,17.47 80.42,18.22 78.87,18.22 78.72,18.37 76.58,18.37
  IN3 w0.058: v5(12.62,6.23) 12.62,6.51 11.48,7.65 11.33,7.65 11.05,7.93 10.77,7.93 v9(10.29,8.41)
  GND4 w0.081: v4(10.06,8.74) 10.29,8.51 v9(10.29,8.41)
DAC_GPU: length 5.4
  TOP w0.203: PUV1.28 77.62,29.9 v5(78.14,30.43) 78.28,30.57 PCV10.1
  BOTTOM w0.254: PCV13.2 77.19,31.38 v2(77.8,30.77) v5(78.14,30.43) 78.35,30.63 PRV32.2
DAT_SMB: length 10.9
  TOP w0.081: v2(31.29,4.35) 31.78,3.86 PR21.1 31.78,3.37 32.21,2.93 32.34,2.93 32.5,3.09 v5(32.5,3.15)
  BOTTOM w0.081: v5(32.5,3.15) 32.5,3.11 32.71,2.9 32.85,2.9 33,3.06 33,5.34 31.37,6.97 31.37,8.94 31.29,9.02 30.93,9.02 30.82,9.13 PBATT1.6
DCIN_CHG: length 3.1
  TOP w0.081: 42.38,15.26 42.91,15.26 v2(43.04,15.38)
  BOTTOM w0.203: PCB21.1 42.04,16.09 42.1,16.16 v5(42.16,16.16) 42.35,16.16 42.87,16.67 PUB1.18
DCIN_ISL95338_1: length 4.6
  TOP w0.081: v2(57.82,35.02) 58.37,34.47 PRV90.2
  BOTTOM w0.203: PCV37.1 59.31,34.6 v5(59.31,32.86)
  BOTTOM w0.254: PUV3.17 58.79,32.59 59.05,32.86 v5(59.31,32.86)
DDR_A_ACT#: length 55.8
  IN4 w0.086: v6(123.51,86.09) 123.65,86.09 123.79,86.23 123.79,86.37 123.65,86.51 123.52,86.51 123.42,86.62 123.42,86.84 123.5,86.93 123.69,86.93 123.77,87.01 123.77,87.19 123.69,87.27 123.5,87.27 123.42,87.36 123.42,87.53 123.5,87.62 123.69,87.62 123.77,87.7 123.77,87.88 123.69,87.96 123.5,87.96 123.42,88.05 123.42,88.25 123.76,88.6 124.01,88.6 124.33,88.27 124.33,79.28 124.25,79.19 123.78,79.19 123.69,79.1 123.69,78.93 123.78,78.85 124.2,78.85 124.29,78.76 124.29,78.59 124.2,78.5 123.78,78.5 123.69,78.41 123.69,78.24 123.78,78.15 124.2,78.15 124.29,78.07 124.29,77.9 124.2,77.81 123.78,77.81 123.69,77.72 123.69,77.55 123.78,77.46 124.16,77.46 124.25,77.37 124.25,77.03 123.8,76.59 123.8,74.43 122.91,73.53 122.91,66.65 123.33,66.23 123.33,64.05 123.81,63.57 124.01,63.57 124.09,63.49 124.09,63.29 124.18,63.21 124.3,63.21 124.38,63.29 124.38,63.51 124.47,63.6 124.59,63.6 124.69,63.5 124.69,63.06 v6(124.7,63.05) 124.79,63.05 125.08,63.34 126.99,63.34 127.15,63.17 127.78,63.17 v7(127.9,63.05) 128,63.15 128.4,63.15 128.49,63.23 128.49,63.34 128.57,63.43 128.74,63.43 128.83,63.34 128.83,63.23 128.92,63.15 129.09,63.15 129.18,63.23 129.18,63.37 129.26,63.45 129.44,63.45 129.52,63.37 129.52,63.23 129.61,63.15 135,63.15 v6(135.1,63.05) 135.56,63.51 135.88,63.51 135.96,63.42 135.96,63.26 136.05,63.17 136.22,63.17 136.31,63.26 136.31,63.42 136.39,63.51 137.17,63.51 137.59,63.08 138.27,63.08 v7(138.3,63.05) 138.4,63.15 141.26,63.15 141.67,63.56 142.36,63.56 v7(142.84,64.04)
DDR_A_ALERT#: length 71.6
  TOP w0.081: v8(119.76,83.47) 119.85,83.38 122.55,83.38 123.16,82.77 v10(124.05,82.77) 124.08,82.79 124.08,86.96 123.65,87.39 UC1.AU5
  TOP w0.122: UD4.P9 129.26,60.65 128.87,60.25 124.97,60.25 124.94,60.23 v8(124.38,60.23) ; RD193.2 140.96,59.59 UD3.P9 139.66,60.65 139.27,60.25 135.37,60.25 135.34,60.23 v8(134.78,60.23)
  IN1 w0.086: v4(137.68,60.25) 137.63,60.2 134.81,60.2 v8(134.78,60.23) 134.66,60.35 133.03,60.35 132.84,60.16 130.64,60.16 130.45,59.97 127.61,59.97 127.33,60.25 v4(127.28,60.25) 127.21,60.18 124.43,60.18 v8(124.38,60.23) 123.86,60.23 123.37,60.72 122.23,60.72 119.94,63.01 119.94,67.86 119.86,67.95 119.53,67.95 119.44,68.04 119.44,83.15 v8(119.76,83.47)
  BOTTOM w0.122: v4(137.68,60.25) 133.9,60.25 UD1.P9 ; UD2.P9 123.5,60.25 v4(127.28,60.25)
DDR_A_BA0: length 60.3
  TOP w0.081: v8(120.8,83.7) 120.77,83.72 119.31,83.72 118.75,84.29 117.56,84.29 117.31,84.54 117.31,85.54 117.09,85.75 116.65,85.75 116.42,85.98 116.42,86.32 116.25,86.49 116.25,86.85 115.97,87.14 UC1.AH5
  TOP w0.122: UD4.N2 v8(124.28,61.65) ; UD3.N2 v8(134.68,61.65)
  IN1 w0.086: v8(141.95,61.31) 141.41,60.77 139.01,60.77 v4(138.74,61.04) 138.31,61.47 136.15,61.47 135.92,61.71 134.74,61.71 v8(134.68,61.65) 134.48,61.45 134.31,61.45 134.22,61.54 134.22,61.6 134.14,61.69 133.96,61.69 133.88,61.6 133.88,61.54 133.79,61.45 133.62,61.45 133.53,61.54 133.53,61.6 133.44,61.69 133.27,61.69 133.19,61.6 133.19,61.54 133.1,61.45 132.77,61.45 132.33,61.01 128.37,61.01 v4(128.34,61.04) 128.24,61.04 127.91,61.37 125.98,61.37 125.61,61.74 124.38,61.74 v8(124.28,61.65) 123.04,61.65 122.41,62.28 122.28,62.28 122.19,62.19 122.07,62.19 121.94,62.31 121.94,62.43 122.04,62.53 122.04,62.65 121.92,62.77 121.8,62.77 121.7,62.68 121.58,62.68 121.46,62.8 121.46,62.92 121.55,63.02 121.55,63.14 121.43,63.26 121.31,63.26 121.21,63.16 121.09,63.16 120.97,63.29 120.97,63.41 121.06,63.51 121.06,63.63 120.83,63.86 120.83,73.1 120.49,73.43 120.45,73.43 120.33,73.55 120.33,73.72 120.42,73.8 120.51,73.8 120.6,73.89 120.6,74.06 120.51,74.15 120.42,74.15 120.33,74.24 120.33,74.41 120.42,74.49 120.51,74.49 120.6,74.58 120.6,74.75 120.51,74.84 120.42,74.84 120.33,74.93 120.33,75.1 120.42,75.19 120.51,75.19 120.6,75.27 120.6,75.44 120.51,75.53 120.42,75.53 120.33,75.62 120.33,75.82 120.42,75.9 120.51,75.9 120.6,75.99 120.6,76.16 120.51,76.25 120.42,76.25 120.33,76.34 120.33,76.51 120.42,76.59 120.51,76.59 120.6,76.68 120.6,76.85 120.51,76.94 120.42,76.94 120.33,77.03 120.33,77.2 120.42,77.29 120.51,77.29 120.6,77.37 120.6,77.54 120.51,77.63 120.42,77.63 120.33,77.72 120.33,77.89 120.42,77.98 120.51,77.98 120.6,78.06 120.6,78.24 120.51,78.32 120.42,78.32 120.33,78.41 120.33,78.58 120.42,78.67 120.51,78.67 120.6,78.75 120.6,78.93 120.51,79.01 120.42,79.01 120.33,79.1 120.33,79.27 120.42,79.36 120.51,79.36 120.6,79.44 120.6,79.62 120.51,79.7 120.42,79.7 120.33,79.79 120.33,79.96 120.42,80.05 120.51,80.05 120.6,80.14 120.6,80.31 120.51,80.39 120.42,80.39 120.33,80.48 120.33,80.65 120.42,80.74 120.51,80.74 120.6,80.83 120.6,81 120.52,81.08 120.42,81.08 120.33,81.17 120.33,81.34 120.42,81.43 120.79,81.43 120.88,81.52 120.88,81.69 120.79,81.78 120.42,81.78 120.33,81.86 120.33,82.44 120.38,82.49 120.38,83.99 120.47,84.08 120.62,84.08 120.71,83.99 120.71,83.78 120.79,83.7 v8(120.8,83.7)
  BOTTOM w0.122: v4(128.34,61.04) 128.35,61.15 UD2.N2 ; UD1.N2 138.75,61.15 v4(138.74,61.04)
DDR_A_BA1: length 62.8
  TOP w0.081: v8(120.84,82.45) 120.77,82.38 v2(119.68,82.38) 119.68,82.38 119.65,82.41 119.58,82.41 118.37,83.62 116.56,83.62 115.97,84.21 UC1.AH1
  TOP w0.122: v8(136.28,61.88) 138.72,61.88 139.1,61.5 UD3.N8 139.53,61.88 RD184.1 ; UD4.N8 128.7,61.5 128.32,61.88 v8(125.88,61.88)
  IN1 w0.086: v4(137.68,61.85) 137.65,61.88 v8(136.28,61.88) 136.22,61.94 132.98,61.94 132.32,61.28 130.78,61.28 130.7,61.36 130.7,61.43 130.61,61.52 130.44,61.52 130.35,61.43 130.35,61.36 130.27,61.28 130.09,61.28 130.01,61.36 130.01,61.46 129.92,61.55 129.75,61.55 129.66,61.46 129.66,61.36 129.57,61.28 129.28,61.28 129.2,61.36 129.2,61.46 129.11,61.55 128.94,61.55 128.85,61.46 128.85,61.36 128.76,61.28 128.59,61.28 128.37,61.5 128.09,61.5 127.74,61.85 v4(127.28,61.85) 125.91,61.85 v8(125.88,61.88) 125.83,61.93 123.75,61.93 123.52,62.16 123.01,62.16 122.4,62.77 122.4,63.38 122.19,63.59 122.07,63.59 121.88,63.41 121.76,63.41 121.64,63.53 121.64,63.65 121.94,63.95 121.94,64.07 121.81,64.19 121.69,64.19 121.39,63.9 121.27,63.9 121.12,64.05 121.12,73.22 120.89,73.44 120.89,81.08 121.19,81.37 121.19,82.6 121.08,82.7 121.08,82.77 121,82.86 120.76,82.86 120.67,82.77 120.67,82.54 120.76,82.45 v8(120.84,82.45)
  BOTTOM w0.122: UD2.N8 124.3,61.85 v4(127.28,61.85) ; UD1.N8 134.7,61.85 v4(137.68,61.85)
DDR_A_BG0: length 54.8
  TOP w0.081: UC1.AU1 123.51,84.62 123.25,84.36 v6(122.43,84.36)
  IN4 w0.086: v6(122.43,84.36) 122.43,84.69 122.53,84.79 122.9,84.79 123.06,84.63 123.06,84.23 122.96,84.13 122.78,84.13 122.66,84 122.66,83.83 122.74,83.75 123.31,83.75 123.39,83.83 123.39,84.8 123.54,84.95 123.66,84.95 123.8,84.8 123.8,79.85 123.72,79.76 123.45,79.76 123.37,79.85 123.37,80.88 123.24,81 122.79,81 122.53,80.75 122.53,74.92 122.33,74.72 122.33,66.38 122.73,65.98 122.73,63.42 v6(123.9,62.25) 124.86,62.25 125.12,62.51 125.7,62.51 125.88,62.33 128.62,62.33 v7(128.7,62.25) 128.76,62.31 129.18,62.31 129.26,62.22 129.26,61.96 129.35,61.87 129.52,61.87 129.61,61.96 129.61,62.4 129.7,62.49 129.87,62.49 129.96,62.4 129.96,61.96 130.04,61.87 130.21,61.87 130.3,61.96 130.3,62.2 130.39,62.28 130.56,62.28 130.65,62.2 130.65,61.96 130.73,61.87 130.91,61.87 130.99,61.96 130.99,62.16 131.08,62.25 131.72,62.25 131.98,62.51 132.59,62.51 132.85,62.25 v6(134.3,62.25) 135.26,62.25 135.52,62.51 136.8,62.51 136.98,62.33 137.95,62.33 138.15,62.54 138.39,62.54 138.67,62.25 v7(139.1,62.25) 139.52,62.67 142.61,62.67 v7(142.84,62.89)
DDR_A_BG1: length 51.1
  TOP w0.081: v8(122.05,83.78) 123.47,83.78 123.83,84.14 123.83,85.24 123.63,85.44 UC1.AU2
  TOP w0.122: v1(121.41,64.42) 121.26,64.42 121.01,64.16 120.58,64.16 120.46,64.28 120.46,66.75 120.58,66.87 RD244.2 121.69,66.87 122.68,65.88 131.23,65.88 RD242.2 132.83,65.6 133.07,65.84 135.79,65.84 136.17,65.46 137.69,65.46 138.1,65.86 140.49,65.86 141.07,66.45 RD238.2
  IN1 w0.086: v1(121.41,64.42) 121.41,64.42 121.41,73.34 121.18,73.56 121.18,80.96 121.48,81.25 121.48,83.36 121.91,83.78 v8(122.05,83.78)
  GND2 w0.122: v3(121.45,63.46) 121.45,64.12 121.41,64.16 v1(121.41,64.42)
  GND4 w0.122: v4(121.03,63.19) 121.17,63.19 v3(121.45,63.46)
DDR_A_CKE0: length 56.8
  TOP w0.081: UC1.AT1 123.02,85.03 123.02,85.07 123.07,85.12 v6(123.13,85.12)
  IN4 w0.086: v6(123.13,85.12) 123.13,86.71 122.91,86.92 122.91,88.18 123.81,89.08 124.94,89.08 125.67,88.36 125.67,84.55 124.9,83.78 124.9,76.67 124.46,76.23 124.46,74.35 123.13,73.01 123.13,68.21 123.21,68.12 124.21,68.12 124.29,68.04 124.29,67.63 124.21,67.54 123.47,67.54 123.38,67.45 123.38,66.65 123.62,66.41 123.62,64.13 v6(123.9,63.85) 124.41,63.85 124.5,63.94 124.5,64.2 124.59,64.29 124.76,64.29 124.84,64.2 124.84,63.94 124.93,63.85 125.1,63.85 125.19,63.94 125.19,64.03 125.28,64.11 125.45,64.11 125.54,64.03 125.54,63.94 125.62,63.85 v7(128.7,63.85) 128.99,64.14 130.53,64.14 130.64,64.02 130.64,63.82 130.73,63.73 130.9,63.73 130.99,63.82 130.99,64 131.08,64.09 131.25,64.09 131.33,64 131.33,63.82 131.42,63.73 131.59,63.73 131.68,63.82 131.68,63.95 131.77,64.04 132.92,64.04 133.12,64.24 133.86,64.24 134.25,63.85 v6(134.3,63.85) 134.43,63.98 136.82,63.98 136.9,64.06 136.9,64.14 136.99,64.23 137.16,64.23 137.25,64.14 137.25,64.06 137.46,63.85 v7(139.1,63.85) 142.08,63.85 v7(142.84,64.61)
DDR_A_CLK0: length 72.9
  TOP w0.081: UC1.AG1 115.24,84.79 115.24,85.06 115.13,85.17 114.95,85.17 114.82,85.05 114.82,84.31 116.85,82.29 118.7,82.29 119.44,81.55 120.07,81.55 120.11,81.6 120.78,81.6 120.82,81.55 123.18,81.55 123.27,81.64 123.27,81.78 123.18,81.87 v8(122.81,81.87)
  TOP w0.125: v8(124.4,64.4) 124.56,64.24 124.79,64.24 125.04,63.99 127.76,63.99 UD4.K7 ; v8(134.8,64.4) 134.96,64.24 135.19,64.24 135.42,64.01 138.14,64.01 UD3.K7
  IN1 w0.086: v8(141.95,65.88) 141.73,65.66 140.84,65.66 140.34,65.16 140.34,65.16 139.87,64.69 139.01,64.69 138.46,64.15 138.34,64.15 138.24,64.25 v4(138.24,64.26) 138.14,64.26 137.75,64.65 135.1,64.65 134.86,64.4 v8(134.8,64.4) 134.8,64.37 134.69,64.26 134.44,64.26 134.35,64.35 134.35,64.52 134.26,64.61 134.09,64.61 134.01,64.52 134.01,64.38 133.94,64.32 133.92,64.3 133.75,64.3 133.66,64.38 133.66,64.52 133.57,64.61 133.4,64.61 133.32,64.52 133.32,64.38 133.23,64.3 132.1,64.3 131.68,64.3 131.65,64.26 128.65,64.26 128.55,64.16 128.46,64.16 128.4,64.22 128.4,64.33 128.3,64.43 128.19,64.43 128.1,64.34 128.1,64.24 128.02,64.16 127.93,64.16 127.84,64.25 v4(127.84,64.26) 127.74,64.26 127.32,64.68 127.32,65.2 127.13,65.39 126.64,65.39 126.46,65.22 126.46,64.71 126.35,64.59 125.14,64.59 125.09,64.54 125.03,64.54 124.78,64.29 124.51,64.29 v8(124.4,64.4) 124.29,64.4 123.9,64.8 123.33,64.8 123.19,64.94 123.19,67.65 123.39,67.85 123.39,71.93 125,73.54 125,75.69 125.48,76.17 125.48,76.24 125.48,76.3 125.48,82.44 125.3,82.62 124.7,82.62 124.56,82.48 124.56,80.79 124.47,80.7 123.6,80.7 123.51,80.78 123.51,81.37 123.31,81.56 122.91,81.56 122.81,81.66 v8(122.81,81.87)
  BOTTOM w0.125: v4(127.84,64.26) 127.84,64.24 127.64,64.05 124.9,64.05 UD2.K7 ; UD1.K7 135.24,63.99 137.93,63.99 138.21,64.26 v4(138.24,64.26)
DDR_A_CLK#0: length 73.6
  TOP w0.081: UC1.AG2 115.14,85.34 114.88,85.34 114.66,85.12 114.66,84.24 116.78,82.12 118.63,82.12 119.37,81.38 v13(120.48,81.38) 122.72,81.38 122.81,81.29 v8(122.81,81.28)
  TOP w0.125: v8(125.15,64.29) 125.2,64.24 128.02,64.24 128.41,63.85 UD4.K8 ; v8(135.55,64.29) 135.57,64.26 138.38,64.26 138.79,63.85 UD3.K8
  IN1 w0.086: v8(141.95,65.31) 141.77,65.48 141.74,65.48 141.71,65.51 140.9,65.51 140.42,65.03 140.42,65.03 139.94,64.54 139.07,64.54 138.52,63.99 138.09,63.99 137.76,64.33 v4(137.7,64.33) 137.59,64.44 137.3,64.44 137.21,64.36 137.21,64.15 137.13,64.06 136.95,64.06 136.87,64.15 136.87,64.39 136.76,64.49 136.66,64.49 136.55,64.39 136.55,64.15 136.46,64.06 136.29,64.06 136.2,64.15 136.2,64.38 136.12,64.47 135.72,64.47 v8(135.55,64.29) 135.39,64.45 135.21,64.45 134.87,64.11 134.37,64.11 134.34,64.15 132.04,64.15 131.74,64.15 131.71,64.11 128.71,64.11 128.61,64.01 127.73,64.01 127.41,64.33 v4(127.3,64.33) 127.3,64.48 127.17,64.62 127.17,65.14 127.06,65.24 126.7,65.24 126.61,65.16 126.61,64.25 126.53,64.16 126.36,64.16 126.27,64.25 126.27,64.36 126.18,64.44 126.01,64.44 125.92,64.36 125.92,64.12 125.84,64.04 125.66,64.04 125.58,64.12 125.58,64.36 125.49,64.44 125.3,64.44 v8(125.15,64.29) 124.99,64.14 124.84,64.14 124.84,64.14 124.65,64.14 124.65,64.14 124.28,64.14 124.13,64.29 124.13,64.31 124.11,64.33 124.01,64.47 123.99,64.47 123.81,64.65 123.26,64.65 123.04,64.87 123.04,67.71 123.24,67.91 123.24,71.99 124.85,73.6 124.85,75.75 125.33,76.23 125.33,82.38 125.24,82.46 124.76,82.46 124.71,82.42 124.71,80.72 124.54,80.55 123.53,80.55 123.36,80.72 123.36,81.3 123.25,81.41 122.94,81.41 v8(122.81,81.28)
  BOTTOM w0.125: v4(127.3,64.33) 127.27,64.29 124.57,64.29 UD2.K8 ; v4(137.7,64.33) 137.59,64.21 134.85,64.21 UD1.K8
