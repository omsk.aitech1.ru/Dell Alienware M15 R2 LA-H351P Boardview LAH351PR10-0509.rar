# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FB_B_CMD13: length 16.5
  TOP w0.089: 21.13,111.26 21.79,110.59 23.59,110.59 23.79,110.79 24.16,110.79 24.52,111.15 UG1.C41
  TOP w0.099: UG13.L12 10.73,114.98 17.21,114.98 20.56,111.63 v2(20.6,111.63) 20.65,111.58 20.66,111.58 20.98,111.26 21.13,111.26
FB_B_CMD14: length 18.4
  TOP w0.081: UG13.J11 9.19,114.9 ; UG13.K11 9.51,114.58 9.19,114.9
  TOP w0.089: UG1.B41 23.95,111.15 23.82,111.15 23.52,110.85 21.97,110.85 21.14,111.68 21.13,111.68
  TOP w0.099: 21.13,111.68 21.02,111.68 21,111.7 19.42,113.28 v2(19.38,113.28) 17.38,115.28 16.73,115.28 16.32,115.69 10.18,115.69 10.01,115.52 10.01,115.14 9.84,114.97 9.27,114.97 9.19,114.9 9.19,114.9
FB_B_CMD15: length 17.9
  TOP w0.081: 9.3,115.68 9.22,115.68 UG13.J12 ; 9.3,115.68 9.3,115.66 UG13.K12 ; 9.3,115.68 9.27,115.71
  TOP w0.089: UG1.A41 22.09,111.15 21.13,112.11
  TOP w0.099: 9.27,115.71 9.27,116.24 9.46,116.42 9.47,116.42 9.48,116.43 16.12,116.43 16.56,115.99 17.13,115.99 v2(17.45,115.67) 17.45,115.67 21.02,112.11 21.13,112.11
FB_B_CMD16: length 32.2
  TOP w0.089: UG1.B49 23.62,117.08 23.62,117.69 23.5,117.82 23.09,117.82 22.73,118.18 22.73,118.95
  TOP w0.099: 22.73,118.95 22.73,120.09 21.26,121.56 v2(21.26,131.32) 21.26,131.39 17.98,134.67 9.04,134.67 8.51,134.14 8.51,132.8 UG14.L3
FB_B_CMD17: length 30.8
  TOP w0.081: UG14.J3 9.26,132.78 ; UG14.K3 9.1,132.64 9.1,132.64 9.24,132.78
  TOP w0.089: UG1.A49 23.25,116.76 22.94,117.08 22.94,117.62 22.43,118.12 22.43,118.65
  TOP w0.099: 9.26,132.78 9.26,134.07 9.51,134.32 v2(17.81,134.32) 20.96,131.17 20.96,121.4 22.43,119.94 22.43,118.65 ; 9.26,132.78 9.26,132.78 ; 9.26,132.78 9.24,132.78
FB_B_CMD18: length 28
  TOP w0.089: UG1.A48 22.73,116.57 22.73,117.49 22.1,118.12 22.1,118.31
  TOP w0.099: UG14.J1 10.01,133.53 16.49,133.53 RG1486.2 v2(18.95,132.27) 20.66,130.56 20.66,121.28 22.1,119.84 22.1,118.31
FB_B_CMD19: length 32
  TOP w0.081: UG14.J4 9.31,131.66 9.25,131.73 9.25,131.96 9.17,131.96 UG14.K4
  TOP w0.089: UG1.D47 25.01,115.69 23.18,115.69 22.5,116.37 22.5,117.29 21.8,118 21.8,118.01
  TOP w0.099: 21.8,118.01 21.8,119.72 20.32,121.19 v2(20.32,126.13) 20.32,130.41 18.94,131.79 17.36,131.79 16.36,132.79 10.14,132.79 10.01,132.66 10.01,132.22 9.82,132.02 9.31,132.02 9.25,131.96
FB_B_CMD20: length 26.7
  TOP w0.089: UG1.A47 23.25,115.36 22.29,116.32 22.29,116.94 21.51,117.72
  TOP w0.099: UG14.H3 10.74,132.05 16.53,132.05 17.17,131.41 18.78,131.41 v2(19.62,130.57) 19.99,130.2 19.99,121.1 21.49,119.59 21.49,117.74 21.51,117.72
FB_B_CMD21: length 26.5
  TOP w0.089: 21.29,117.51 22.05,116.76 22.05,116.13 23.18,115 23.54,115 23.9,115.35 UG1.B47
  TOP w0.099: UG14.G4 11.52,131.27 16.61,131.27 16.91,130.96 v2(17.77,130.96) 18.59,130.96 19.69,129.87 19.69,120.97 21.19,119.47 21.19,117.61 21.29,117.51
FB_B_CMD22: length 30.2
  TOP w0.081: UG14.J5 9.26,131.28 ; UG14.K5 9.24,131.28
  TOP w0.089: UG1.C47 24.3,115 23.87,115 23.66,114.79 23.11,114.79 21.82,116.09 21.82,116.56 21.13,117.24
  TOP w0.099: 9.24,131.28 10.61,131.28 10.77,131.11 10.77,130.67 10.89,130.55 18.42,130.55 19.15,129.83 v2(19.15,127.54) 19.39,127.3 19.39,120.84 20.89,119.34 20.89,117.49 21.13,117.24
FB_B_CMD23: length 31.3
  TOP w0.081: UG14.H5 9.82,130.36 8.68,130.36 UG14.L5
  TOP w0.089: UG1.C45 24.65,114.08 24.42,114.31 23.79,114.31 23.51,114.59 23.05,114.59 21.58,116.06 21.58,116.37 21.13,116.82
  TOP w0.099: 9.24,130.36 9.24,130.19 9.35,130.08 18.23,130.08 18.66,129.65 18.66,127.54 19.08,127.12 19.08,120.68 v2(19.49,120.27) 20.59,119.18 20.59,117.36 21.13,116.82
FB_B_CMD24: length 30.5
  TOP w0.089: 21.13,116.39 21.31,116.21 21.31,116.06 23.07,114.3 23.44,114.3 23.78,113.95 UG1.B45
  TOP w0.099: UG14.M4 7.73,131.31 7.73,130.5 8.46,129.76 18.09,129.76 18.31,129.55 v2(18.31,129.16) 18.31,127.47 18.78,126.99 18.78,120.5 20.28,118.99 20.28,117.23 21.13,116.39
FB_B_CMD25: length 28.7
  TOP w0.089: 21.13,115.96 21.13,115.88 23.06,113.95 UG1.A45
  TOP w0.099: UG14.M11 7,126.79 7,127.39 8.07,128.46 16.86,128.46 18.48,126.84 18.48,120.37 19.43,119.42 v2(19.43,118.18) 19.43,117.66 21.13,115.96
FB_B_CMD26: length 33.6
  TOP w0.081: UG14.M10 7.77,126.77 9.2,126.77 v8(9.25,126.82) 9.29,126.77 10.73,126.77 UG14.G10
  TOP w0.089: 21.13,115.53 23.07,113.59 25.01,113.59 UG1.D44
  TOP w0.099: 21.13,115.53 19.1,117.56 19.1,119.32 18.17,120.25 18.17,124.42 v2(18.11,124.48) 18.17,124.53 18.17,126.3 RG1484.2 16.33,128.14 8.73,128.14 8.6,128.01 v8(8.32,128.01)
  IN1 w0.071: v8(9.25,126.82) 9.25,127.22 8.65,127.82 8.51,127.82 v8(8.32,128.01)
FB_B_CMD27: length 27.5
  TOP w0.081: UG14.H10 10.37,127.45 10.24,127.58 8.21,127.58 8.13,127.5 UG14.L10
  TOP w0.089: 21.13,115.11 22.99,113.25 UG1.A44
  TOP w0.099: 9.19,127.58 9.19,127.68 9.33,127.82 15.74,127.82 17.3,126.26 17.3,125.42 17.77,124.95 v2(17.77,122.49) 17.77,120.23 18.8,119.2 18.8,117.44 21.13,115.11
FB_B_CMD28: length 22.3
  TOP w0.089: UG1.B44 23.8,113.25 23.49,112.94 22.87,112.94 21.13,114.68
  TOP w0.099: 21.13,114.68 18.5,117.31 18.5,119.07 17.35,120.22 v2(17.35,120.65) 17.35,124.86 16.18,126.02 11.52,126.02 UG14.G11
FB_B_CMD29: length 21.7
  TOP w0.089: UG1.C44 24.3,112.9 23.86,112.9 23.66,112.7 22.68,112.7 21.13,114.25
  TOP w0.099: UG14.H12 10.76,125.28 10.76,123.97 11,123.74 13.4,123.74 18.17,118.97 v2(18.17,117.3) 18.17,117.21 21.13,114.25
FB_B_CMD30: length 23.9
  TOP w0.081: UG14.J12 9.44,125.48 9.25,125.48 9.25,125.6 9.19,125.67 UG14.K12
  TOP w0.089: UG1.C42 24.65,111.92 24.38,112.2 23.74,112.2 23.49,112.45 22.5,112.45 21.13,113.82
  TOP w0.099: 9.25,125.48 9.25,125.41 9.35,125.31 9.84,125.31 10.01,125.14 10.01,123.83 10.54,123.31 12.45,123.31 14.06,121.69 v2(14.95,121.69) 14.97,121.69 17.84,118.83 17.84,117.12 21.13,113.82
FB_B_CMD31: length 28
  TOP w0.081: UG14.J11 9.32,126.11 9.18,126.11 UG14.K11
  TOP w0.089: 21.13,113.39 21.21,113.39 22.39,112.2 23.37,112.2 23.73,111.85 UG1.B42
  TOP w0.099: 21.13,113.39 17.52,117 17.52,118.71 15.23,121.01 v2(12,121.01) 8.01,121.01 7.79,121.23 7.79,125.04 8,125.25 8.27,125.25 8.48,125.45 8.48,125.93 8.57,126.02 9.08,126.02 9.18,126.11
FB_B_CMD32: length 26.6
  TOP w0.089: UG1.D41 25.21,111.15 24.88,111.48 22.19,111.48 21.13,112.54
  TOP w0.099: UG13.H12 8.51,115.72 8.51,119.98 8.89,120.36 12.64,120.36 13.37,119.62 v2(15.28,119.62) 15.72,119.62 16.84,118.5 16.84,116.75 21.05,112.54 21.13,112.54
FB_B_CMD33: length 26.2
  TOP w0.089: UG1.A42 22.25,111.85 21.13,112.97
  TOP w0.099: UG14.L12 7.85,125.67 7.49,125.31 7.24,125.31 6.99,125.06 6.99,123.66 7.34,123.3 7.34,121.17 7.85,120.66 13.54,120.66 v2(13.69,120.51) 13.73,120.46 15.33,120.46 17.16,118.63 17.16,116.86 21.05,112.97 21.13,112.97
FB_B_D0: length 24.7
  IN4 w0.086: v6(28.15,104.85) 26.8,106.2 25.86,106.2 24.59,107.47 16.5,107.47 15.77,106.75 9.93,106.75 7.75,108.93 6.22,108.93 v6(5.88,108.59)
FB_B_D1: length 26.6
  IN4 w0.086: v3(25.35,104.85) 24.81,104.31 21,104.31 20.83,104.49 18.32,104.49 18.08,104.49 17.72,104.12 6.63,104.12 5.28,105.47 4.12,105.47 3.24,106.35 3.24,108.95 v6(3.63,109.34)
FB_B_D2: length 22.1
  IN4 w0.086: v6(3.63,108.59) 4,108.21 4,107.66 4.19,107.47 4.5,107.47 4.75,107.22 4.75,107.04 7.09,104.7 16.16,104.7 17.16,105.7 23.09,105.7 v3(23.25,105.55)
FB_B_D3: length 22.9
  IN4 w0.086: v3(23.95,104.85) 22.74,104.85 22.18,105.42 17.32,105.42 16.32,104.41 6.84,104.41 5.36,105.89 4.74,105.89 3.94,106.7 3.94,107.34 3.63,107.65 v6(3.63,107.84)
FB_B_D4: length 21.4
  IN4 w0.086: v3(26.05,104.85) 25.59,105.31 25.27,105.31 24.01,106.57 16.67,106.57 16.09,106 7.95,106 6.99,106.96 6.99,107.48 v6(6.63,107.84)
FB_B_D5: length 23.9
  IN4 w0.086: v3(27.45,104.85) 26.41,105.89 25.76,105.89 24.47,107.18 16.55,107.18 15.86,106.49 9.49,106.49 8.51,107.47 7.94,107.47 7.75,107.66 7.75,108.04 7.56,108.23 6.27,108.23 v6(5.88,107.84)
FB_B_D6: length 30.6
  TOP w0.122: UG1.J30 v3(28.85,103.96)
  IN4 w0.086: v6(2.88,108.59) 2.48,108.19 2.48,106.39 3.77,105.09 5.2,105.09 6.46,103.83 17.84,103.83 18.2,104.2 20.71,104.2 20.88,104.02 28.79,104.02 v3(28.85,103.96)
FB_B_D7: length 21.6
  IN4 w0.086: v6(7.38,107.84) 7.38,107.6 7.63,107.34 7.63,106.82 8.2,106.25 16.01,106.25 16.65,106.89 24.35,106.89 25.64,105.6 26,105.6 v3(26.75,104.85)
FB_B_D8: length 27
  IN1 w0.086: v8(28.15,107.65) 27.81,107.99 27.81,109.25 27.65,109.41 22.35,109.41 18.45,113.31 17.14,113.31 16.99,113.16 12.22,113.16 10.07,115.3 7.88,115.3 7.45,115.73 7.29,115.73 7.06,115.96 7.06,116.13 6.75,116.43 6.22,116.43 v8(5.88,116.08)
FB_B_D9: length 24.9
  IN1 w0.086: v8(27.45,107.65) 27.02,108.08 26.64,108.08 26.43,108.28 26.43,108.76 26.32,108.87 20.9,108.87 16.91,112.86 11.63,112.86 9.52,114.97 7.28,114.97 6.94,115.32 6.94,115.57 6.63,115.88 v8(6.63,116.08)
FB_B_D10: length 25.8
  IN1 w0.086: v8(7.38,116.08) 7.65,116.08 8.06,115.67 10.15,115.67 12.34,113.48 16.8,113.48 16.95,113.63 18.7,113.63 22.23,110.11 27.64,110.11 28.51,109.24 28.51,108.51 28.85,108.17 v8(28.85,107.65)
FB_B_D11: length 24.1
  IN1 w0.086: v8(5.88,115.33) 6.11,115.33 6.44,115 6.76,115 7.23,114.53 7.66,114.53 9.62,112.57 16.79,112.57 21.32,108.04 26.23,108.04 26.62,107.65 v8(26.75,107.65)
FB_B_D12: length 28.1
  IN1 w0.086: v8(3.63,115.33) 3.99,114.97 4.45,114.97 4.74,114.68 4.74,113.8 5.99,112.55 7.56,112.55 8.98,111.12 17,111.12 21.26,106.87 24.66,106.87 24.97,106.57 25.44,106.57 25.7,106.3 25.7,105.59 25.79,105.5 26.44,105.5 26.47,105.54 26.74,105.54 v8(26.75,105.55)
FB_B_D13: length 25.9
  IN1 w0.086: v1(25.35,105.55) 25.35,105.73 24.52,106.55 21.17,106.55 16.91,110.81 8.86,110.81 7.85,111.81 5.8,111.81 4.04,113.58 4.04,114.17 v8(3.63,114.58)
FB_B_D14: length 32.2
  IN1 w0.086: v8(28.85,104.85) 28.68,104.85 28.32,104.49 25.27,104.49 25.02,104.74 25.02,104.93 24.77,105.18 21.71,105.18 17.21,109.69 12.26,109.69 12.1,109.85 8.67,109.85 7.84,110.68 5.49,110.68 2.52,113.65 2.52,114.98 v8(2.88,115.33)
FB_B_D15: length 30.5
  IN1 w0.086: v8(3.63,116.08) 3.22,115.67 3.22,113.71 5.46,111.47 7.72,111.47 8.7,110.49 16.82,110.49 21.39,105.92 24.67,105.92 24.92,105.66 24.92,105.47 25.15,105.25 27.15,105.25 v8(27.45,105.55)
FB_B_D16: length 16.8
  IN1 w0.086: v8(15.62,115.33) 19.66,115.33 23.46,111.53 26.18,111.53 26.37,111.73 26.37,111.98 26.66,112.27 26.98,112.27 27.8,113.09 27.8,113.33 27.53,113.6 26.4,113.6 v8(26.05,113.95)
FB_B_D17: length 17.4
  IN1 w0.086: v8(14.87,116.08) 14.58,116.08 14.23,115.73 13.22,115.73 13,115.96 13,116.88 13.92,117.81 19.89,117.81 23.75,113.95 v8(25.35,113.95)
FB_B_D18: length 19.6
  IN1 w0.086: v8(26.75,113.95) 26.56,113.95 26.23,114.28 23.86,114.28 19.45,118.69 12.94,118.69 12.26,118.01 12.26,115.7 v8(12.62,115.33)
FB_B_D19: length 20.4
  IN1 w0.086: v8(27.45,113.95) 27.06,114.34 26.67,114.34 26.39,114.62 25.78,114.62 25.4,115 24.05,115 20.04,119.01 12.81,119.01 11.53,117.73 11.53,116.49 v8(11.12,116.08)
FB_B_D20: length 12.3
  IN1 w0.086: v8(25.35,111.85) 23.56,111.85 19.66,115.75 15.62,115.75 15.2,115.33 v8(14.87,115.33)
FB_B_D21: length 14.9
  IN1 w0.086: v8(14.87,114.58) 14.52,114.94 14.52,115.46 14.75,115.69 14.92,115.69 15.33,116.09 15.33,116.25 15.5,116.42 19.43,116.42 23.65,112.2 25.7,112.2 v8(26.05,111.85)
FB_B_D22: length 20.4
  IN1 w0.086: v8(26.75,111.85) 26.94,111.66 27.6,111.66 27.81,111.45 27.81,110.99 27.6,110.77 23.81,110.77 19.59,115 15.63,115 15.27,114.64 15.27,114.49 14.98,114.2 13.91,114.2 13.75,114.35 13.75,114.73 13.49,115 13.28,115 12.96,115.33 12.96,115.48 12.62,115.81 v8(12.62,116.08)
FB_B_D23: length 25.9
  IN1 w0.086: v8(28.15,111.15) 28.12,111.18 28.12,113.79 26.95,114.96 25.87,114.96 25.45,115.38 24.12,115.38 20.17,119.33 12.62,119.33 10.71,117.42 10.71,116.06 11.04,115.73 11.38,115.73 11.73,116.08 v8(11.87,116.08)
FB_B_D24: length 18.7
  IN4 w0.086: v3(26.05,111.15) 24.97,112.23 13.2,112.23 11.19,110.21 11.19,108.93 11.38,108.74 11.38,108.1 v6(11.12,107.84)
FB_B_D25: length 19.3
  IN4 w0.086: v3(26.75,109.75) 24.58,111.91 13.35,111.91 11.53,110.09 11.53,109.17 11.62,109.09 11.62,108.1 v6(11.87,107.84)
FB_B_D26: length 17
  IN4 w0.086: v6(12.62,108.59) 12.23,108.98 12.23,110.37 13.46,111.6 24.2,111.6 v3(26.05,109.75)
FB_B_D27: length 16
  IN4 w0.086: v6(12.62,107.84) 13.08,108.29 13.08,110.28 14.08,111.28 23.82,111.28 v3(25.35,109.75)
FB_B_D28: length 13.4
  TOP w0.089: UG1.F38 26.8,109.05 v3(27.17,108.67)
  IN4 w0.086: v6(14.87,109.34) 15.17,109.63 24.07,109.63 24.83,108.87 26.98,108.87 v3(27.17,108.67)
FB_B_D29: length 12.1
  TOP w0.089: v3(26.04,108.49) 26.05,108.5 UG1.E38
  IN4 w0.086: v6(14.87,108.59) 15.28,108.99 24.3,108.99 24.81,108.49 v3(26.04,108.49)
FB_B_D30: length 10.8
  IN4 w0.086: v3(25.35,107.65) 24.82,107.65 24.3,108.17 15.21,108.17 v6(14.87,107.84)
FB_B_D31: length 10.8
  IN4 w0.086: v3(26.05,107.65) 25.53,108.17 24.71,108.17 24.3,108.59 v6(15.62,108.59)
FB_B_D32: length 23.6
  IN4 w0.086: v3(30.95,117.45) 30.24,118.16 30.24,119.74 27.24,122.73 27.24,123.47 27.05,123.66 26.31,123.66 18.18,131.79 15.94,131.79 15.81,131.92 15.36,131.92 v6(14.87,132.41)
FB_B_D33: length 32.8
  IN4 w0.086: v6(12.62,132.41) 13,132.79 13,134.01 13.58,134.58 17.64,134.58 25.89,126.33 27.01,126.33 33.38,119.96 33.38,117.08 v3(32.35,116.05)
FB_B_D34: length 22.6
  IN4 w0.086: v6(15.62,132.41) 15.93,132.11 18.32,132.11 26.35,124.07 27.31,124.07 30.95,120.43 v3(30.95,118.15)
FB_B_D35: length 23.3
  IN4 w0.086: v3(30.95,116.75) 29.84,117.86 29.84,119.58 18.01,131.41 15.13,131.41 v6(14.87,131.66)
FB_B_D36: length 34.2
  IN4 w0.086: v6(12.62,133.16) 12.26,133.53 12.26,134.14 12.89,134.77 17.89,134.77 26.04,126.63 27.12,126.63 33.67,120.08 33.67,116.67 v3(32.35,115.35)
FB_B_D37: length 23.8
  IN4 w0.086: v6(14.87,133.16) 15.23,132.81 18.07,132.81 26.51,124.36 27.43,124.36 32.35,119.44 v3(32.35,118.85)
FB_B_D38: length 37.6
  IN4 w0.086: v6(11.12,133.16) 10.87,133.42 10.87,134.02 11.02,134.17 11.26,134.17 12.37,135.28 18.32,135.28 25.57,128.03 27.01,128.03 34.39,120.64 34.39,115.99 v3(33.05,114.65)
FB_B_D39: length 36.2
  IN4 w0.086: v6(11.87,133.16) 11.52,133.52 11.52,133.98 12.57,135.03 18.16,135.03 26.27,126.92 27.24,126.92 33.96,120.2 33.96,116.26 v3(32.35,114.65)
FB_B_D40: length 20.6
  IN1 w0.086: v8(14.87,125.67) 15.27,126.06 15.8,126.06 16.17,126.44 17.94,126.44 18.95,125.42 18.95,124.36 21.71,121.6 27.1,121.6 29.56,119.14 29.56,118.63 29.84,118.35 29.84,118.04 30.25,117.63 v8(30.25,117.45)
FB_B_D41: length 24.7
  IN1 w0.086: v8(30.25,118.15) 30.59,118.49 30.59,119.13 27.48,122.24 21.9,122.24 19.53,124.6 19.53,125.74 17.61,127.66 14.03,127.66 13.69,127.32 13.69,126.24 13.46,126.01 12.97,126.01 v8(12.62,125.67)
FB_B_D42: length 19.5
  IN1 w0.086: v8(14.87,126.42) 15.21,126.75 18.03,126.75 19.24,125.54 19.24,124.48 21.8,121.92 27.29,121.92 30.25,118.96 v8(30.25,118.85)
FB_B_D43: length 19.2
  IN1 w0.086: v8(30.25,116.75) 30.25,117 29.24,118.01 29.24,118.95 26.91,121.28 21.62,121.28 17.02,125.88 15.84,125.88 v8(15.62,125.67)
FB_B_D44: length 28
  IN1 w0.086: v8(11.12,124.92) 10.77,124.57 10.77,123.05 11.75,122.07 18.16,122.07 23.06,117.18 23.36,117.18 23.6,117.41 25.3,117.41 26.11,116.6 26.11,116.44 26.37,116.19 26.37,115.89 26.56,115.7 26.99,115.7 27.13,115.55 27.13,115.24 29.1,113.27 30.58,113.27 30.95,113.64 v8(30.95,114.65)
FB_B_D45: length 20.3
  IN1 w0.086: v8(14.87,124.92) 15.19,124.59 16.97,124.59 21.27,120.3 25.15,120.3 26.42,119.03 26.42,118.73 27.39,117.75 27.63,117.75 27.77,117.61 27.77,116.58 27.93,116.42 28.26,116.42 28.5,116.18 28.5,115.91 28.66,115.75 29.54,115.75 29.94,115.35 v8(30.25,115.35)
FB_B_D46: length 25.3
  IN1 w0.086: v8(30.95,116.05) 30.55,115.65 30.55,115.23 30.37,115.05 29.74,115.05 29.68,115 28.71,115 28.48,115.23 28.48,115.46 28.24,115.7 27.95,115.7 27.5,116.16 27.5,116.29 27.17,116.61 27.17,117.56 26.18,118.55 25.93,118.55 25.75,118.73 25.75,119.12 24.89,119.98 21.15,119.98 17.46,123.66 12.51,123.66 12.16,124.01 12.16,124.46 v8(12.62,124.92)
FB_B_D47: length 26.9
  IN1 w0.086: v8(30.95,115.35) 30.95,115.22 30.49,114.76 30.27,114.76 30.15,114.65 29.73,114.65 29.28,114.19 28.8,114.19 28.5,114.49 28.5,114.79 28.3,114.99 28.02,114.99 27.74,115.27 27.74,115.47 27.24,115.97 27.24,116 27.21,116.04 27.21,116.14 26.95,116.39 26.62,116.39 26.4,116.62 26.4,117.77 26.3,117.88 25.94,117.88 25.36,118.46 22.23,118.46 18.29,122.39 11.94,122.39 11.45,122.88 11.45,124.49 v8(11.87,124.92)
FB_B_D48: length 27.6
  IN4 w0.086: v6(3.63,125.67) 3.17,125.21 3.17,124.61 3.3,124.49 3.3,123.92 3.81,123.41 4.19,123.41 5.41,122.19 17.15,122.19 23.65,115.69 24.99,115.69 v3(25.35,116.05)
FB_B_D49: length 22.1
  TOP w0.089: UG1.C50 v3(24.26,117.76)
  IN4 w0.086: v3(24.26,117.76) 17.45,124.56 9.79,124.56 9.02,123.79 7.18,123.79 6.99,123.98 6.99,124.56 v6(6.63,124.92)
FB_B_D50: length 25
  IN4 w0.086: v3(24.65,116.05) 23.74,116.05 17.21,122.58 5.4,122.58 3.94,124.04 3.94,124.61 v6(3.63,124.92)
FB_B_D51: length 22.7
  TOP w0.089: UG1.C49 v3(24.32,116.99)
  IN4 w0.086: v3(24.32,116.99) 24.21,116.99 17.41,123.79 11.11,123.79 10.86,123.54 6.6,123.54 6.29,123.85 6.29,124.51 v6(5.88,124.92)
FB_B_D52: length 30.3
  TOP w0.089: UG1.E49 25.78,116.48 25.78,116.45 v3(25.75,116.42)
  IN4 w0.086: v3(25.75,116.42) 25.75,115.95 25.2,115.4 23.49,115.4 17.02,121.88 4.26,121.88 3.56,122.58 3.56,123.03 3.37,123.22 2.86,123.22 2.48,123.6 2.48,125.27 v6(2.88,125.67)
FB_B_D53: length 24
  IN4 w0.086: v6(5.88,125.67) 6.16,125.95 7.68,125.95 7.87,125.76 10.57,125.76 10.92,125.41 17.58,125.41 24.53,118.46 25.31,118.46 26.05,117.71 v3(26.05,117.45)
FB_B_D54: length 23.4
  IN4 w0.086: v3(26.75,116.75) 26.09,116.75 25.63,117.21 25.63,117.73 25.19,118.17 24.41,118.17 17.4,125.18 10.81,125.18 10.6,125.38 7.84,125.38 v6(7.38,124.92)
FB_B_D55: length 32.7
  IN4 w0.086: v6(3.63,126.42) 3.35,126.14 2.67,126.14 2.22,125.69 2.22,122.71 3.37,121.57 11.56,121.57 12,121.12 17.36,121.12 23.37,115.12 25.32,115.12 26.25,116.05 v3(26.75,116.05)
FB_B_D56: length 32.3
  IN4 w0.086: v6(3.63,133.16) 3.24,132.78 3.24,130.77 5.14,128.87 7.9,128.87 8.97,127.8 17.61,127.8 25.72,119.69 25.72,118.48 v3(26.75,117.45)
FB_B_D57: length 29.4
  IN4 w0.086: v6(2.88,132.41) 2.6,132.14 2.6,130.98 5.03,128.55 6.41,128.55 8.83,126.14 17.14,126.14 17.27,126.27 17.93,126.27 v3(25.35,118.85)
FB_B_D58: length 29.9
  IN4 w0.086: v3(28.85,117.45) 29.27,117.87 29.27,119.73 18.55,130.46 10.86,130.46 8.57,132.74 7.8,132.74 v6(7.38,133.16)
FB_B_D59: length 32.2
  IN4 w0.086: v3(28.15,116.05) 27.24,116.96 27.24,117.5 26.85,117.89 ; 26.54,118.21 26.04,118.71 26.04,119.78 17.75,128.07 9.19,128.07 7.49,129.77 5.07,129.77 4.06,130.77 4.06,131.23 v6(3.63,131.66)
  IN4 w0.089: 26.85,117.89 26.54,118.21
FB_B_D60: length 29.8
  IN4 w0.086: v6(5.88,133.16) 6.23,132.81 6.6,132.81 7.3,132.11 8.13,132.11 10.35,129.89 18.08,129.89 28.56,119.41 28.56,118.56 28.15,118.15 v3(28.15,118.15)
FB_B_D61: length 29.3
  IN4 w0.086: v3(28.85,118.15) 28.85,119.63 18.3,130.18 10.7,130.18 8.42,132.46 7.78,132.46 7.56,132.68 7.11,132.68 v6(6.63,133.16)
FB_B_D62: length 32.1
  IN4 w0.086: v6(3.63,132.41) 3.93,132.11 4.69,132.11 5.38,131.41 5.38,130.94 6.24,130.09 7.73,130.09 9.47,128.35 17.87,128.35 26.35,119.87 26.35,118.8 27.53,117.62 27.53,117.37 v3(28.15,116.75)
FB_B_D63: length 28.2
  IN4 w0.086: v6(5.88,132.41) 6.13,132.15 6.81,132.15 7.56,131.41 8.01,131.41 8.02,131.41 8.1,131.41 9.93,129.57 17.88,129.57 28.15,119.31 v3(28.15,118.85)
FB_B_DBI0: length 21.7
  IN4 w0.086: v6(5.13,107.84) 5.31,107.84 5.68,107.47 6.1,107.47 6.27,107.29 6.27,107.03 7.54,105.76 16.26,105.76 16.79,106.28 23.79,106.28 24.65,105.43 v3(24.65,104.85)
FB_B_DBI1: length 26.9
  TOP w0.089: UG1.E33 v8(26.05,105.89)
  IN1 w0.086: v8(26.05,105.89) 26.05,106.46 25.61,106.9 25.11,106.9 24.81,107.19 21.35,107.19 17.1,111.44 9.14,111.44 7.69,112.9 7.33,112.9 6.02,114.21 5.82,114.21 5.52,114.51 5.52,114.64 5.19,114.97 5,114.97 4.8,115.16 4.8,115.58 5.13,115.9 v8(5.13,116.08)
FB_B_DBI2: length 15.3
  IN1 w0.086: v8(26.05,113.25) 23.98,113.25 19.75,117.49 14.27,117.49 13.72,116.93 13.72,116.43 v8(13.37,116.08)
FB_B_DBI3: length 17.5
  IN4 w0.086: v6(13.37,107.84) 13.72,108.18 13.72,110.3 14.37,110.96 23.56,110.96 25.21,109.31 27.01,109.31 v3(27.45,109.75)
FB_B_DBI4: length 29.7
  IN4 w0.086: v6(13.37,133.16) 13.72,133.51 13.72,134.12 13.93,134.33 17.44,134.33 26.69,125.08 27.53,125.08 33.02,119.59 33.02,117.42 v3(32.35,116.75)
FB_B_DBI5: length 22.2
  IN1 w0.086: v8(30.25,116.05) 29.8,116.05 29.16,116.68 29.16,117.63 29,117.8 28.73,117.8 28.49,118.03 28.49,118.94 26.47,120.97 21.49,120.97 16.89,125.56 16,125.56 15.83,125.39 13.85,125.39 v8(13.37,124.92)
FB_B_DBI6: length 24.8
  TOP w0.089: UG1.D50 v3(24.95,117.06)
  IN4 w0.086: v6(5.13,124.92) 5.46,124.58 5.46,123.6 5.84,123.22 11.11,123.22 11.43,123.54 17.16,123.54 24.05,116.64 24.36,116.64 24.51,116.69 24.88,117.06 v3(24.95,117.06)
FB_B_DBI7: length 30.7
  IN4 w0.086: v6(5.13,133.16) 5.4,132.89 5.4,132.38 5.86,131.92 5.98,131.92 6.13,131.77 6.13,131.65 6.67,131.11 7.93,131.11 9.79,129.26 17.79,129.26 27.56,119.49 27.56,119.32 ; 27.56,118.75 27.56,118.04 v3(28.15,117.45)
  IN4 w0.089: 27.56,118.75 27.56,119.32
FB_B_DEBUG0: length 6.1
  TOP w0.081: RG1446.1 20.87,105.15 21.13,105.15
  TOP w0.089: UG1.C35 25.02,106.58 25.02,105.37 24.79,105.15 21.13,105.15
FB_B_DEBUG1: length 5.6
  TOP w0.081: 23.3,119.52 23.3,120.11 21.78,121.63 RG1451.1
  TOP w0.089: 23.3,119.52 23.3,118.9 23.62,118.58 23.62,117.96 23.95,117.64 UG1.B50
FB_B_EDC0: length 21.5
  IN4 w0.086: v3(23.95,105.55) 23.5,105.99 17,105.99 16,104.99 7.45,104.99 5.46,106.97 5.46,107.17 5.22,107.41 5.08,107.41 4.65,107.84 v6(4.38,107.84)
FB_B_EDC1: length 26.6
  IN1 w0.086: v8(4.38,116.08) 4.72,116.43 5.33,116.43 5.5,116.25 5.5,115.16 5.74,114.92 6.06,114.92 6.28,114.71 6.28,114.4 6.47,114.21 7.5,114.21 9.99,111.72 17.22,111.72 21.44,107.5 24.98,107.5 25.24,107.25 25.75,107.25 v8(26.05,106.95)
FB_B_EDC2: length 16
  IN1 w0.086: v8(27.45,113.25) 27.1,112.9 23.84,112.9 19.55,117.2 14.76,117.2 14.5,116.93 14.5,116.64 14.12,116.26 v8(14.12,116.08)
FB_B_EDC3: length 17.2
  IN4 w0.086: v3(28.15,109.05) 25.06,109.05 23.44,110.67 14.76,110.67 14.48,110.39 14.48,108.19 v6(14.12,107.84)
FB_B_EDC4: length 26.8
  IN4 w0.086: v3(32.35,117.45) 32.36,117.45 32.73,117.82 32.73,119.47 27.47,124.73 26.59,124.73 17.75,133.57 14.53,133.57 v6(14.12,133.16)
FB_B_EDC5: length 19.8
  IN1 w0.086: v8(14.12,124.92) 14.4,124.92 14.67,125.19 16.82,125.19 21.4,120.61 25.94,120.61 27.78,118.77 27.78,118.01 27.97,117.82 28.26,117.82 28.5,117.58 28.5,116.64 28.85,116.29 v8(28.85,116.05)
FB_B_EDC6: length 27
  TOP w0.089: UG1.D51 v3(24.96,117.76)
  IN4 w0.086: v6(4.38,124.92) 4.81,124.48 4.81,123.69 5.54,122.96 11.31,122.96 11.63,123.28 16.96,123.28 23.87,116.38 24.48,116.38 24.67,116.44 24.84,116.61 25.02,116.61 25.34,116.93 25.34,117.38 25.31,117.4
  IN4 w0.089: 25.31,117.4 v3(24.96,117.76)
FB_B_EDC7: length 30.1
  TOP w0.089: UG1.F51 27.12,118.52 v3(27.12,118.58)
  IN4 w0.086: v6(4.38,133.16) 4.7,132.84 4.7,132.47 5.87,131.31 6.06,131.31 6.92,130.44 8.12,130.44 9.62,128.94 17.7,128.94 27.12,119.52 v3(27.12,118.58)
FB_B_WCK01: length 28.9
  TOP w0.099: v3(28.55,105.25) UG1.J33 ; v3(5.42,109.71) 5.33,109.7 5.12,109.42 UG13.D4
  IN2 w0.084: v3(28.55,105.25) 28.55,105.39 28.37,105.56 28.13,105.56 27.8,105.23 26.27,105.23 25.61,105.9 9.07,105.9 8.47,106.5 8.47,108.2 7.66,109.01 7.47,109.01 6.93,109.54 6.93,109.87 6.35,110.45 5.45,110.45 5.08,110.09 5.08,109.82 5.19,109.71 v3(5.42,109.71)
FB_B_WCK23: length 19
  TOP w0.099: v3(29.19,110.09) 29.13,110.08 UG1.J39
  IN2 w0.084: v3(29.19,110.09) 29.01,110.27 29.01,110.69 27.94,111.76 19.46,111.76 18.73,112.49 17.5,112.49 17.49,112.49 15.21,112.49 15.21,112.49 14.49,112.49 13.78,113.2 13.78,113.91 13.37,114.31 v3(13.37,114.58)
FB_B_WCK45: length 30.8
  TOP w0.089: v3(30.56,114.39) 30.27,114.58 UG1.L46
  IN2 w0.084: v3(13.37,131.66) 12.99,131.28 12.99,130.8 12.99,130.8 12.99,130.54 13.43,130.1 21.63,130.1 31.55,120.18 31.55,115.38 v3(30.56,114.39)
FB_B_WCK67: length 32
  TOP w0.099: UG14.R11 5.13,126.51 v3(4.86,126.77)
  IN2 w0.084: v3(4.86,126.77) 4.9,126.82 4.9,127.47 5.26,127.83 7,127.83 7.68,127.15 7.68,126.33 8.66,125.35 8.66,124.29 11.53,121.42 17.01,121.42 24.51,113.92 26.4,113.92 27.6,115.12 27.91,115.12 v3(28.15,115.35)
FB_B_WCK#01: length 29
  TOP w0.099: UG1.H33 28.23,105.55 v3(28.55,105.87) ; UG13.D5 v3(4.76,109.71)
  IN2 w0.084: v3(28.55,105.87) 28.45,105.77 28.05,105.77 27.72,105.44 26.35,105.44 25.69,106.1 9.16,106.1 8.67,106.58 8.67,108.28 7.75,109.21 7.56,109.21 7.14,109.63 7.14,109.96 6.44,110.66 5.36,110.66 4.88,110.17 4.88,109.82 4.85,109.8 4.85,109.79 v3(4.76,109.71)
FB_B_WCK#23: length 19.1
  TOP w0.099: v3(28.44,110.09) 28.43,110.08 UG1.H39
  IN2 w0.084: v3(28.44,110.09) 28.37,110.03 28.37,109.85 28.46,109.76 28.66,109.76 28.8,109.9 28.8,110.61 27.85,111.56 19.37,111.56 18.65,112.28 17.41,112.28 17.41,112.28 15.29,112.28 15.29,112.28 14.41,112.28 13.58,113.11 13.58,113.71 13.45,113.83 v3(13.37,113.83)
FB_B_WCK#45: length 30.7
  TOP w0.089: 30.5,113.85 30.32,113.97 UG1.L45
  TOP w0.099: v3(30.56,113.75) 30.56,113.78 30.55,113.82 30.5,113.85
  IN2 w0.084: v3(30.56,113.75) 30.95,114.15 30.95,114.5 31.75,115.3 31.75,120.27 21.71,130.3 13.51,130.3 13.2,130.62 13.2,130.83 13.28,130.91 v3(13.37,130.91)
FB_B_WCK#67: length 32
  TOP w0.099: UG14.R10 v3(5.46,126.77)
  IN2 w0.084: v3(28.15,114.65) 28.15,114.78 28.02,114.91 27.68,114.91 26.48,113.71 24.43,113.71 16.92,121.22 11.45,121.22 8.46,124.21 8.46,125.27 7.48,126.25 7.48,127.06 6.91,127.63 5.35,127.63 5.11,127.39 5.11,127 5.33,126.77 v3(5.46,126.77)
FB_B_WCKB01: length 29.2
  TOP w0.089: v3(27.77,107.2) 27.77,107.2 27.56,106.96 UG1.G35
  IN2 w0.084: v3(5.13,114.58) 5.13,114.32 5.54,113.91 5.54,113.05 7,111.59 7.65,111.59 9.56,109.68 9.56,106.86 9.8,106.62 16.77,106.62 17.41,107.26 21.87,107.26 21.88,107.26 25.61,107.26 25.99,106.89 26.87,106.89 27.19,107.2 v3(27.77,107.2)
FB_B_WCKB23: length 16.8
  IN2 w0.084: v3(13.37,109.34) 13.37,109.61 12.97,110.02 12.97,111.18 13.39,111.6 17.97,111.6 19.04,110.53 26.33,110.53 26.75,110.95 v3(26.75,111.15)
FB_B_WCKB45: length 29.6
  TOP w0.099: v3(13.07,126.7) 13.29,126.42 UG14.D11 ; UG1.M44 v3(31.38,113.12)
  IN2 w0.084: v3(31.38,113.12) 31.31,113.2 30.22,113.2 30,113.42 30,114.72 30.02,114.74 30.02,119.55 28.26,121.31 27.18,121.31 21.65,126.84 17.94,126.84 16.81,127.97 14.38,127.97 13.46,127.04 13.28,127.04 13.07,126.82 v3(13.07,126.7)
FB_B_WCKB67: length 35.4
  TOP w0.099: UG14.R4 v3(4.81,131.35)
  IN2 w0.084: v3(4.81,131.35) 4.88,131.28 4.88,130.18 5.1,129.95 8.94,129.95 11.36,127.53 11.36,126.81 12.35,125.82 13.43,125.82 13.61,126 13.98,126 13.99,126 14.26,126 15.28,126 15.4,125.88 15.85,125.88 15.97,126 17.08,126 17.28,126.2 21.08,126.2 27.03,120.26 28.03,120.26 28.21,120.08 28.21,120.08 28.56,119.72 28.57,119.72 29.32,118.96 29.32,116.09 28.99,115.76 28.99,115.43 28.91,115.35 v3(28.85,115.35)
FB_B_WCKB#01: length 29.2
  TOP w0.099: UG1.H35 27.93,106.79 27.83,106.72 27.81,106.57 v3(27.81,106.56)
  IN2 w0.084: v3(5.13,113.83) 5.25,113.83 5.33,113.75 5.33,112.97 6.91,111.39 7.56,111.39 9.36,109.59 9.36,106.78 9.72,106.42 16.85,106.42 17.5,107.06 21.79,107.06 21.79,107.06 22.81,107.06 22.81,107.06 25.53,107.06 25.91,106.68 26.96,106.68 27.28,107 27.48,107 27.81,106.67 v3(27.81,106.56)
FB_B_WCKB#23: length 16.8
  IN2 w0.084: v3(13.37,110.09) 13.55,110.09 13.64,110.17 13.64,110.38 13.55,110.47 13.25,110.47 13.17,110.55 13.17,111.09 13.47,111.39 17.89,111.39 18.95,110.33 26.42,110.33 27.24,111.15 v3(27.45,111.15)
FB_B_WCKB#45: length 29.6
  TOP w0.089: UG1.M45 31.07,113.85
  TOP w0.099: 31.07,113.85 v3(31.36,113.63) ; v3(13.07,127.46) 13.29,127.17 UG14.D10
  IN2 w0.084: v3(31.36,113.63) 31.13,113.4 30.3,113.4 30.2,113.5 30.2,114.63 30.23,114.66 30.23,119.63 28.34,121.52 27.26,121.52 21.74,127.04 18.02,127.04 16.89,128.17 14.3,128.17 13.37,127.24 13.25,127.24 13.07,127.42 v3(13.07,127.46)
FB_B_WCKB#67: length 35.6
  TOP w0.099: v3(5.26,130.52) UG14.R5
  IN2 w0.084: v3(28.85,114.65) 29.13,114.65 29.2,114.71 29.2,115.67 29.53,116 29.53,119.05 28.65,119.92 28.65,119.92 28.41,120.16 28.41,120.16 28.11,120.46 27.11,120.46 21.17,126.41 17.2,126.41 17,126.2 15.88,126.2 15.76,126.08 15.48,126.08 15.36,126.2 14.35,126.2 14.35,126.2 13.9,126.2 13.9,126.2 13.53,126.2 13.35,126.02 12.43,126.02 11.56,126.9 11.56,127.62 9.02,130.16 5.19,130.16 5.08,130.27 5.08,130.39 5.2,130.52 v3(5.26,130.52)
FB_C_CLK0: length 26.7
  IN2 w0.084: v3(27.45,92.95) 27.27,93.13 27.27,93.31 27.06,93.51 24.48,93.51 15.01,84.05 9.8,84.05 9,83.25 9,79.8 v3(8.88,79.67)
FB_C_CLK1: length 28.5
  IN2 w0.084: v3(28.15,97.15) 28.23,97.23 28.35,97.23 28.51,97.07 28.51,96.28 28.29,96.05 25.93,96.05 25.42,96.56 24.46,96.56 16.42,88.52 10.2,88.52 9.44,89.29 9.44,92 9.23,92.2 9.23,92.97 9.32,93.06 9.57,93.06 v3(9.62,93.01)
FB_C_CLK#0: length 26.6
  IN2 w0.084: v3(26.75,92.95) 26.85,92.85 26.97,92.85 27.06,92.95 27.06,93.23 26.98,93.31 24.56,93.31 15.1,83.85 9.88,83.85 9.21,83.17 9.21,79.8 9.33,79.67 v3(9.62,79.67)
FB_C_CLK#1: length 28.5
  IN2 w0.084: v3(8.88,93.01) 9.03,92.85 9.03,92.12 9.23,91.92 9.23,89.2 10.12,88.32 16.51,88.32 24.54,96.36 25.34,96.36 25.84,95.85 28.37,95.85 28.71,96.19 28.71,97.02 v3(28.85,97.15)
FB_C_CMD0: length 33.6
  TOP w0.089: UG1.C11 25,89.79 25,88.63 25.28,88.35 25.47,88.35 25.65,88.17 25.65,81.34
  TOP w0.099: 25.65,81.34 25.65,80.51 v2(17.91,72.77) 17.31,72.17 8.36,72.17 7.73,72.8 7.73,74.03 UG15.H3
FB_C_CMD1: length 33.3
  TOP w0.081: UG15.K3 9.26,74.06 ; UG15.J3 9.24,74.06
  TOP w0.089: 24.97,81.34 24.97,88.16 24.78,88.35 24.34,88.35 24.31,88.38 24.31,89.79 UG1.B11
  TOP w0.099: 9.26,74.06 8.68,74.06 8.49,73.87 8.49,72.75 8.72,72.52 17.12,72.52 v10(21.34,76.74) 24.97,80.36 24.97,81.34
FB_C_CMD2: length 28.9
  TOP w0.089: UG1.A11 23.61,89.79 23.61,88.64 23.9,88.35 24.07,88.35 24.25,88.17 24.25,86.77 24.26,86.76 24.26,81.34
  TOP w0.099: UG15.J1 9.25,73.3 17.12,73.3 RG1489.2 v2(19.19,75.37) 21.87,78.06 22.21,78.06 24.26,80.1 24.26,81.34
FB_C_CMD3: length 29.8
  TOP w0.081: UG15.K4 9.24,74.79 9.1,74.92 9.1,74.95 UG15.J4
  TOP w0.089: 23.17,90.49 25.01,90.49 UG1.D11
  TOP w0.099: 23.17,90.49 23.14,90.45 23.12,90.45 22.95,90.28 22.95,90.26 22.89,90.2 22.89,86.67 22.34,86.12 22.34,81.27 v2(20.31,79.25) 15.84,74.77 13.15,74.77 13,74.62 13,74.24 12.83,74.07 10.16,74.07 10.01,74.22 10.01,74.58 9.81,74.79 9.24,74.79
FB_C_CMD4: length 24.8
  TOP w0.089: 22.63,90.37 22.64,90.39 22.64,90.4 23.09,90.85 UG1.A12
  TOP w0.099: 22.63,90.37 22.53,90.27 22.53,86.77 21.88,86.12 21.88,81.28 v2(17.76,77.16) 16.13,75.53 12.42,75.53 12.26,75.36 12.26,74.93 12.1,74.77 10.72,74.77 UG15.L3
FB_C_CMD5: length 24.8
  TOP w0.089: 22.99,91.2 23.47,91.2 23.82,90.85 UG1.B12
  TOP w0.099: 22.99,91.2 22.2,90.41 22.2,86.9 21.46,86.16 21.46,81.41 v2(18.38,78.32) 16.41,76.36 11.75,76.36 11.47,76.08 11.47,75.52 UG15.M4
FB_C_CMD6: length 28.3
  TOP w0.081: 9.26,75.55 9.62,75.92 UG15.K5 ; UG15.J5 9.25,75.55
  TOP w0.089: UG1.C12 24.28,91.22 23.72,91.22 23.51,91.44 22.81,91.44 21.84,90.48
  TOP w0.099: 9.25,75.55 10.64,75.55 10.73,75.64 10.73,76.04 11.43,76.74 16.2,76.74 v2(18.98,79.52) 18.98,79.54 21.07,81.63 21.07,86.21 21.84,86.98 21.84,90.48
FB_C_CMD7: length 29.7
  TOP w0.081: UG15.L5 9.88,76.42 8.62,76.42 UG15.H5
  TOP w0.089: UG1.C14 24.35,91.95 23.89,91.95 23.63,91.69 22.6,91.69
  TOP w0.099: 9.19,76.42 9.19,76.84 9.46,77.12 16.12,77.12 19.76,80.76 v2(19.76,80.86) 19.76,81.89 20.62,82.76 20.62,86.25 21.54,87.16 21.54,90.63 22.6,91.69
FB_C_CMD8: length 28.7
  TOP w0.089: UG1.B14 23.76,92.25 23.46,91.95 22.43,91.95
  TOP w0.099: 22.43,91.95 21.24,90.75 21.24,90.71 21.23,90.71 21.23,87.32 20.21,86.29 20.21,83.04 v2(19.77,82.6) 19.2,82.03 19.2,80.63 16.07,77.5 9.12,77.5 7.75,76.13 7.75,75.55 UG15.G4
FB_C_CMD9: length 28.7
  TOP w0.089: 22.3,92.25 UG1.A14
  TOP w0.099: UG15.G11 7.03,80.08 7.03,79.17 8.19,78.01 16.15,78.01 18.9,80.76 18.9,82.33 19.82,83.25 v2(19.82,84.91) 19.82,86.41 20.93,87.52 20.93,90.89 22.3,92.25
FB_C_CMD10: length 32.1
  TOP w0.081: UG15.G10 7.75,80.05 v8(9.4,80.05) 9.69,80.05 9.69,80.05 10.75,80.05 UG15.M10
  TOP w0.089: UG1.D14 25.02,92.58 22.2,92.58
  TOP w0.099: v8(9.27,78.64) 9.33,78.58 15.99,78.58 RG1487.2 18.57,81.15 18.57,82.43 19.02,82.88 19.02,86.18 v2(19.47,86.62) 20.63,87.78 20.63,91.02 22.2,92.58
  IN1 w0.071: v8(9.27,78.64) 9.27,79.92 v8(9.4,80.05)
FB_C_CMD11: length 26.8
  TOP w0.081: UG15.H10 8.35,79.45 8.35,79.44 8.53,79.26 9.96,79.26 UG15.L10
  TOP w0.089: UG1.A15 22.13,92.95
  TOP w0.099: 9.26,79.26 9.26,79.11 9.35,79.03 15.47,79.03 17.16,80.71 17.16,81.44 18.59,82.88 18.59,86.49 v2(20.28,88.17) 20.33,88.22 20.33,91.15 22.13,92.95
FB_C_CMD12: length 22.7
  TOP w0.089: 22.18,93.28 23.47,93.28 23.8,92.95 UG1.B15
  TOP w0.099: 22.18,93.28 22.04,93.28 20.02,91.26 20.02,88.6 18.16,86.74 v2(18.16,84.29) 18.16,82.92 16.65,81.4 16.65,80.9 15.83,80.08 15.02,80.08 14.98,80.04 11.51,80.04 UG15.M11
FB_C_CMD13: length 23.9
  TOP w0.089: UG1.C15 24.25,93.34 23.7,93.34 23.54,93.5 22.5,93.5 22.42,93.57 22.32,93.57 22.31,93.58 21.91,93.58 21.81,93.48 21.8,93.48
  TOP w0.099: 21.8,93.48 19.71,91.39 19.71,91.24 19.71,88.9 17.78,86.97 v2(17.78,86.07) 17.78,83.01 16.27,81.49 16.27,81.22 15.83,80.78 10.77,80.78 UG15.L12
FB_C_CMD14: length 26.3
  TOP w0.081: UG15.K11 9.62,80.43 9.25,80.8 UG15.J11
  TOP w0.089: UG1.C17 24.65,94.26 24.38,93.99 23.86,93.99 23.66,93.79 22.96,93.79
  TOP w0.099: 22.96,93.79 22.95,93.78 22.52,93.78 22.42,93.88 22.18,93.88 21.59,93.88 19.41,91.7 19.41,91.52 19.41,89.26 v2(18.08,87.93) 17.39,87.23 17.39,83.03 15.88,81.53 10.23,81.53 10,81.3 10,81.04 9.78,80.83 9.77,80.83 9.77,80.83 9.48,80.83 9.48,80.83 9.28,80.83 9.25,80.8
FB_C_CMD15: length 25.2
  TOP w0.081: UG15.K12 9.56,81.17 9.22,81.52 UG15.J12
  TOP w0.089: 22.75,94.04 23.48,94.04 23.79,94.35 UG1.B17
  TOP w0.099: 22.75,94.04 22.57,94.04 22.43,94.18 22.31,94.18 21.46,94.18 21.28,93.99 21.27,93.99 19.11,91.83 19.11,91.64 19.11,91.64 19.11,90.74 19.11,89.52 v2(19,89.42) 17.13,87.55 17.13,83.33 16.11,82.31 10.25,82.31 9.98,82.04 9.98,81.76 9.75,81.53 9.23,81.53 9.22,81.52
FB_C_CMD16: length 20.2
  TOP w0.089: UG1.B24 21.58,101.62
  TOP w0.099: 21.58,101.62 20.01,103.19 v2(16.51,103.19) 14.29,100.97 9.57,100.97 8.53,99.93 8.53,98.66 UG16.L3
FB_C_CMD17: length 19
  TOP w0.081: UG16.K3 9.24,98.62 ; UG16.J3 9.26,98.62
  TOP w0.089: UG1.A24 21.13,101.37
  TOP w0.099: 9.26,98.62 9.26,98.62 ; 9.26,98.62 9.24,98.62 ; 9.26,98.62 9.26,99.9 9.95,100.59 14.46,100.59 16.68,102.81 v2(18.94,102.81) 19.69,102.81 21.13,101.37
FB_C_CMD18: length 18.4
  TOP w0.089: UG1.D23 25.28,98.61 25.11,98.61 24.79,98.93 23.05,98.93 21.13,100.85
  TOP w0.099: 21.13,100.85 v2(20.56,101.42) 19.61,102.38 RG1490.2 16.95,102.38 14.78,100.21 10.24,100.21 10.04,100.01 9.89,100.01 UG16.J1
FB_C_CMD19: length 16.7
  TOP w0.081: UG16.K4 9.24,97.87 ; 9.26,97.87 9.62,97.51 UG16.J4
  TOP w0.089: UG1.A23 22.92,98.55
  TOP w0.091: 21.07,99.41 22.07,99.41 22.92,98.55
  TOP w0.099: 9.24,97.87 9.79,97.87 9.99,98.07 9.99,99.23 10.16,99.41 v2(20.9,99.41) 21.07,99.41
FB_C_CMD20: length 14.3
  TOP w0.089: UG1.B23 23.87,98.55 23.57,98.25 22.75,98.25 21.97,99.02 21.13,99.02
  TOP w0.099: UG16.H3 10.72,98.6 16.13,98.6 16.56,99.02 v2(19.11,99.02) 21.13,99.02
FB_C_CMD21: length 14.6
  TOP w0.089: UG1.C23 24.27,98.17 23.78,98.17 23.54,97.93 22.62,97.93 21.91,98.64 21.13,98.64
  TOP w0.099: UG16.G4 11.51,97.89 16,97.89 16.81,98.69 v2(17.51,98.69) 21.08,98.69 21.13,98.64
FB_C_CMD22: length 17.4
  TOP w0.081: UG16.K5 9.24,97.12 ; 9.26,97.12 9.62,96.76 UG16.J5
  TOP w0.089: UG1.C21 24.56,97.15 24.23,97.48 23.83,97.48 23.59,97.73 22.32,97.73 21.72,98.33 21.13,98.33
  TOP w0.099: 9.24,97.12 15.7,97.12 16.91,98.33 21.13,98.33
FB_C_CMD23: length 19
  TOP w0.081: UG16.H5 10.02,96.4 8.48,96.4 UG16.L5
  TOP w0.089: 21.13,98.01 21.53,98.01 22.09,97.45 23.43,97.45 23.66,97.22 23.88,97.22 UG1.B21
  TOP w0.099: 21.13,98.01 17,98.01 16.26,97.27 16.26,96.93 15.3,95.97 9.33,95.97 9.19,96.11 9.19,96.4
FB_C_CMD24: length 18.4
  TOP w0.089: UG1.A21 21.94,97.15 21.4,97.69 21.13,97.69
  TOP w0.099: UG16.M4 7.73,97.15 7.73,96.3 8.38,95.64 15.42,95.64 16.74,96.96 16.74,97.32 17.11,97.69 21.13,97.69
FB_C_CMD25: length 22.2
  TOP w0.089: 21.13,97.27 21.44,97.27 21.89,96.82 25.09,96.82 25.35,96.56 UG1.D20
  TOP w0.099: 21.13,97.27 v2(18.97,97.27) 18.47,97.27 18.36,97.37 17.27,97.37 17.06,97.16 17.06,96.71 15.03,94.68 8.06,94.68 6.96,93.59 6.96,92.67 UG16.M11
FB_C_CMD26: length 24.1
  TOP w0.081: UG16.G10 10.76,92.64 v8(9.22,92.64) 7.74,92.64 UG16.M10
  TOP w0.089: 21.13,96.92 21.2,96.92 21.78,96.33 23.13,96.33 UG1.A20
  TOP w0.099: 21.13,96.92 v2(20.7,96.92) RG1488.2 15.08,94.3 8.91,94.3 8.82,94.21 8.82,93.84 8.73,93.74 8.55,93.74 8.45,93.84 8.45,94.21 8.36,94.3 8.13,94.3 7.91,94.08 v8(7.91,93.57)
  IN1 w0.071: v8(7.91,93.57) 7.91,93.3 8.57,92.64 v8(9.22,92.64)
FB_C_CMD27: length 18.8
  TOP w0.081: UG16.H10 9.96,93.42 8.48,93.42 8.35,93.3 8.35,93.23 UG16.L10
  TOP w0.089: UG1.B20 23.73,96.45 23.34,96.07 21.43,96.07 21.43,96.07 21.26,96.24 21.13,96.24
  TOP w0.099: 9.31,93.42 9.31,93.58 9.68,93.94 15.56,93.94 17.13,95.52 18.5,95.52 19.23,96.24 21.13,96.24
FB_C_CMD28: length 15.7
  TOP w0.089: UG1.C20 24.65,96.36 24.37,96.07 23.76,96.07 23.5,95.82 21.38,95.82 21.26,95.94 21.13,95.94
  TOP w0.099: 21.13,95.94 19.48,95.94 19.23,95.69 18.23,94.69 v2(18.05,94.69) 17.86,94.69 16.69,93.53 11.85,93.53 11.47,93.14 11.47,92.6 UG16.G11
FB_C_CMD29: length 16.2
  TOP w0.089: 21.13,95.64 21.25,95.64 21.33,95.57 23.7,95.57 23.83,95.44 24.26,95.44 UG1.C18
  TOP w0.099: 21.13,95.64 19.81,95.64 v2(19.61,95.44) 19.33,95.16 19.13,95.16 15.82,91.85 10.72,91.85 UG16.H12
FB_C_CMD30: length 17.5
  TOP w0.081: UG16.J12 UG16.K12
  TOP w0.089: 22.29,95.34 22.3,95.35 23.5,95.35 23.81,95.05 UG1.B18
  TOP w0.091: 22.29,95.34 20.01,95.34 18.85,94.18
  TOP w0.099: 18.85,94.18 v2(17.66,92.99) 15.8,91.14 9.49,91.14 9.25,91.38 9.25,91.51
FB_C_CMD31: length 19.5
  TOP w0.081: 9.22,91.86 8.88,92.2 UG16.K11 ; UG16.J11 9.23,91.86
  TOP w0.089: UG1.A18 23.2,95 20.55,95
  TOP w0.099: 9.23,91.86 8.7,91.86 8.49,91.65 8.49,91.3 8.66,91.13 9,91.13 9.25,90.87 9.25,90.62 9.51,90.36 15.92,90.36 20.55,95
FB_C_CMD32: length 25.8
  TOP w0.089: 21.69,94.49 23.11,94.49 UG1.A17
  TOP w0.099: UG15.H12 7.73,81.57 7.73,82.07 7.98,82.32 9.79,82.32 10.01,82.54 10.01,82.81 10.33,83.13 16.49,83.13 16.8,83.44 16.8,87.68 18.76,89.64 v2(18.76,91.63) 18.76,91.94 21.31,94.49 21.69,94.49
FB_C_CMD33: length 23.2
  TOP w0.089: 21.13,94.7 21.25,94.7 21.29,94.74 24.96,94.74 UG1.D17
  TOP w0.099: 21.13,94.7 20.89,94.7 v2(19.88,93.69) 18.36,92.18 18.36,89.69 17.96,89.28 9.84,89.28 9.25,89.88 9.25,90.12 9.01,90.36 7.96,90.36 7.77,90.55 7.77,91.15 UG16.L12
FB_C_D0: length 28
  IN1 w0.086: v8(6.63,73.68) 6.96,74.01 6.96,74.52 9.06,76.61 18.66,76.61 20.18,78.12 20.18,80.33 20.81,80.96 20.81,84.93 22.84,86.96 23.41,86.96 23.62,86.75 23.62,86.47 23.8,86.3 24.3,86.3 v8(24.65,86.65)
FB_C_D1: length 30.9
  IN1 w0.086: v8(25.35,86.65) 24.75,87.25 24.5,87.25 24.12,87.63 23.72,87.63 23.52,87.43 22.42,87.43 20.18,85.19 20.18,81.15 19.6,80.57 19.6,78.49 18.35,77.24 8.76,77.24 7.06,75.54 3.99,75.54 v8(3.63,75.18)
FB_C_D2: length 24.9
  IN1 w0.086: v8(23.25,86.65) 22.98,86.65 21.13,84.8 21.13,80.87 20.47,80.21 20.47,77.96 18.8,76.29 9.99,76.29 v8(7.38,73.68)
FB_C_D3: length 28
  IN1 w0.086: v8(5.88,73.68) 6.32,74.12 6.32,74.69 6.46,74.83 6.86,74.83 8.95,76.93 18.54,76.93 19.89,78.27 19.89,80.45 20.5,81.06 20.5,85.06 22.58,87.15 23.72,87.15 23.95,86.92 v8(23.95,86.65)
FB_C_D4: length 31.7
  IN1 w0.086: v8(23.95,85.25) 23.6,84.9 23.03,84.9 22.4,84.27 22.4,78.13 16.1,71.83 6.78,71.83 6.41,71.47 4.38,71.47 3.3,72.54 3.3,73.35 v8(3.63,73.68)
FB_C_D5: length 30.7
  IN1 w0.086: v8(3.63,74.43) 4,74.05 4,72.61 4.83,71.78 6.29,71.78 6.65,72.15 15.97,72.15 21.34,77.51 21.34,79.85 22.08,80.6 22.08,84.41 22.93,85.25 v8(23.25,85.25)
FB_C_D6: length 36.9
  IN1 w0.086: v8(5.88,74.43) 5.6,74.43 5.26,74.77 3.34,74.77 3.19,74.62 3.19,74.21 3.05,74.07 2.77,74.07 2.41,73.71 2.41,71.85 3.11,71.15 6.6,71.15 6.97,71.51 16.23,71.51 22.72,78 22.72,83.74 23.16,84.19 23.34,84.19 23.7,84.55 v8(23.95,84.55)
FB_C_D7: length 35.5
  IN1 w0.086: v8(2.88,74.43) 2.71,74.43 2.1,73.81 2.1,71.78 3.05,70.83 6.73,70.83 7.09,71.19 16.36,71.19 23.04,77.86 23.04,83.16 23.59,83.72 23.59,83.98 23.74,84.14 23.97,84.14 24.31,84.47 24.31,84.67 24.65,85.01 v8(24.65,85.25)
FB_C_D8: length 28.4
  IN1 w0.086: v8(25.35,88.75) 25.07,89.03 25.07,89.61 24.33,90.36 20.94,90.36 16.21,85.63 5.46,85.63 3.3,83.46 3.3,81.42 3.54,81.17 v8(3.63,81.17)
FB_C_D9: length 28.1
  IN1 w0.086: v8(24.65,88.75) 24.71,88.81 24.71,89.53 24.19,90.04 21.13,90.04 15.69,84.6 5.39,84.6 4,83.21 4,81.8 4.2,81.6 5.55,81.6 v8(5.88,81.92)
FB_C_D10: length 25.1
  IN1 w0.086: v8(7.38,81.92) 7.75,82.3 7.75,83.18 7.9,83.33 16.84,83.33 17.89,84.38 17.89,84.5 17.67,84.72 17.67,84.84 17.79,84.96 17.91,84.96 18.13,84.74 18.25,84.74 18.38,84.86 18.38,84.99 18.16,85.21 18.16,85.33 18.28,85.45 18.4,85.45 18.62,85.23 18.74,85.23 18.86,85.35 18.86,85.47 18.64,85.69 18.64,85.82 21.28,88.45 23.91,88.45 24.25,88.12 24.25,87.95 24.5,87.69 25.46,87.69 25.73,87.96 25.73,88.43 v8(26.05,88.75)
FB_C_D11: length 23.2
  IN1 w0.086: v8(23.95,88.75) 23.93,88.77 21.19,88.77 17.12,84.71 17.12,84.58 17.3,84.41 17.3,84.29 17.18,84.16 17.05,84.16 16.88,84.34 16.76,84.34 16.64,84.22 16.64,84.09 16.81,83.92 16.81,83.8 16.69,83.68 16.57,83.68 16.39,83.85 16.27,83.85 16.06,83.65 7.36,83.65 7.21,83.5 7.21,82.89 7.12,82.81 6.95,82.81 6.86,82.89 6.86,83.05 6.78,83.14 6.44,83.14 6.35,83.05 6.35,82.2 v8(6.63,81.92)
FB_C_D12: length 24
  IN1 w0.086: v8(3.63,81.92) 3.63,81.65 3.98,81.3 3.98,81.18 4.3,80.87 8.03,80.87 9.49,82.33 16.74,82.33 22.16,87.75 23.37,87.75 23.67,88.05 v8(23.95,88.05)
FB_C_D13: length 23.5
  IN1 w0.086: v8(23.25,88.05) 22.98,88.05 22.93,88.1 22.06,88.1 21.31,87.35 21.19,87.35 20.95,87.59 20.83,87.59 20.71,87.47 20.71,87.35 20.95,87.11 20.95,86.99 20.81,86.85 20.69,86.85 20.45,87.09 20.33,87.09 20.21,86.97 20.21,86.85 20.45,86.61 20.45,86.49 20.33,86.36 20.2,86.36 19.96,86.6 19.84,86.6 19.72,86.48 19.72,86.36 19.96,86.12 19.96,86 19.84,85.88 19.71,85.88 19.48,86.12 19.35,86.12 19.23,85.99 19.23,85.87 19.47,85.63 19.47,85.51 17,83.04 9.6,83.04 8.38,81.82 8.38,81.82 8.23,81.66 8.07,81.5 6.2,81.5 v8(5.88,81.17)
FB_C_D14: length 35.3
  IN1 w0.086: v8(26.75,86.65) 26.35,87.05 26.35,88.17 26.72,88.53 26.72,88.95 24.68,90.99 20.5,90.99 15.81,86.3 4.97,86.3 2.01,83.34 2.01,81.44 2.65,80.8 3.25,80.8 v8(3.63,80.42)
FB_C_D15: length 32.4
  IN1 w0.086: v8(26.05,86.65) 26.05,88.31 26.4,88.66 26.4,88.82 24.55,90.68 20.75,90.68 16.06,85.98 5.29,85.98 2.39,83.09 2.39,81.66 v8(2.88,81.17)
FB_C_D16: length 22.9
  IN4 w0.086: v3(26.75,95.05) 26.34,95.46 25.91,95.46 25.05,94.6 24.73,94.6 21.09,90.96 21.09,88.3 17.22,84.44 13.22,84.44 12.22,83.43 12.22,82.27 v3(11.87,81.92)
FB_C_D17: length 22.6
  IN4 w0.086: v3(12.62,81.17) 13.02,81.57 13.02,82.06 13.37,82.41 13.48,82.41 13.63,82.57 13.63,82.75 14.48,83.59 17.34,83.59 21.72,87.97 21.72,90.69 25.16,94.13 25.25,94.13 25.68,94.57 26.97,94.57 v3(27.45,95.05)
FB_C_D18: length 20.9
  IN4 w0.086: v3(12.62,81.92) 12.62,82.17 13.02,82.57 13.02,83.09 13.85,83.92 17.13,83.92 21.37,88.16 21.37,90.8 24.92,94.35 25.16,94.35 25.86,95.05 v3(26.05,95.05)
FB_C_D19: length 25.1
  IN4 w0.086: v3(28.15,95.05) 27.49,95.71 25.86,95.71 24.98,94.83 24.51,94.83 20.8,91.12 20.8,88.42 17.1,84.73 13.03,84.73 11.56,83.25 11.56,82.36 v3(11.12,81.92)
FB_C_D20: length 16.9
  IN4 w0.086: v3(25.35,92.95) 22.73,90.33 22.73,87.64 16.72,81.63 15.17,81.63 v3(14.87,81.92)
FB_C_D21: length 16.8
  IN4 w0.086: v3(15.62,81.17) 16.72,81.17 23.11,87.57 23.11,90.2 25.59,92.67 25.77,92.67 v3(26.05,92.95)
FB_C_D22: length 21.5
  TOP w0.089: v3(27.3,93.88) 27.33,93.96 UG1.G17
  IN4 w0.086: v3(27.3,93.88) 27.85,93.33 27.85,92.85 27.6,92.6 27.14,92.6 26.95,92.41 25.65,92.41 23.37,90.12 23.37,87.38 16.79,80.8 15.25,80.8 v3(14.87,81.17)
FB_C_D23: length 22.2
  TOP w0.122: UG1.H17 28.43,93.95 v3(28.46,93.95)
  IN4 w0.086: v3(14.87,80.42) 15.2,80.1 16.54,80.1 23.62,87.18 23.62,90.13 25.63,92.14 27.17,92.14 27.43,92.41 27.77,92.41 28.46,93.1 v3(28.46,93.95)
FB_C_D24: length 29.9
  IN4 w0.086: v3(12.62,73.68) 13,74.06 13,76.15 13.94,77.09 17.99,77.09 23.05,82.15 23.05,84.34 23.81,85.1 23.81,85.12 24.95,86.26 24.95,90.26 25.75,91.05 26.43,91.05 26.73,91.35 28.6,91.35 28.85,91.6 v3(28.85,92.95)
FB_C_D25: length 28.8
  TOP w0.122: UG1.H15 v3(28.45,92.57)
  IN4 w0.086: v3(12.62,74.43) 12.24,74.81 12.24,76.04 13.69,77.49 17.94,77.49 22.68,82.22 22.68,84.37 24.57,86.27 24.57,90.13 25.67,91.23 26.36,91.23 26.88,91.74 27.06,91.74 27.53,92.22 28.09,92.22 v3(28.45,92.57)
FB_C_D26: length 27.8
  TOP w0.089: UG1.E14 25.82,92.02 v3(25.82,91.76)
  IN4 w0.086: v3(25.82,91.76) 25.57,91.76 23.88,90.07 23.88,86.71 22.04,84.87 22.04,82.49 17.75,78.2 13.37,78.2 10.77,75.59 10.77,74.03 v3(11.12,73.68)
FB_C_D27: length 27.9
  TOP w0.089: v3(26.35,91.77) 26.35,91.85 UG1.F14
  IN4 w0.086: v3(26.35,91.77) 25.98,91.4 25.53,91.4 24.26,90.13 24.26,86.64 22.36,84.74 22.36,82.36 17.89,77.89 13.57,77.89 11.48,75.8 11.48,74.07 v3(11.87,73.68)
FB_C_D28: length 24.3
  TOP w0.122: UG1.H11 v3(28.48,89.78)
  IN4 w0.086: v3(14.87,73.68) 15.2,74.01 18.65,74.01 24.9,80.25 24.9,83.64 27.62,86.36 27.62,87.33 28.48,88.18 v3(28.48,89.78)
FB_C_D29: length 23
  TOP w0.089: UG1.G11 v3(27.78,89.78)
  IN4 w0.086: v3(15.62,74.43) 18.64,74.43 24.58,80.36 24.58,83.73 27.36,86.51 27.36,87.45 28.14,88.24 28.14,89.42 v3(27.78,89.78)
FB_C_D30: length 22.8
  TOP w0.089: UG1.F11 v3(27.05,89.82)
  IN4 w0.086: v3(14.87,74.43) 15.22,74.77 18.44,74.77 24.26,80.59 24.26,83.82 26.39,85.95 26.39,89.16 v3(27.05,89.82)
FB_C_D31: length 22
  TOP w0.089: UG1.E11 v3(26.38,89.78)
  IN4 w0.086: v3(26.38,89.78) 25.97,89.37 25.97,85.94 23.95,83.92 23.95,80.68 18.79,75.53 15.23,75.53 v3(14.87,75.18)
FB_C_D32: length 16.6
  IN1 w0.086: v8(28.85,102.75) 28.85,102.36 28.21,101.72 25.93,101.72 25.69,101.48 25.69,101.16 25.53,100.99 19.88,100.99 16.76,97.88 15.24,97.88 14.87,97.51 v8(14.87,97.5)
FB_C_D33: length 19.8
  IN1 w0.086: v8(26.75,103.45) 26.17,104.03 24.84,104.03 24.64,104.23 21.46,104.23 21.08,104.61 14.86,104.61 10.79,100.55 10.79,99.33 v8(11.12,99)
FB_C_D34: length 14.5
  IN1 w0.086: v8(28.15,102.75) 28.15,102.48 27.67,102.01 25.97,102.01 25.68,101.72 23.08,101.72 22.87,101.51 19.88,101.51 16.63,98.25 v8(15.62,98.25)
FB_C_D35: length 25.5
  IN1 w0.086: v8(27.45,103.45) 27.03,103.87 26.62,103.87 26.19,104.3 25.04,104.3 24.83,104.52 21.68,104.52 20.64,105.56 15.11,105.56 9.98,100.43 9.98,98.44 10.54,97.88 12.25,97.88 v8(12.62,98.25)
FB_C_D36: length 15.6
  IN1 w0.086: v8(14.87,98.25) 14.52,98.61 13.26,98.61 13.08,98.79 13.08,99.84 13.89,100.65 16.29,103.06 21.75,103.06 22,103.31 22.94,103.31 23.1,103.15 23.43,103.15 23.73,103.45 v8(23.95,103.45)
FB_C_D37: length 13.7
  IN1 w0.086: v8(23.25,103.45) 23.1,103.6 21.39,103.6 21.14,103.35 15.63,103.35 12.28,100 12.28,99.35 v8(12.62,99)
FB_C_D38: length 15.4
  IN1 w0.086: v8(14.87,99) 15.22,99.35 16.46,99.35 19,101.9 25.54,101.9 25.97,102.33 27.52,102.33 27.85,102.66 27.85,103.15 v8(28.15,103.45)
FB_C_D39: length 16.5
  IN1 w0.086: v8(24.65,103.45) 24.59,103.45 24.13,103.91 21.27,103.91 20.95,104.23 15.37,104.23 11.56,100.42 11.56,99.32 v8(11.87,99)
FB_C_D40: length 15.7
  IN4 w0.086: v3(25.35,101.35) 25.34,101.34 25.34,100.79 17.21,92.66 17.21,91.85 16.45,91.09 15.2,91.09 v6(14.87,90.76)
FB_C_D41: length 28
  IN4 w0.086: v6(11.12,90.76) 10.83,91.05 10.83,92.79 12.91,94.86 15.44,94.86 20.83,100.25 20.83,101.69 22.81,103.68 27.3,103.68 29.25,101.73 29.25,101.05 v3(28.85,100.65)
FB_C_D42: length 22.8
  IN4 w0.086: v3(26.75,101.35) 26.34,101.75 26.07,101.75 25.14,102.69 23.09,102.69 22.25,101.85 22.25,100.41 15.72,93.88 12.88,93.88 12.26,93.25 12.26,92.86 12.51,92.61 12.64,92.61 12.99,92.25 12.99,91.39 12.62,91.02 v6(12.62,90.76)
FB_C_D43: length 23.7
  TOP w0.089: v3(27.18,100.99) 27.45,101.28 UG1.G27
  IN4 w0.086: v3(27.18,100.99) 27.24,101.06 27.24,101.44 26.63,102.05 26.2,102.05 25.27,102.98 22.97,102.98 21.96,101.97 21.96,100.53 15.63,94.2 12.95,94.2 12.03,93.27 12.03,92.61 12.26,92.38 12.26,91.87 v6(12.62,91.51)
FB_C_D44: length 13.9
  IN4 w0.086: v6(15.62,91.51) 16.17,91.51 16.89,92.23 16.89,92.8 24.64,100.54 24.64,101.34 v3(24.65,101.35)
FB_C_D45: length 14
  IN4 w0.086: v3(23.95,101.35) 23.73,101.13 23.73,100.05 16.38,92.7 16.38,92.42 15.88,91.91 15.28,91.91 v6(14.87,91.51)
FB_C_D46: length 12.9
  IN4 w0.086: v3(23.25,101.35) 23.25,100.06 15.8,92.61 15.23,92.61 v6(14.87,92.26)
FB_C_D47: length 23.8
  IN4 w0.086: v3(27.45,102.75) 27.07,103.13 26.24,103.13 26.1,103.27 22.85,103.27 21.48,101.9 21.48,100.46 15.57,94.55 12.92,94.55 11.47,93.09 11.47,91.16 v6(11.87,90.76)
FB_C_D48: length 34.5
  IN4 w0.086: v3(28.15,96.45) 27.59,95.89 25.76,95.89 24.95,95.08 24.31,95.08 20.46,91.23 20.46,89.89 17.06,86.49 5.86,86.49 3.64,88.71 3.01,88.71 2.22,89.5 2.22,91.11 2.62,91.51 v6(2.88,91.51)
FB_C_D49: length 31
  TOP w0.089: UG1.D18 24.89,95.51 v3(24.71,95.51)
  IN4 w0.086: v6(3.63,91.51) 3.21,91.09 2.72,91.09 2.53,90.9 2.53,89.85 3.19,89.19 3.61,89.19 5.84,86.96 17.08,86.96 20.15,90.03 20.15,91.49 24.17,95.51 v3(24.71,95.51)
FB_C_D50: length 30.8
  IN4 w0.086: v6(3.63,90.76) 3.33,90.46 3.33,89.93 6.03,87.23 16.83,87.23 19.82,90.22 19.82,91.62 24.05,95.85 25.39,95.85 25.62,96.08 27.08,96.08 v3(27.45,96.45)
FB_C_D51: length 30.1
  IN4 w0.086: v3(26.05,96.45) 25.73,96.45 25.45,96.17 23.89,96.17 19.49,91.76 19.49,90.35 16.69,87.55 6.26,87.55 4,89.8 4,91.88 v6(3.63,92.26)
FB_C_D52: length 25.1
  IN4 w0.086: v6(7.38,90.76) 7.68,90.45 7.68,89.69 8.19,89.18 15.88,89.18 17.84,91.15 17.84,92.4 23.45,98.01 26.21,98.01 v3(26.75,98.55)
FB_C_D53: length 26.3
  TOP w0.089: UG1.E21 v3(25.78,97.56)
  IN4 w0.086: v3(25.78,97.56) 23.46,97.56 18.16,92.27 18.16,90.91 16.14,88.89 7.85,88.89 6.99,89.75 6.99,90.07 6.68,90.38 6.52,90.38 6.25,90.64 6.25,91.13 v6(5.88,91.51)
FB_C_D54: length 25
  IN4 w0.086: v6(5.88,90.76) 5.88,90.51 6.29,90.1 6.29,89.82 7.53,88.57 16.27,88.57 18.48,90.78 18.48,92.14 23.46,97.12 25.32,97.12 v3(25.35,97.15)
FB_C_D55: length 25.1
  IN4 w0.086: v6(6.63,90.76) 7.02,91.15 8.32,91.15 8.51,90.96 8.51,90.39 9.4,89.5 15.75,89.5 17.52,91.27 17.52,92.53 23.54,98.55 v3(26.05,98.55)
