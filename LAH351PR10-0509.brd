# Allegro board LAH351PR10-0509.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 64.33,27.52 64.33,26.19 64.24,26.1 63.59,26.1 63.46,25.97 63.46,24.77 63.6,24.63 63.75,24.63 63.82,24.56 63.82,23.46 62.83,22.47 62.17,22.47 62.08,22.38 61.11,22.38 60.96,22.23 60.96,20.5 61.06,20.4 62.98,20.4 63.15,20.57 63.15,22.03 64.14,23.01 64.14,24.5 64.34,24.7 64.69,24.7 64.91,24.92 64.91,25.96 64.85,26.02 64.71,26.02 64.58,26.15 64.58,27.97 64.83,28.22 64.83,29.87 64.71,30 63.98,30 63.53,30.46 62.92,30.46 62.74,30.28 62.74,30.11 62.26,29.63 62.26,29.32 62.38,29.2 62.85,29.2 62.94,29.11 62.94,28.32 63.17,28.09 63.75,28.09
GND on TOP: 94.11,132.27 94.23,132.27 94.3,132.2 94.3,131.31 94.49,131.12 95.57,131.12 95.69,131 95.69,130.11 95.95,129.85 96.71,129.85 96.77,129.79 96.77,129.54 96.71,129.47 95.12,129.47 95,129.35 95,128.96 95.12,128.84 95.5,128.84 95.63,128.71 95.63,127.76 95.38,127.5 91.97,127.5 91.82,127.36 91.82,125.66 91.59,125.43 89.46,125.43 89.38,125.5 89.38,128.91 89.92,129.44 89.92,129.69 90.04,129.82 90.61,129.82 90.77,129.66 93.92,129.66 94.04,129.79 94.04,132.2
GND on TOP: 124.14,106.62 124.14,106.43 124.52,106.05 124.52,105.42 124.65,105.29 124.9,105.29 124.96,105.35 124.96,106.06 125.35,106.45 125.35,106.64 125.21,106.78 125.06,106.78 124.85,106.58 124.66,106.58 124.46,106.78 124.3,106.78
GND on TOP: 133.54,123.79 133.54,123.6 133.6,123.54 134.43,123.54 134.68,123.28 134.68,122.33 134.81,122.2 136.14,122.2 136.27,122.33 136.27,123.28 136.46,123.47 137.41,123.47 137.48,123.54 137.48,123.79 137.41,123.85 133.6,123.85
GND on TOP: 108.71,138.39 110.93,138.39 111.25,138.08 111.25,134.97 110.93,134.65 108.84,134.65 108.46,135.03 108.46,138.14
GND on TOP: 61.79,27.78 61.91,27.65 61.91,26.7 61.34,26.13 61.34,25.55 61.15,25.36 60.39,25.36 60.26,25.49 60.26,27.59 60.45,27.78
GND on TOP: 102.81,132.33 102.93,132.33 103,132.27 103,131.38 103.19,131.19 104.27,131.19 104.39,131.06 104.39,130.17 104.65,129.92 105.41,129.92 105.47,129.85 105.47,129.6 105.41,129.54 103.82,129.54 103.7,129.41 103.7,129.03 103.82,128.9 104.2,128.9 104.33,128.77 104.33,127.82 104.08,127.57 100.59,127.57 99.72,126.7 99.72,125.76 99.52,125.55 97.05,125.55 96.88,125.73 96.88,128.7 97.18,129.01 97.74,129.01 97.98,128.77 99.25,128.77 100.2,129.73 102.62,129.73 102.74,129.85 102.74,132.27
GND on TOP: 36.22,4.38 36.41,4.19 36.41,2.16 36.12,1.87 34.16,1.87 34.16,1.88 33.6,1.88 33.6,1.88 32.85,1.88 32.54,2.19 32.54,3.05 32.35,3.24 32.35,4.13 32.6,4.38
GND on TOP: 27.63,3.6 27.52,3.71 27.52,4.61 27.6,4.69 29.38,4.69 29.45,4.62 29.45,3.71 29.34,3.6
GND on TOP: 126.55,106.62 126.55,106.43 126.93,106.05 126.93,105.42 126.99,105.36 127.32,105.36 127.38,105.41 127.38,106.06 127.76,106.45 127.76,106.64 127.62,106.78 127.47,106.78 127.27,106.58 127.08,106.58 127.07,106.59 127.05,106.59 126.85,106.78 126.71,106.78
GND on TOP: 143.57,103.91 147.83,103.91 147.96,103.79 147.96,102.14 147.51,101.69 145.16,101.69 144.84,101.37 144.84,100.23 145.03,100.04 145.03,99.28 144.97,99.21 144.78,99.21 144.72,99.28 144.72,99.85 144.59,99.98 144.15,99.98 144.02,99.85 144.02,99.28 143.95,99.21 143.76,99.21 143.7,99.28 143.7,99.85 143.38,100.17 143.38,101.37 143.19,101.56 142.37,101.56 142.3,101.63 142.3,101.82 142.37,101.88 143.89,101.88 144.08,102.07 144.08,102.39 143.89,102.58 143.51,102.58 143.38,102.71 143.38,103.72
GND on TOP: 110.8,106.03 111.2,106.42 111.2,106.64 111.06,106.78 110.87,106.78 110.69,106.6 110.5,106.6 110.47,106.62 110.42,106.62 110.29,106.75 110.1,106.75 109.98,106.62 109.98,106.43 110.36,106.05 110.36,105.42 109.96,105.02 109.96,104.83 110.09,104.7 110.85,104.7 110.98,104.83 110.98,105.29 110.8,105.47
GND on TOP: 129.83,119.85 129.83,119.73 129.76,119.66 128.87,119.66 128.68,119.47 128.68,118.39 128.56,118.26 127.67,118.26 127.41,118.01 127.41,117.25 127.35,117.19 127.1,117.19 127.03,117.25 127.03,118.84 126.9,118.96 126.52,118.96 126.4,118.84 126.4,118.46 126.27,118.33 125.32,118.33 125.06,118.58 125.06,122.02 123.85,123.24 123.85,124.06 124.85,125.06 126.87,125.06 127.22,124.71 127.22,120.04 127.35,119.92 129.76,119.92
GND on TOP: 34.77,37.95 35.09,38.27 36.96,38.27 37.27,37.95 37.27,36.96 37.11,36.79 35.05,36.79 34.77,37.07
GND on TOP: 56.07,26.32 55.44,25.68 55.44,21.53 54.38,20.47 54.18,20.47 54.05,20.6 54.05,21.21 54.61,21.77 54.61,22.57 54.04,23.14 54.04,24.28 54.61,24.86 54.61,25.99 54.28,26.32 54.28,27.97 54.58,28.27 55.98,28.27 56.07,28.18
GND on TOP: 134.38,52.61 133.17,52.61 132.79,52.99 132.79,53.57 132.74,53.62 132.31,53.62 132.28,53.6 132.28,52.58 132.56,52.3 134.24,52.3 134.43,52.11 134.43,51.63 134.54,51.51 135.71,51.51 135.79,51.59 135.79,51.7 135.9,51.82 136.93,51.82 136.98,51.77 136.98,50.73 137.07,50.64 137.07,50.12 136.88,49.93 136.14,49.93 136.09,49.87 136.09,49.39 135.33,48.63 135.33,48.19 135.08,47.93 134.82,47.93 134.7,47.81 134.7,47.14 134.75,47.09 135.34,47.09 135.42,47.17 135.42,47.64 135.66,47.88 135.89,47.88 136.39,48.38 137.02,48.38 137.63,48.99 137.63,50.99 137.58,51.04 137.58,52.01 137.43,52.16 137.13,52.16 137.1,52.12 135.99,52.12 135.84,52.28 135.84,52.73 135.66,52.91 134.68,52.91
GND on TOP: 68.14,63.85 69.91,63.85 70.23,63.53 70.23,59.72 70.04,59.53 67.88,59.53 67.75,59.65 67.75,63.46
GND on TOP: 112.64,106.75 112.45,106.75 112.33,106.62 112.33,106.43 112.71,106.05 112.71,105.42 112.37,105.08 112.37,104.83 112.5,104.7 113.26,104.7 113.39,104.83 113.39,105.12 113.15,105.35 113.15,106.18 112.77,106.56 112.77,106.62
GND on TOP: 86.68,132.17 86.8,132.17 86.87,132.11 86.87,131.22 87.06,131.03 88.14,131.03 88.27,130.9 88.27,130.01 88.52,129.76 89.28,129.76 89.34,129.69 89.34,129.44 89.28,129.38 87.69,129.38 87.57,129.25 87.57,128.87 87.69,128.74 88.07,128.74 88.2,128.62 88.2,127.66 87.95,127.41 84.48,127.41 84.12,127.05 84.12,126.42 83.95,126.24 81.86,126.24 81.72,126.38 81.72,129.19 82.11,129.57 86.49,129.57 86.61,129.69 86.61,132.11
GND on TOP: 96.65,138.33 96.84,138.33 96.9,138.27 96.9,137.12 97.03,137 98.11,137 98.17,136.93 98.17,135.66 98.11,135.6 97.03,135.6 96.9,135.47 96.9,134.39 96.84,134.33 96.65,134.33 96.58,134.39 96.58,138.27
GND on TOP: 34.62,33.01 34.62,30.61 34.92,30.3 37.35,30.3 37.48,30.43 37.48,32.77 37.1,33.15 34.76,33.15
GND on TOP: 120.33,106.75 120.52,106.75 120.64,106.62 120.64,106.43 120.26,106.05 120.26,105.42 120.14,105.29 119.88,105.29 119.82,105.35 119.82,106.1 119.44,106.47 119.44,106.66 119.56,106.77 119.75,106.77 119.91,106.61 120.18,106.61
GND on TOP: 67.63,36.48 67.63,38.7 67.75,38.83 71.06,38.83 71.31,38.57 71.31,36.54 71.06,36.29 67.82,36.29
GND on TOP: 122.2,105.23 122.29,105.32 122.37,105.32 122.43,105.37 122.43,106.46 122.34,106.55 122.31,106.55 122.12,106.73 121.98,106.73 121.74,106.98 121.74,107.03 121.73,107.04 121.7,107.18 121.73,107.33 121.74,107.34 121.74,108.33 121.73,108.34 121.7,108.48 121.73,108.63 121.74,108.64 121.74,109.63 121.73,109.64 121.7,109.78 121.73,109.93 121.74,109.94 121.74,110.93 121.73,110.94 121.7,111.09 121.73,111.23 121.74,111.24 121.74,111.5 121.61,111.62 121.61,111.76 121.43,111.95 121.14,111.95 121.03,111.83 121.03,111.56 121.08,111.41 121.03,111.27 121.03,110.91 121.08,110.76 121.03,110.62 121.03,110.26 121.08,110.11 121.03,109.97 121.03,109.61 121.08,109.46 121.03,109.31 121.03,109.21 120.69,108.87 120.69,108.12 120.82,107.99 120.88,107.99 121.03,107.84 121.03,107.66 121.08,107.51 121.03,107.36 121.03,107.01 121.08,106.86 121.03,106.71 121.03,106.37 121.11,106.21 121.09,106.04 121.07,106.01 121.36,105.72 121.36,105.32 121.45,105.23
GND on TOP: 121.82,106.66 121.82,106.4 122.17,106.05 122.17,105.42 122.3,105.29 122.55,105.29 122.61,105.35 122.61,106.06 123,106.45 123,106.64 122.86,106.78 122.71,106.78 122.51,106.58 122.31,106.58 122.11,106.78 121.95,106.78
GND on TOP: 117.98,106.75 118.17,106.75 118.3,106.62 118.3,106.43 117.91,106.05 117.91,105.42 117.79,105.29 117.53,105.29 117.47,105.35 117.47,106.07 117.1,106.45 117.1,106.64 117.23,106.78 117.4,106.78 117.58,106.61 117.83,106.61
GND on TOP: 75.44,150.65 77.41,150.65 77.6,150.46 77.6,150.14 77.72,150.01 78.3,150.01 78.49,149.82 78.49,149 78.93,148.55 82.61,148.55 82.93,148.24 82.93,147.22 82.8,147.09 82.42,147.09 82.23,146.9 82.23,146.24 82.21,146.22 81.71,146.22 81.66,146.27 81.66,147.86 81.53,147.98 78.8,147.98 77.09,149.7 75.44,149.7 75.31,149.82 75.31,150.52
GND on TOP: 114.71,106.4 114.77,106.34 114.81,106.26 114.82,106.25 115.04,106.03 115.04,105.53 115.25,105.32 115.53,105.32 115.77,105.56 115.77,106.19 115.83,106.25 115.84,106.27 115.88,106.34 115.95,106.4 115.98,106.42 115.98,106.61 115.84,106.75 115.57,106.75 115.51,106.68 115.45,106.64 115.26,106.62 115.11,106.73 115.06,106.78 114.83,106.78 114.71,106.65
GND on TOP: 80.9,144.17 81.09,143.98 81.09,141.95 80.96,141.82 80.64,141.82 80.52,141.95 80.52,143.54 80.45,143.6 79.82,143.6 79.63,143.41 78.42,143.41 78.3,143.54 78.3,144.05 78.42,144.17
GND on BOTTOM: 54.17,25.05 55.63,25.05 55.82,24.86 55.82,21.74 55.81,21.74 55.81,21.52 54.64,20.35 54.64,19.51 54.41,19.28 53.54,19.28 53.47,19.36 53.47,20.98 54.04,21.55 54.04,24.92
GND on BOTTOM: 93.03,132.36 96.58,132.36 97.09,132.87 97.79,132.87 98.3,132.36 98.3,130.77 98.17,130.65 97.73,130.65 97.47,130.39 97.47,129.25 97.85,128.87 99.95,128.87 100.97,129.89 100.97,131.41 101.79,132.23 102.67,132.23 102.92,132.49 104.39,132.49 104.65,132.23 106.43,132.23 106.74,131.92 106.74,131.03 106.49,130.77 105.6,130.77 105.47,130.65 105.47,129.12 105.79,128.81 107.82,128.81 110.24,131.22 113.35,131.22 115.63,133.5 115.63,135.85 115.95,136.17 123.63,136.17 124.84,134.97 124.84,132.74 125.22,132.36 126.62,132.36 127,131.98 127,128.55 126.49,128.04 124.27,128.04 123.13,129.19 121.09,129.19 120.78,129.5 120.78,130.33 120.52,130.58 118.11,130.58 117.67,130.14 117.67,126.77 116.9,126.01 106.81,126.01 106.32,125.53 103.63,125.53 103.15,126.01 99.72,126.01 99.09,125.38 95.89,125.38 95.25,126.01 91.47,126.01 90.91,125.45 88.67,125.45 88.11,126.01 80.39,126.01 79.95,126.46 79.95,128.81 80.77,129.63 91.88,129.63 92.39,130.14 92.39,131.73
GND on BOTTOM: 34.76,27.56 36.11,27.56 36.33,27.79 36.33,28.53 36.58,28.77 37.29,28.77 37.34,28.82 37.34,32.31 37.41,32.39 37.41,32.91 37.21,33.11 36.8,33.11 36.32,33.59 36.32,34.22 36.5,34.39 37.15,34.39 37.34,34.58 37.34,37.77 37.02,38.09 34.84,38.09 34.61,37.86 34.61,27.71
GND on BOTTOM: 40.8,110.55 40.8,101.34 40.89,101.25 41.27,101.25 41.37,101.34 41.37,110.55 41.31,110.61 40.86,110.61
GND on BOTTOM: 8.43,8.32 8.48,8.37 8.48,9.11 8.44,9.14 6.47,9.14 6.26,9.35 6.26,9.98 6.14,10.1 3.65,10.1 3.54,9.99 3.54,8.45 3.66,8.32
GND on BOTTOM: 43.47,38.37 45.26,38.37 46.08,37.56 46.08,35.54 46.24,35.37 48.09,35.37 48.41,35.05 48.41,30.25 48.86,29.81 48.86,25.67 48.69,25.5 48.69,24.83 48.92,24.6 49.9,24.6 49.91,24.62 50.34,24.62 50.48,24.48 50.48,22.46 50.32,22.29 49.62,22.29 49.23,22.68 48.46,22.68 48.27,22.88 48.27,24.13 47.64,24.77 45.95,24.77 45.22,25.49 45.22,28.56 45.24,28.58 45.24,32.86 43.01,35.08 43.01,37.91
GND on BOTTOM: 66.61,61.11 68.9,61.11 69.53,60.48 69.53,55.91 70.8,54.64 70.8,53.18 70.55,52.92 66.67,52.92 66.29,53.3 66.29,60.8
GND on BOTTOM: 36.67,110.49 36.67,102.42 36.73,102.36 37.18,102.36 37.24,102.42 37.24,110.49 37.18,110.55 36.73,110.55
GND on BOTTOM: 47.53,109.85 47.53,101.34 47.69,101.18 48.45,101.18 48.51,101.25 48.51,102.1 48.1,102.52 48.1,109.85 48.04,109.91 47.59,109.91
GND on BOTTOM: 59.31,137 59.75,137 60.01,136.74 60.01,129.57 59.82,129.38 58.8,129.38 58.67,129.5 58.67,132.49 59.18,133 59.18,136.87
GND on BOTTOM: 32.51,110.52 32.51,102.45 32.58,102.39 33.02,102.39 33.08,102.45 33.08,110.52 33.02,110.58 32.58,110.58
GND on BOTTOM: 121.73,104.74 122.3,104.74 122.43,104.61 122.43,93.75 122.3,93.63 121.54,93.63 121.28,93.88 121.28,101.82 121.09,102.01 121.09,102.26 121.22,102.39 121.48,102.39 121.6,102.52 121.6,103.53 121.48,103.66 121.22,103.66 121.09,103.79 121.09,104.04 121.22,104.17 121.54,104.17 121.67,104.29 121.67,104.68
GND on BOTTOM: 21.47,12.48 21.4,12.55 19.18,12.55 18.97,12.34 18.97,6.35 19.23,6.1 20.9,6.1 21.47,6.66
GND on BOTTOM: 109.86,104.74 110.43,104.74 110.55,104.61 110.55,100.61 110.36,100.42 110.36,95.28 110.55,95.09 110.55,94.07 110.43,93.94 109.92,93.94 109.41,94.45 109.41,99.34 109.66,99.6 109.66,100.42 109.6,100.48 109.35,100.48 109.28,100.55 109.28,100.93 109.35,100.99 109.66,100.99 109.86,101.18 109.86,101.95 109.79,102.01 109.35,102.01 109.28,102.07 109.28,102.39 109.35,102.45 109.66,102.45 109.86,102.64 109.86,103.53 109.73,103.66 109.28,103.66 109.22,103.72 109.22,104.04 109.35,104.17 109.66,104.17 109.79,104.29 109.79,104.68
GND on BOTTOM: 66.87,107.85 67.63,107.85 67.75,107.72 67.75,105.5 67.63,105.37 66.8,105.37 66.67,105.5 66.67,107.66
GND on BOTTOM: 106.3,93.88 106.68,94.26 106.68,100.42 106.81,100.55 107,100.55 107.12,100.68 107.12,100.93 107,101.06 106.68,101.06 106.49,101.25 106.49,101.88 106.68,102.07 107,102.07 107.06,102.14 107.06,102.45 107,102.52 106.62,102.52 106.49,102.64 106.49,103.6 106.55,103.66 107,103.66 107.06,103.72 107.06,104.04 107,104.1 106.62,104.1 106.55,104.17 106.55,104.68 106.49,104.74 105.79,104.74 105.73,104.68 105.73,99.6 105.6,99.47 105.6,96.1 105.35,95.85 105.35,94.07 105.54,93.88
GND on BOTTOM: 20.87,15.33 20.75,15.45 20.75,16.13 21.03,16.41 29.27,16.41 30.04,17.17 30.04,26.27 30.66,26.89 36.58,26.89 36.7,26.76 36.7,25.94 36.64,25.87 35.43,25.87 35.4,25.9 31.39,25.9 31.15,25.67 31.15,24.87 31.24,24.78 31.87,24.78 31.95,24.71 31.95,23 31.78,22.83 31.78,22.83 31.24,22.29 31.24,16.47 30.1,15.33
GND on BOTTOM: 35.27,110.49 35.27,102.42 35.34,102.36 35.78,102.36 35.85,102.42 35.85,110.49 35.78,110.55 35.34,110.55
GND on BOTTOM: 120.08,93.12 122.81,93.12 123.38,92.55 129.35,92.55 129.62,92.81 136.6,92.81 136.83,92.59 136.83,91.34 136.58,91.09 120.9,91.09 120.14,91.85 115.44,91.85 114.68,92.61 114.68,93.12 114.74,93.18 120.02,93.18
GND on BOTTOM: 48.8,109.85 48.8,102.52 48.86,102.45 49.31,102.45 49.37,102.52 49.37,109.85 49.31,109.91 48.86,109.91
GND on BOTTOM: 33.94,110.49 33.94,102.42 34,102.36 34.45,102.36 34.51,102.42 34.51,110.49 34.45,110.55 34,110.55
GND on BOTTOM: 49.78,57.37 53.28,57.37 53.53,57.11 53.53,54.64 53.34,54.45 49.85,54.45 49.66,54.64 49.66,57.24
GND on BOTTOM: 38.07,110.49 38.07,101.28 38.1,101.25 38.54,101.25 38.64,101.34 38.64,110.49 38.58,110.55 38.13,110.55
GND on BOTTOM: 111.32,104.99 112.01,104.99 112.14,104.87 112.14,104.17 112.27,104.04 112.65,104.04 112.78,103.91 112.78,103.72 112.65,103.6 112.27,103.6 112.14,103.47 112.14,102.39 112.27,102.26 112.59,102.26 112.71,102.14 112.71,101.88 112.59,101.75 112.27,101.75 112.14,101.63 112.14,100.8 112.2,100.74 112.65,100.74 112.78,100.61 112.78,100.42 112.65,100.29 112.52,100.29 112.46,100.23 112.46,95.15 112.14,94.83 112.14,94.01 111.95,93.82 111.44,93.82 111.12,94.13 111.12,104.8
GND on BOTTOM: 74.04,31.78 76.2,31.78 76.45,31.52 76.45,29.24 76.71,28.98 76.71,27.71 75.82,26.82 72.64,26.82 72.01,27.46 72.01,30.63 72.39,31.02 73.66,31.02 73.91,31.27 73.91,31.65
GND on BOTTOM: 124.69,125.15 127.05,125.15 127.3,124.89 127.3,118.49 127,118.19 125.22,118.19 124.61,118.8 124.61,121.69 122.99,123.32 122.99,123.98 123.09,124.08 124.23,124.08 124.59,124.44 124.59,125.05
GND on BOTTOM: 65.06,78.06 70.13,78.06 70.64,77.55 71.72,77.55 71.81,77.46 71.81,76.88 71.77,76.84 65.02,76.84 64.85,77.02 64.85,77.84
GND on BOTTOM: 126.68,104.29 129.35,104.29 129.48,104.17 129.48,95.34 128.71,95.34 128.59,95.47 128.59,96.23 128.65,96.29 128.65,98.07 127.7,99.02 126.49,99.02 126.36,99.15 126.36,103.98
GND on BOTTOM: 134.8,104.68 133.84,104.68 133.65,104.49 133.65,98.6 133.79,98.45 134.75,98.45 134.94,98.64 134.94,104.53
GND on BOTTOM: 60.01,27.71 61.79,27.71 61.91,27.59 61.91,25.68 61.79,25.55 60.45,25.55 60.26,25.36 60.26,24.73 60.2,24.67 59.63,24.67 59.56,24.73 59.56,26.63 59.88,26.95 59.88,27.59
GND on BOTTOM: 25.98,10.76 28.51,10.76 28.77,10.51 28.77,1.62 28.51,1.36 24.26,1.36 24,1.62 24,7.99 22.77,9.22 22.77,11.61 22.54,11.84 22.54,12.28 22.67,12.41 24.33,12.41
GND on BOTTOM: 79.15,146.87 79.25,146.97 79.25,147.67 79.31,147.73 84.52,147.73 84.77,147.47 84.77,137.51 84.52,137.25 74.68,137.25 74.3,137.63 74.3,140.59 74.7,140.59 74.83,140.72 74.83,141.28 74.63,141.48 74.3,141.48 74.3,145.24 74.5,145.24 74.83,145.57 74.83,145.75 74.8,145.77 74.8,146.18 74.75,146.23 74.32,146.23 74.3,146.26 74.3,146.52 74.23,146.59 74.23,146.78 74.32,146.87
GND on BOTTOM: 126.56,97.63 127.57,97.63 127.76,97.44 127.76,96.23 127.64,96.1 126.49,96.1 126.3,96.29 126.3,97.37
GND on BOTTOM: 44.8,109.85 44.8,101.28 44.83,101.25 45.28,101.25 45.37,101.34 45.37,109.85 45.31,109.91 44.86,109.91
GND on BOTTOM: 46.2,109.85 46.2,102.55 46.29,102.45 46.7,102.45 46.77,102.52 46.77,109.85 46.7,109.91 46.26,109.91
GND on BOTTOM: 50.26,109.85 50.26,102.2 50.16,102.1 50.16,96.48 48.83,95.15 48.83,92.37 49.15,92.05 49.15,90.57 49.21,90.52 51.82,90.52 52.13,90.83 52.13,102.71 51.56,103.28 51.56,103.66 51.44,103.79 51.21,103.79 50.83,104.17 50.83,109.85 50.77,109.91 50.32,109.91
GND on BOTTOM: 45.02,13.03 45.02,11.51 45.1,11.43 46.23,11.43 46.69,10.97 46.69,8.49 45.47,7.27 45.47,7.03 44.41,5.97 44.41,5.86 45.11,5.16 46.28,5.16 46.48,5.36 46.96,5.36 47.17,5.16 47.17,4.37 47.27,4.27 49.07,4.27 49.49,4.69 50.34,4.69 50.77,5.12 50.77,8.23 49.94,9.07 49.94,11.05 48.86,12.13 48.86,13 48.76,13.1 45.09,13.1
GND on BOTTOM: 41.81,54.45 38.32,54.45 38.07,54.7 38.07,57.18 38.26,57.37 41.75,57.37 41.94,57.18 41.94,54.57
GND on BOTTOM: 117.47,104.74 118.11,104.74 118.17,104.68 118.17,104.23 118.3,104.1 118.62,104.1 118.75,103.98 118.75,103.72 118.62,103.6 118.3,103.6 118.17,103.47 118.17,102.71 118.3,102.58 118.68,102.58 118.75,102.52 118.75,102.14 118.68,102.07 118.3,102.07 118.24,102.01 118.24,101.31 118.3,101.25 118.62,101.25 118.75,101.12 118.75,100.93 118.49,100.68 118.49,93.75 118.36,93.63 117.47,93.63 117.35,93.75 117.35,94.64 117.41,94.71 117.41,104.68
GND on BOTTOM: 7.15,24 9.58,24 9.78,24.2 9.78,29.71 9.68,29.82 7.17,29.82 6.93,29.58 6.93,24.22
GND on BOTTOM: 140.66,130.64 145.63,130.64 145.69,130.58 145.69,129.82 145.62,129.75 145.04,129.75 145,129.71 145,128.85 145.08,128.77 146.72,128.77 146.75,128.75 146.75,128.16 146.72,128.13 145.95,128.13 145.88,128.06 145.88,125.42 145.69,125.23 141.21,125.23 141.14,125.16 141.14,124.32 141.08,124.26 140.5,124.26 140.46,124.29 140.46,130.44
GND on BOTTOM: 116.62,93.85 116.52,93.75 115.7,93.75 115.47,93.98 115.47,99.41 115.49,99.42 115.49,100.47 115.35,100.61 115.35,100.99 115.41,101.06 115.73,101.06 115.92,101.25 115.92,102.01 115.86,102.07 115.41,102.07 115.35,102.14 115.35,102.45 115.41,102.52 115.73,102.52 115.92,102.71 115.92,103.6 115.79,103.72 115.35,103.72 115.28,103.79 115.28,104.1 115.41,104.23 115.73,104.23 115.86,104.36 115.86,104.74 115.87,104.76 115.87,104.91 115.95,104.99 116.65,104.99 116.78,104.87 116.78,103.47 116.62,103.31
GND on BOTTOM: 30.29,111.47 32.45,111.47 32.51,111.41 32.51,111.09 32.45,111.03 31.62,111.03 31.43,110.84 31.43,101.88 31.37,101.82 31.05,101.82 30.99,101.88 30.99,102.96 30.73,103.22 30.73,104.1 30.99,104.36 30.99,110.71 30.8,110.9 30.35,110.9 30.23,111.03 30.23,111.41
GND on BOTTOM: 29.24,57.37 32.73,57.37 32.99,57.11 32.99,54.64 32.8,54.45 29.31,54.45 29.11,54.64 29.11,57.24
GND on BOTTOM: 121.62,54.72 123.64,54.72 123.98,54.38 123.98,50.24 123.65,49.91 121.6,49.91 121.49,49.8 121.49,49.02 121.68,48.83 124.61,48.83 125.55,49.77 125.55,55.32 124.64,56.23 121.7,56.23 121.46,55.99 121.46,54.88
GND on BOTTOM: 102.7,139.35 108.03,139.35 108.21,139.54 108.21,140.71 108.03,140.89 102.65,140.89 102.39,140.64 101.71,140.64 101.66,140.59 101.66,140.37 101.67,140.37 101.67,140.2 101.39,139.92 101.39,139.22 101.42,139.19 102.54,139.19
GND on BOTTOM: 55.05,115.22 55.05,114.33 55.44,113.95 63.82,113.95 64.01,114.14 64.01,115.85 63.69,116.17 56.01,116.17
GND on BOTTOM: 11.94,56.08 4.8,56.08 4.47,55.75 4.47,52.15 4.88,51.73 11.68,51.73 12.57,52.62 12.57,55.46
GND on BOTTOM: 42.07,110.49 42.07,101.28 42.1,101.25 42.55,101.25 42.64,101.34 42.64,110.49 42.58,110.55 42.13,110.55
GND on BOTTOM: 39.47,109.28 39.47,101.22 39.53,101.15 39.97,101.15 40.04,101.22 40.04,109.28 39.97,109.34 39.53,109.34
GND on BOTTOM: 113.28,100.17 114.05,100.17 114.17,100.04 114.17,96.67 114.05,96.55 113.28,96.55 113.16,96.67 113.16,100.04
GND on BOTTOM: 12.71,12.43 12.71,6.62 12.83,6.5 14.35,6.5 15.04,7.19 15.04,8.69 15.12,8.77 15.12,12.48 15.05,12.55 12.83,12.55
GND on BOTTOM: 148.21,74.39 151.64,74.39 151.76,74.26 151.76,72.1 151.45,71.78 148.08,71.78 147.96,71.91 147.96,74.13
GND on BOTTOM: 29.91,97.56 30.23,97.56 31.05,96.74 31.05,91.4 31.04,91.39 31.04,91.16 31.14,91.06 32.48,91.06 32.55,90.99 32.55,90.64 32.49,90.58 29.97,90.58 29.84,90.71 29.84,97.5
GND on BOTTOM: 81.18,84.64 78.77,84.64 78.59,84.46 78.59,80.7 78.99,80.29 80.67,80.29 81.38,81 81.38,84.43
GND on BOTTOM: 43.4,109.28 43.4,101.22 43.47,101.15 43.91,101.15 43.97,101.22 43.97,109.28 43.91,109.34 43.47,109.34
GND on BOTTOM: 56.32,38.52 56.02,38.81 50.03,38.81 49.77,38.56 44.23,38.56 44.22,38.55 32.35,38.55 32.25,38.65 32.25,39.39 32.42,39.56 37.38,39.56 37.66,39.84 39.33,39.84 39.69,39.49 44.55,39.49 44.92,39.86 51.79,39.86 51.96,40.02 53.7,40.02 53.78,39.93 59.75,39.93 59.86,40.03 61.65,40.03 61.93,39.75 66.73,39.75 66.83,39.65 72.95,39.65 73.16,39.44 75.95,39.44 76.01,39.37 76.01,37.56 75.18,36.73 75.18,36.22 74.8,35.84 66.84,35.84 66.45,36.24 66.45,38.08 66.01,38.52
GND on BOTTOM: 124.46,97.63 125.54,97.63 125.67,97.5 125.67,96.17 125.54,96.04 124.33,96.04 124.27,96.1 124.27,97.44
GND on GND1: outline of 128 points within 0.2,0.2 152.8,156.8
GND on IN1: 45.53,8.5 50.67,8.5 50.98,8.19 50.98,3.84 50.77,3.63 46.52,3.63 45.34,4.82 45.34,8.31
GND on IN1: outline of 106 points within 0.2,86.57 57.47,145.8
GND on IN1: 132.54,55.15 139.08,55.15 139.32,54.9 139.32,48.44 137.99,47.11 135.12,47.11 135.09,47.13 133.16,47.13 131.74,48.55 131.74,53.23 132.33,53.83 132.33,54.63 132.32,54.64 132.32,54.93
GND on IN1: 33.73,88.43 34.51,88.43 35.18,87.76 35.18,81.73 44.02,72.89 44.02,72.02 45.96,70.08 45.96,62.79 45.26,62.09 41.03,62.09 40.23,62.89 40.23,75.22 39.36,76.1 36.83,76.1 33.63,79.3 33.63,88.33
GND on GND2: outline of 139 points within 0.2,0.2 152.8,156.8
GND on IN2: 139.32,48.91 139.32,48.44 137.99,47.11 135.12,47.11 135.09,47.13 133.16,47.13 131.74,48.55 131.74,53.23 132.33,53.83 132.33,54.63 132.55,54.84 135.23,54.84 137.96,52.11 137.96,50.27
GND on IN2: 45.96,24.86 45.69,25.12 45.69,25.73 45.49,25.94 44.98,25.94 44.81,26.11 44.81,29.38 45.83,30.41 45.83,31.22 45.55,31.5 44.95,31.5 44.75,31.69 44.75,33.82 43.33,35.25 43.33,38.22 43.5,38.38 45.83,38.38 46.15,38.06 46.15,36.62 47.56,35.21 47.56,31.17 48.86,29.87 48.86,25.14 48.58,24.86
GND on IN2: 34.84,28.77 37.06,28.77 37.41,29.12 37.41,37.86 37.15,38.13 34.86,38.13 34.57,37.84 34.57,29.07 34.84,28.81
GND on IN2: 45.53,8.5 50.67,8.5 50.98,8.19 50.98,3.42 50.79,3.23 46.34,3.23 45.34,4.23 45.34,8.31
GND on IN2: outline of 126 points within 0.2,70.56 58.29,145.8 ; 1 cut-out
GND on GND3: outline of 137 points within 0.2,0.2 152.8,156.8
GND on VCC: 27,147.73 27,156.5 27.09,156.71 27.3,156.8 31.55,156.8 31.75,156.72 32.07,156.08 32.55,155.89 57.55,155.89 58.03,156.08 58.35,156.72 58.55,156.8 62.4,156.8 62.61,156.71 62.7,156.5 62.7,152.5 62.77,152.18 62.99,151.93 62.99,149.1 61.62,147.73
GND on VCC: 0.5,0.2 0.29,0.29 0.2,0.5 0.2,7.46 11.05,7.46 11.06,7.45 11.3,7.45 11.86,6.89 11.87,6.89 19.3,6.89 20.26,7.84 50.61,7.84 54.17,4.28 69.68,4.28 69.75,4.35 79.18,4.35 79.18,3.84 79.2,3.84 79.2,0.2
GND on VCC: 109.33,145.19 109.18,145.34 109.18,147.9 108.08,149 102.23,149 100.14,151.09 94.42,151.09 94.23,150.9 94.23,149.25 92.33,149.25 91.31,150.27 85.32,150.27 84.2,151.39 84.2,156.8 143.8,156.8 144.01,156.71 144.1,156.5 144.1,151.4 144.01,151.19 143.8,151.1 142.89,151.1 141.39,149.6 142.89,148.1 143.8,148.1 144.01,148.01 144.1,147.8 144.1,147 144.3,146.5 144.8,146.3 152.5,146.3 152.68,146.23 152.79,146.08 140.99,146.08 140.1,145.19
GND on GND4: outline of 89 points within 0.2,0.2 152.8,156.8
GND on GND5: outline of 128 points within 0.2,0.2 152.8,156.8
VCC_CORE_PH1 on TOP: 88.65,128.74 89.22,128.74 89.28,128.68 89.28,123.12 89.13,122.96 86.87,122.96 86.74,123.09 86.74,123.85 86.68,123.92 85.92,123.92 85.85,123.85 85.85,123.09 85.72,122.96 84.52,122.96 84.45,123.03 84.45,127.03 84.65,127.22 88.39,127.22 88.52,127.35 88.52,128.62
VCC_CORE_PH1 on BOTTOM: 88.46,123.34 88.33,123.47 88.33,124.23 89.2,125.11 90.78,125.11 90.92,124.97 90.92,123.57 90.69,123.34
VCC_CORE_PH2 on TOP: 96.14,128.87 96.71,128.87 96.8,128.78 96.8,123.24 96.58,123.03 92.2,123.03 92.01,123.22 92.01,127.09 92.2,127.28 95.76,127.28 96.01,127.54 96.01,128.74
VCC_CORE_PH2 on BOTTOM: 96.38,123.5 96.32,123.44 94.39,123.44 94.32,123.51 94.32,125.1 94.45,125.22 95.97,125.22 96.38,124.82
VCC_CORE_PH3 on TOP: 104.74,128.87 105.31,128.87 105.42,128.76 105.42,123.26 105.19,123.03 100.81,123.03 100.79,123.04 100.19,123.04 99.89,123.34 99.89,126.58 100.58,127.28 104.36,127.28 104.62,127.54 104.62,128.74
VCC_CORE_PH3 on BOTTOM: 104.11,124.49 104.11,123.6 103.81,123.29 102.45,123.29 102.21,123.54 102.21,125 102.35,125.14 103.47,125.14
VCC_CORE_PH4 on TOP: 113.06,128.93 113.63,128.93 113.82,128.74 113.82,123.41 113.51,123.09 107.82,123.09 107.7,123.22 107.7,126.57 108.47,127.35 112.68,127.35 112.93,127.6 112.93,128.81
VCC_CORE_PH4 on BOTTOM: 111.94,124.51 111.94,123.27 111.62,122.95 110.11,122.95 109.96,123.1 109.96,124.67 110.16,124.87 111.58,124.87
VCC_CORE_PH5 on TOP: 124.78,128.01 124.78,127.44 124.59,127.25 120.52,127.25 120.33,127.43 120.33,131.09 119.82,131.6 116.65,131.6 116.46,131.79 116.46,133.82 116.65,134.01 122.81,134.01 123.19,133.63 123.19,128.39 123.44,128.14 124.65,128.14
VCC_CORE_PH5 on BOTTOM: 123.3,128.96 123.44,128.82 123.44,127.22 123.33,127.1 121.97,127.1 121.54,127.54 121.54,128.51 121.98,128.96
VCC_CORE_PH6 on TOP: 120.59,122.9 124.02,122.9 124.84,122.07 124.84,118.33 125.16,118.01 126.24,118.01 126.3,117.95 126.3,117.25 126.24,117.19 122.24,117.19 120.27,119.15 120.27,122.58
VDD_1.2V on TOP (solid shape): 149.26,46.12 150.98,46.12 151.1,45.99 151.1,44.4 150.98,44.27 149.8,44.27 149.01,45.06 149.01,45.35 148.12,46.24 148.12,46.5 148.18,46.56 148.82,46.56
VDDP_1.2V on TOP (solid shape): 151.35,41.29 151.35,38.98 150.96,38.6 149.3,38.6 149.05,38.85 149.05,40.73 149.13,40.81 149.27,40.9 149.36,41.05 149.38,41.06 149.38,41.29 149.5,41.42 151.22,41.42
+FBX_PLLAVDD on BOTTOM: 50.97,110.71 50.97,111.81 50.86,111.91 50.23,111.91 50.1,111.79 50.1,111.68 49.84,111.42 46.5,111.42 46.13,111.79 45.47,111.79 45.34,111.66 45.34,111.15 45.47,111.03 45.91,111.03 46.26,110.68 46.26,110.58 46.37,110.47 50.74,110.47
+HDMI_5V_OUT on BOTTOM (solid shape): 136.21,151.41 136.21,149.32 136.9,148.63 136.9,146.93 136.72,146.75 135.99,146.75 135.86,146.88 135.86,147.57 135.51,147.92 130.11,147.92 129.83,148.2 129.83,150.61 133.83,150.61 133.83,150.56 133.83,150.51 133.85,150.46 133.87,150.41 133.9,150.37 133.94,150.33 133.98,150.3 134.03,150.28 134.08,150.26 134.13,150.26 134.18,150.26 134.23,150.26 134.28,150.28 134.33,150.3 134.37,150.33 134.41,150.37 134.44,150.41 134.46,150.46 134.48,150.51 134.48,150.56 134.48,150.61 134.48,150.66 134.46,150.71 134.44,150.76 134.41,150.8 134.37,150.84 134.33,150.87 134.28,150.89 134.23,150.91 134.18,150.92 134.13,150.92 134.08,150.91 134.03,150.89 133.98,150.87 133.94,150.84 133.9,150.8 133.87,150.76 133.85,150.71 133.83,150.66 133.83,150.61 129.83,150.61 129.83,151.69 129.87,151.73 130.56,151.73 130.66,151.63 130.66,151.41 130.76,151.32 133.19,151.32 133.72,151.84 135.78,151.84
+IFPCD_PLLVDD on BOTTOM: 58.86,98.01 58.55,98.33 55.44,98.33 53.15,96.04 53.15,95.6 53.28,95.47 54.17,95.47 55.82,97.12 57.91,97.12 57.98,97.06 57.98,96.73 58.22,96.48 58.74,96.48 58.86,96.61
+IFPE_PLLVDD on BOTTOM: 53.45,94.63 55.42,94.63 55.69,94.9 58.67,94.9 58.86,94.71 58.86,93.74 58.25,93.12 53.47,93.12 53.34,93.25 53.34,94.52
+INV_PWR_LCD on TOP: 28.51,144.36 32.3,144.36 32.54,144.12 32.54,142.8 30.92,141.19 27.62,141.19 27.43,141.38 27.43,142.18 27.2,142.41 27.2,143.06
+INV_PWR_LCD on TOP: 37.08,153.32 37.21,153.19 37.21,152.17 37.08,152.05 34.92,152.05 34.8,152.17 34.8,153.19 34.92,153.32
+INV_PWR_LCD on BOTTOM: 35.94,151.56 35.94,150.9 36.07,150.78 37.34,150.78 37.47,150.9 37.47,153.06 37.21,153.32 36.2,153.32 36.18,153.3 35.51,153.3 35.29,153.09 35.29,152.21
+INV_PWR_LCD on IN3: 35.31,153.25 37.21,153.25 37.59,152.87 37.59,149.06 33.59,145.06 33.59,143.03 32.58,142.01 30.54,142.01 30.16,142.39 30.16,145.06 34.8,149.7 34.8,152.75
+INV_PWR_SRC on TOP: 33.97,144.43 35.18,144.43 35.5,144.11 35.5,143.09 35.69,142.9 39.62,142.9 39.75,142.78 39.75,142.01 40.01,141.76 40.7,141.76 40.83,141.63 40.83,140.74 40.64,140.55 33.91,140.55 33.53,140.93 33.53,143.98
+LCDVDD on TOP: 22.28,135.27 22.09,135.08 20.31,135.08 20.12,135.27 20.12,138.46 20.76,139.11 21.89,139.11 22.28,138.72
+LCDVDD on BOTTOM: 29.48,143.16 30.8,143.16 31.1,142.85 31.1,141.58 31.01,141.49 30.52,141.49 30.21,141.18 30.21,140.6 29.88,140.27 29.88,138.62 29.4,138.14 28.42,138.14 27.83,138.74 27.83,139.4 27.67,139.55 27.05,139.55 26.87,139.73 26.87,140.73 27.52,141.38 28.89,141.38 29.21,141.7 29.21,142.89
+LCDVDD on BOTTOM: 38.1,150.9 38.23,150.78 39.24,150.78 39.37,150.9 39.37,153.06 39.12,153.32 38.35,153.32 38.1,153.06
+LCDVDD on IN2: 29.08,139.6 29.08,142.71 29.84,143.47 29.84,144.62 29.65,144.81 28.51,144.81 28.32,144.62 28.32,143.92 24.51,140.11 20.07,140.11 19.75,139.79 19.75,137.7 19.94,137.51 23.37,137.51 24.67,138.81 28.29,138.81
+LCDVDD on IN2: 37.59,153.32 39.12,153.32 39.24,153.19 39.24,151.16 38.48,150.4 37.21,150.4 36.96,150.65 36.96,151.67 37.47,152.17 37.47,153.19
+NVVDD on TOP (solid shape): 74.42,86.69 74.42,84.61 74.3,84.48 73.53,84.48 73.47,84.42 73.43,84.42 73.43,83.66 73.47,83.66 73.53,83.59 74.36,83.59 74.42,83.53 74.42,82.26 74.1,81.94 71.5,81.94 71.37,82.07 71.37,85.31 71.18,85.5 70.74,85.5 70.61,85.63 70.61,86.58 70.93,86.9 74.22,86.9
+NVVDD on BOTTOM (solid shape): 74.93,86.01 74.93,81.56 74.68,81.31 71.88,81.31 71.37,81.82 71.37,86.82 71.58,87.02 73.91,87.02
+NVVDD on TOP: 30.81,91.11 31.12,90.8 51.36,90.8 51.61,91.05 51.61,107.77 59.82,115.98 59.82,119.22 59.9,119.3 52.93,119.3 52.93,117.29 46.84,111.19 31.22,111.19 30.81,110.78
+NVVDD on TOP: 51.56,52.54 51.12,52.99 51.12,54.7 50.99,54.83 50.36,54.83 50.16,54.64 50.16,53.18 49.78,52.8 43.56,52.8 43.43,52.92 43.43,54.64 43.24,54.83 42.48,54.83 42.35,54.7 42.35,52.8 42.29,52.73 35.94,52.73 35.75,52.92 35.75,54.7 35.62,54.83 34.86,54.83 34.86,52.64 34.79,52.57 28.57,52.57 28.27,52.87 28.27,54.54 28.08,54.73 28.08,55.86 28,55.93 27.38,55.93 27.29,55.84 27.29,52.78 27.09,52.58 24.31,52.58 23.04,53.85 23.04,56.66 24.77,58.38 24.77,61.43 25.3,61.97 60.99,61.97 61.47,62.46 64.36,62.46 67.61,59.21 73.85,59.21 75.88,57.18 75.88,54.83 73.53,54.83 73.53,53.24 73.28,52.99 66.74,52.99 66.61,53.11 66.61,54.7 66.48,54.83 65.72,54.83 65.6,54.7 65.6,53.3 65.34,53.05 60.87,53.05 60.48,52.66 58.98,52.66 58.71,52.92 58.71,55.84 57.9,55.84 57.9,54.75 57.53,54.38 57.53,52.73 57.34,52.54
+NVVDD on BOTTOM: 51.8,88.26 63.93,76.14 63.93,64.8 65.02,63.7 65.02,53.11 64.45,52.54 24.26,52.54 23.75,53.05 23.75,53.11 23.24,53.62 23.24,56.67 25.04,58.47 25.68,58.47 28.14,60.94 28.14,65.2 27.37,65.98 27.37,87.21 30.06,89.91 32.67,89.91 32.62,89.96 32.62,91.24 31.42,91.24 31.24,91.42 31.24,96.74 30.16,97.82 30.16,101.12 30.42,101.37 31.18,101.37 31.62,101.82 31.62,110.64 31.94,110.96 32.58,110.96 32.89,111.28 44.45,111.28 45.4,110.33 49.72,110.33 50.23,109.82 50.23,102.33 49.85,101.95 49.85,96.61 48.7,95.47 48.7,92.37 49.11,91.96 49.11,89.88 49.16,89.83 50.24,89.83
+NVVDD on IN1: 50.88,92 50.88,91.77 49.98,90.88 31.81,90.88 31.13,91.55 31.13,109.66 32.52,111.05 46.8,111.05 52.04,116.28 52.87,116.28 53.26,116.67 53.26,116.79 53.31,116.84 53.43,116.84 53.96,117.37 53.96,117.49 54.01,117.54 54.13,117.54 54.56,117.97 54.56,118.78 55.19,119.4 59.19,119.4 60.46,118.13 60.46,113.08 58.52,111.14 55.04,111.14 50.74,106.83 50.74,101.06 52.68,99.11 59.84,99.11 61.26,97.69 61.34,97.69 63.56,95.47 64.52,95.47 64.83,95.15 65.02,95.15 65.09,95.21 65.53,95.21 70.55,90.2 71.07,90.2 74.61,86.65 74.61,81.98 74.5,81.87 69.95,81.87 69.62,82.2 69.62,87.12 63.25,93.5 52.37,93.5 ; 1 cut-out
+NVVDD on IN2: 74.87,86.07 74.87,82.64 73.9,81.68 70.7,81.68 69.98,82.4 66.85,82.4 66.13,81.68 56.73,81.68 47.31,91.1 31.95,91.1 31.37,91.68 31.37,110.14 32.26,111.03 46.74,111.03 50.04,114.33 53.04,114.33 56.97,118.26 59.18,118.26 59.63,117.82 59.63,114.84 53.43,108.64 51.97,108.64 51.12,107.79 51.12,97.18 52.2,96.1 58.03,96.1 66.47,87.66 73.24,87.66 74.83,86.07
+NVVDD on VCC: 24.87,52.73 23.3,54.3 23.3,62.09 24.21,62.99 24.21,70.67 22.35,72.52 22.35,118.67 23.22,119.53 58.31,119.53 59.44,118.41 59.44,115.45 51.18,107.19 51.18,92.34 49.53,90.68 49.53,88.19 50.44,87.28 72.67,87.28 74.3,85.65 74.3,52.73 ; 3 cut-outs
+NVVDD on IN3: 65.98,62.77 65.98,53.81 64.8,52.63 24.1,52.63 23.11,53.62 23.11,59.39 23.3,59.58 23.3,61.78 23.88,62.35 23.88,71.22 22.48,72.62 22.48,118.39 24.13,120.04 57.66,120.04 60.39,117.31 60.39,91.98 59.56,91.15 59.56,69.18 ; 3 cut-outs
+PEX_VDD on TOP (solid shape): outline of 83 points within 51.76,105.35 53.57,107.87
+PEX_VDD on TOP: 51.76,93.21 51.75,93.23 51.74,93.26 51.74,98.61 51.86,98.73 52.84,98.73 53.04,98.52 53.04,93.31 52.94,93.21
+PEX_VDD on BOTTOM: 65.21,112.68 64.07,113.82 54.67,113.82 53.15,112.3 53.15,110.08 53.04,109.97 53.04,108.91 52.96,108.83 52.95,108.83 52.95,106.15 53.12,105.99 60.45,105.99 60.45,93.5 59.94,92.99 53.21,92.99 52.9,93.31 52.9,98.33 52.77,98.45 52.39,98.45 52.31,98.38 52.31,90.89 52.41,90.79 62.47,90.79 64.12,92.44 64.12,105.8 65.21,106.9
+PEX_VDD on IN2: 52.26,108.1 53.66,108.1 53.85,107.91 53.85,107.72 53.34,107.22 53.34,96.74 52.9,96.29 52.26,96.29 51.94,96.61 51.94,98.58 52.77,99.41 52.77,104.8 51.94,105.63 51.94,107.79
+RTC_CELL on TOP (solid shape): 119.02,27.59 119.02,26.87 118.87,26.72 117.05,26.72 117.05,26.72 116.57,26.72 116.47,26.82 116.47,27.51 116.57,27.61 116.66,27.61 117,27.52 117.23,27.78 118.83,27.78
+TBTA_VBUS on TOP: 100.01,148.17 100.97,148.17 101.09,148.05 101.09,145.89 101.6,145.38 101.6,144.74 101.35,144.49 100.08,144.49 99.79,144.78 99.79,146.11 100.2,146.52 100.2,147.35 99.95,147.6 99.95,148.11
+TBTA_VBUS on BOTTOM: 98.04,142.73 98.04,142.52 98.12,142.44 98.42,142.44 98.51,142.35 98.51,142.06 98.6,141.96 100.13,141.96 100.29,142.13 100.29,142.14 101.04,142.88 102.95,142.88 103.29,142.55 107.21,142.55 108.46,143.79 108.46,148.05 108.08,148.43 106.3,148.43 105.98,148.11 105.98,145.45 105.54,145 104.71,145 104.46,145.25 100.97,145.25 100.77,145.44 100.77,145.89 100.58,146.08 99.76,146.08 99.57,145.89 99.57,144.68 98.93,144.05 98.93,143.45 98.74,143.26 98.59,143.26 98.53,143.2 98.53,142.83 98.47,142.77 98.09,142.77
+TBTA_VBUS on IN2: 95.83,150.41 95.95,150.29 95.95,149.55 95.98,149.51 97.66,149.51 97.71,149.57 97.71,150.3 97.83,150.41 98.27,150.41 98.41,150.27 98.41,149.04 98.3,148.94 95.4,148.94 95.27,149.06 95.27,150.22 95.45,150.41
+TBTA_VBUS on VCC: 100.18,144.49 95.8,148.87 94.97,148.87 94.74,149.1 94.74,150.59 99.91,150.59 102,148.49 107.84,148.49 108.62,147.72 108.62,145.54 102.54,145.54 101.49,144.49
+TBTA_VBUS on IN3: 95.44,150.4 95.76,150.4 95.95,150.21 95.95,149.7 96.01,149.63 97.6,149.63 97.73,149.76 97.73,150.27 97.85,150.4 98.17,150.4 98.81,149.76 99.12,149.76 100.71,148.17 100.71,147.86 100.58,147.73 99.57,147.73 99,148.3 95.76,148.3 95.31,148.74 95.31,150.27
+TBTA_VBUS on GND5: 98.17,142.78 98.68,142.78 98.81,142.65 98.81,140.62 98.36,140.17 98.36,138.58 98.23,138.46 97.79,138.46 97.73,138.52 97.73,141.7 98.04,142.01 98.04,142.65
ADPS_ISL95338_1 on TOP: 56.01,37.62 57.71,37.62 57.91,37.42 57.91,36.1 57.78,35.97 56.13,35.97 55.88,36.22 55.88,37.49
BA on TOP: 22.23,9.87 24.13,9.87 24.7,9.3 24.7,8.18 25.08,8.18 25.88,7.38 25.88,6.62 25.45,6.19 24.19,6.19 23.94,6.44 23.94,7.27 22.03,9.17 22.03,9.68
BS2_1.0VS_VGAP on TOP (solid shape): 73.47,110.07 73.47,109.57 73.34,109.44 71.56,109.44 71.5,109.5 71.5,110.07 71.56,110.14 73.41,110.14
BS2_+1.8VGS on TOP: 49.23,11.62 51.27,11.62 51.32,11.57 51.32,10.94 51.31,10.92 49.16,10.92 49.1,10.99 49.1,11.5
BS_1.0VS_VGAP on TOP (solid shape): 73.53,109.18 73.53,108.04 73.47,107.98 72.52,107.98 72.39,108.1 72.39,109.18 72.52,109.31 73.41,109.31
BS_1.0VS_VGAP on BOTTOM (solid shape): 73.53,109.18 73.53,105.76 73.15,105.37 72.26,105.37 72.2,105.44 72.2,105.56 72.52,105.88 72.52,109.18 72.58,109.25 73.47,109.25
BS_+1.8VGS on TOP: 48.51,8.47 48.51,7.27 48.58,7.2 48.7,7.2 50.04,8.54 50.04,10.19 50,10.23 49.16,10.23 49.09,10.15 49.09,9.04
BST1_ISL95338_1 on BOTTOM (solid shape): 56.26,34.75 56.26,33.94 56.32,33.87 56.32,32.86 56.26,32.79 56.13,32.79 56.07,32.86 56.07,33.94 55.69,34.32 55.69,34.76 55.85,34.93 56.08,34.93
BST1_ISL95338_1 on TOP: 54.23,35.4 54.67,35.4 55.12,34.95 56.07,34.95 56.2,34.83 56.2,34.57 56.07,34.44 55.05,34.44 54.74,34.76 54.23,34.76 54.17,34.83 54.17,35.33
BST1_R_ISL95338_1 on TOP: 52.96,34.19 53.91,34.19 54.17,34.44 54.74,34.44 54.8,34.38 54.8,33.62 54.67,33.49 53.02,33.49 52.9,33.62 52.9,34.13
BST2_ISL95338_1_R on TOP: 54.99,29.75 54.86,29.62 54.42,29.62 54.29,29.75 54.29,30.25 54.3,30.26 54.3,31.77 54.47,31.94 55.14,31.94 55.28,31.81 55.28,30.97 54.99,30.69
BST8_NVVDD_R on TOP (solid shape): 71.22,76.19 71.22,75.53 71.15,75.45 70.31,75.45 70.27,75.49 70.27,75.68 69.98,75.97 68.83,75.97 68.77,76.04 68.77,76.72 68.85,76.8 70.61,76.8
BST_1.2V on TOP (solid shape): 151.57,52.54 151.57,50.95 151.45,50.83 150.75,50.83 150.23,51.35 150.23,52.56 150.34,52.67 151.45,52.67
BST_1.2V on TOP (solid shape): 147.07,50.7 147.07,49.58 147.1,49.55 147.1,48.47 147.04,48.4 146.91,48.4 146.85,48.47 146.85,49.42 146.46,49.81 146.46,50.74 146.53,50.82 146.95,50.82
BST_1.2V on BOTTOM (solid shape): 151.45,52.03 151.45,51.02 151.26,50.83 150.37,50.83 149.86,51.34 147.83,51.34 147.18,50.69 147.18,49.9 146.96,49.68 146.65,49.68 146.47,49.86 146.47,50.93 147.7,52.16 151.32,52.16
BST_1.2V_R on TOP (solid shape): 151.22,55.01 151.22,53.42 151.16,53.36 150.33,53.36 150.27,53.42 150.27,55.01 150.33,55.07 151.16,55.07
BST_1.35PH2_R on TOP: 16.92,39.03 16.34,39.03 16,38.69 15.14,38.69 15.02,38.57 15.02,37.84 15.33,37.53 16.57,37.53 17.04,38 17.04,38.9
BST_3V on TOP: 65.07,24.79 67.56,24.79 67.63,24.73 67.63,24.01 67.41,23.79 65.82,23.79 65.05,24.56 65.05,24.77
BST_3V_R on TOP: 66.61,23.43 68.44,23.43 68.57,23.31 68.57,22.79 68.53,22.75 66.65,22.75 66.56,22.84 66.56,23.38
BST_5V on TOP (solid shape): 57.02,22.38 57.02,21.11 56.9,20.98 56.45,20.98 56.32,21.11 56.32,22.57 56.39,22.63 56.77,22.63
BST_5V on BOTTOM (solid shape): 57.09,21.62 57.09,19.27 57.02,19.2 56.39,19.2 56.32,19.27 56.32,21.55 56.52,21.74 56.96,21.74
BST_5V_R on BOTTOM (solid shape): 58.58,20.13 58.58,18.28 58.45,18.16 57.56,18.16 57.5,18.22 57.5,20.19 57.56,20.25 58.45,20.25
BST_+1VALWP on TOP: 135.7,29.3 136.27,29.3 136.4,29.17 136.4,28.35 136.21,28.16 133.99,28.16 133.86,28.29 133.86,28.79 133.99,28.92 135.32,28.92
BST_+1VALWP_R on TOP: 133.86,31.71 134.68,31.71 134.81,31.59 134.81,31.07 134.58,30.84 134.58,30.48 134.81,30.25 134.81,29.75 134.75,29.68 133.86,29.68 133.55,29.99 133.55,31.41
BST_CHG on BOTTOM (solid shape): 42.42,20.22 43.31,20.22 43.69,19.84 43.69,19.01 43.62,18.95 42.86,18.95 41.4,20.41 40.01,20.41 39.94,20.47 39.94,21.05 40.07,21.17 41.47,21.17
BST_CHG_R on BOTTOM (solid shape): 40.83,22.44 40.83,21.74 40.77,21.68 39.05,21.68 38.99,21.74 38.99,22.44 39.05,22.51 40.77,22.51
BST_PH4 on TOP: 108.2,134.55 110.72,134.55 110.95,134.32 110.95,133.07 110.82,132.95 110.52,132.95 110.24,133.23 110.24,133.33 109.96,133.61 109.17,133.61 108.94,133.38 108.94,133.02 108.79,132.87 108.15,132.87 108.05,132.97 108.05,134.39
BST_PH4_R on TOP: 106.68,133.99 107.75,133.99 107.9,133.84 107.9,133.05 107.75,132.9 106.71,132.9 106.63,132.97 106.63,133.94
BST_PH4_R on BOTTOM: 107.77,133.96 107.92,133.81 107.92,132.95 107.8,132.82 106.71,132.82 106.65,132.87 106.65,133.91 106.71,133.96
BST_VCCIO on BOTTOM (solid shape): 133.92,50.51 133.92,49.68 133.79,49.56 132.72,49.56 132.65,49.62 132.65,50.51 132.78,50.64 133.79,50.64
BST_VCCIO on TOP: 134.56,51.36 134.44,51.36 134.3,51.22 133.53,51.22 133.41,51.11 133.41,50.33 133.53,50.22 134.47,50.22 134.61,50.36 134.61,51.31
BST_VCCIO_R on BOTTOM (solid shape): 131.89,50.45 131.89,49.68 131.76,49.56 130.49,49.56 130.37,49.68 130.37,50.45 130.49,50.57 131.76,50.57
BST_VCCSA on TOP: 145.29,99.91 145.48,99.91 145.54,99.85 145.54,98.9 145.35,98.71 143.19,98.71 143.07,98.58 143.07,97.75 143,97.69 142.1,97.69 142.07,97.72 142.07,98.73 142.43,99.09 145.16,99.09 145.22,99.15 145.22,99.85
BST_VCCSA_R on TOP: 143.69,98.58 145.21,98.58 145.28,98.52 145.28,97.75 145.21,97.69 143.62,97.69 143.56,97.75 143.56,98.45
BST_VCORE_PH1 on TOP: 83.67,134.01 86.21,134.01 86.49,133.73 86.49,132.34 86.39,132.23 86.08,132.23 85.98,132.34 85.98,133.15 85.75,133.38 84.96,133.38 84.35,132.77 83.64,132.77 83.59,132.82 83.59,133.94
BST_VCORE_PH1_R on TOP: 83.39,133.82 83.49,133.72 83.49,132.9 83.34,132.74 82.22,132.74 82.14,132.82 82.14,133.71 82.26,133.82
BST_VCORE_PH1_R on BOTTOM: 82.27,133.89 83.29,133.89 83.46,133.71 83.46,132.9 83.34,132.77 82.25,132.77 82.17,132.84 82.17,133.78
BST_VCORE_PH2 on TOP: 91.31,134.22 93.62,134.22 93.98,133.86 93.98,133 93.9,132.92 93.57,132.92 93.37,133.12 93.37,133.33 93.17,133.53 92.48,133.53 91.9,132.95 91.24,132.95 91.19,133 91.19,134.09
BST_VCORE_PH2_R on TOP (solid shape): 91.03,133.84 91.03,133.1 90.81,132.87 89.87,132.87 89.76,132.97 89.76,133.94 89.81,133.99 90.88,133.99
BST_VCORE_PH2_R on BOTTOM: 89.87,133.99 90.88,133.99 91.03,133.84 91.03,133.05 90.88,132.9 89.87,132.9 89.79,132.97 89.79,133.91
BST_VCORE_PH3 on TOP: 102.22,131.5 102.48,131.5 102.6,131.63 102.6,134.05 102.51,134.14 99.84,134.14 99.73,134.03 99.73,132.81 99.79,132.75 100.56,132.75 100.6,132.79 100.6,133.46 100.68,133.54 101.96,133.54 102.1,133.4 102.1,131.63
BST_VCORE_PH3_R on TOP (solid shape): 99.61,133.91 99.61,132.81 99.52,132.72 98.33,132.72 98.27,132.79 98.27,133.94 98.33,134 99.52,134
BST_VCORE_PH3_R on BOTTOM: 98.27,133.94 98.27,132.79 98.33,132.72 99.52,132.72 99.61,132.81 99.61,133.91 99.52,134 98.33,134
BST_VCORE_PH6 on TOP: 129.03,120.42 129.03,120.23 129.16,120.11 129.86,120.11 130.37,119.6 130.37,119.34 130.43,119.28 131.06,119.28 131.13,119.34 131.13,120.3 130.94,120.49 129.1,120.49
BST_VCORE_PH6_R on TOP: 131.95,121.57 132.52,121.57 132.59,121.5 132.59,119.34 132.52,119.28 131.95,119.28 131.89,119.34 131.89,121.5
DCIN_CHG on TOP (solid shape): 42.42,16.22 42.42,15.2 42.23,15.01 40.26,15.01 40.2,15.08 40.2,15.97 40.26,16.03 41.59,16.03 41.91,16.35 42.29,16.35
DCIN_ISL95338_1 on TOP: 57.98,34.38 58.99,34.38 59.05,34.32 59.05,33.17 59.12,33.11 59.37,33.11 59.5,32.98 59.5,32.73 59.44,32.67 57.91,32.67 57.85,32.73 57.85,34.25
DH_1.2V on TOP (solid shape): 147.78,50.68 147.78,49.84 147.49,49.55 147.49,48.47 147.42,48.4 147.29,48.4 147.23,48.47 147.23,49.61 147.22,49.62 147.22,50.75 147.29,50.82 147.64,50.82
DH_1.2V on BOTTOM (solid shape): 151.7,59.15 151.7,58.13 151.64,58.07 150.62,58.07 150.43,58.26 150.43,59.08 150.56,59.21 151.64,59.21
DH_1.2V on IN1 (solid shape): 151.7,58.96 151.7,52.86 150.69,51.84 150.69,48.99 150.37,48.67 148.21,48.67 147.28,49.6 147.28,50.7 147.47,50.89 147.79,50.89 147.92,50.76 147.92,50.19 148.15,49.96 148.15,49.94 148.4,49.68 149.48,49.68 149.67,49.88 149.67,52.16 150.56,53.05 150.56,58.83 150.94,59.21 151.45,59.21
DL_1.2V on TOP (solid shape): 150.05,52 150.05,51.36 150.48,50.93 150.48,50.09 149.9,49.51 149.9,48.59 149.26,47.96 148.12,47.96 148.06,48.02 148.06,48.15 148.12,48.21 148.82,48.21 149.2,48.59 149.2,49.53 149.81,50.14 149.81,50.74 149.56,50.99 148.7,50.99 148.56,51.13 148.56,52.21 148.69,52.34 149.71,52.34
FBVDDQ_PH2 on TOP (solid shape): 19.6,49.19 20.44,49.19 20.44,50.32 21.53,50.32 21.78,50.07 21.78,46.07 21.59,45.87 20.82,45.87 19.81,44.87 19.73,44.87 19.67,44.81 15.94,44.81 15.85,44.72 15.85,43.5 15.8,43.45 14.94,43.45 14.53,43.86 14.53,46.21 15.05,46.73 15.05,47.57 15.41,47.93 15.41,48.01 16.13,48.73 16.13,50 16.45,50.32 19.6,50.32
FBVDDQ_PH2 on BOTTOM (solid shape): 20.38,48 20.38,46.41 20.32,46.35 18.86,46.35 18.73,46.48 18.73,47.88 18.92,48.07 20.32,48.07
FBVDDQ_SNB1 on TOP (solid shape): 15.43,68.42 15.43,66.39 15.18,66.13 12.57,66.13 12.26,66.45 12.26,68.35 12.57,68.67 15.18,68.67
FBVDDQ_VIN on TOP (solid shape): 6.87,59.91 6.87,57.44 6.77,57.27 6.77,57.08 6.74,57.05 5.95,57.05 5.77,57.14 5.58,57.11 5.51,57.11 5.45,57.1 4.71,57.1 4.67,57.05 4.67,56.61 4.56,56.51 4.14,56.51 3.95,56.31 3.95,55.48 3.84,55.36 3.12,55.36 3.04,55.6 2.8,55.66 2.76,55.7 2.76,58.54 2.93,58.71 4.04,58.71 4.39,58.36 5.38,58.36 5.56,58.54 5.56,59.91 5.66,60.01 6.77,60.01
FBVDDQ_VIN on TOP: 21.89,43.03 21.23,43.03 20.45,42.24 17.88,42.24 17.81,42.17 17.81,41.11 17.93,40.99 19.11,40.99 19.13,41 19.14,41 19.33,40.81 19.33,40.29 19.32,40.27 19.32,40.12 19.9,39.54 19.9,39.03 18.41,37.54 18.41,37.1 18.57,36.95 20.69,36.95 21.08,37.34 21.08,39.03 21.68,39.63 22.03,39.63 22.16,39.75 22.16,42.76
FBVDDQ_VIN on BOTTOM: 14.99,41.05 14.99,41.81 14.61,42.19 11.18,42.19 11.05,42.32 11.05,45.49 11.56,46 12.19,46 12.32,46.13 12.32,46.89 11.94,47.27 11.94,48.54 11.68,48.8 4.19,48.8 4.17,48.77 1.94,48.77 1.4,49.31 1.4,61.74 1.84,62.18 3.47,62.18 3.59,62.05 3.59,61.43 3.34,61.17 3.34,58.3 3.5,58.14 4.87,58.14 5.1,57.91 5.1,57.03 4.32,56.25 4.32,51.97 4.7,51.59 12.45,51.59 13.97,50.07 13.97,48.41 14.73,47.65 14.73,44.34 16.74,42.33 20.64,42.33 20.85,42.12 21.8,42.12 21.89,42.03 21.89,39.73 20.13,37.97 19.42,37.97 18.97,38.43 18.97,40.38 18.82,40.53 15.51,40.53
GPU_B+ on TOP (solid shape): 15.88,37.23 15.88,34.79 15.82,34.74 14.03,34.74 13.78,34.99 13.78,37.21 13.97,37.4 15.7,37.4
GPU_B+ on BOTTOM (solid shape): 14.67,41.68 14.67,40.98 15.52,40.13 15.52,35.84 15.31,35.64 14.37,35.64 14.11,35.89 14.11,36.73 13.98,36.86 11.49,36.86 11.3,37.05 11.3,38.32 10.99,38.64 10.35,38.64 10.22,38.76 10.22,40.35 10.35,40.48 10.86,40.48 11.18,40.79 11.18,41.68 11.37,41.87 14.48,41.87
GPU_B+ on GND2: 16.3,34.82 14.73,34.82 14.71,34.84 14.34,34.84 14.22,34.97 14.22,37.61 14.39,37.77 16.31,37.77 16.61,37.47 16.61,35.14
GPU_B+ on IN4: 15.08,39.14 16.6,37.63 16.6,35.33 16.08,34.81 14.08,34.81 13.84,35.05 13.84,35.97 13.02,36.79 12.64,36.79 12.26,37.18 12.26,38.89 12.51,39.14
GPU_B+ on GND5: 12.45,39.08 14.54,39.08 14.73,38.89 14.73,37.37 14.54,37.18 12.38,37.18 12.26,37.3 12.26,38.89
GT_SW1 on TOP: 148.78,90.71 146.94,88.86 143.13,88.86 142.88,88.61 142.88,87.4 142.81,87.34 142.11,87.34 142.05,87.4 142.05,88.8 146.3,93.06 148.27,93.06 148.59,93.37 148.59,95.4 148.72,95.53 150.62,95.53 150.88,95.28 150.88,91.59 149.99,90.71
LG1_ISL95338_1 on BOTTOM (solid shape): 55.12,33.62 55.12,32.86 55.07,32.81 54.84,32.81 54.74,32.91 53.61,32.91 53.53,32.98 53.53,33.62 53.59,33.68 55.05,33.68
LG1_ISL95338_1 on IN4 (solid shape): 53.82,33.61 53.82,33.15 53.7,33.02 53.4,33.02 52.73,33.7 52.73,34.17 53.26,34.17
LG2_ISL95338_1 on IN3 (solid shape): 53.1,32.91 53.7,32.91 53.81,32.79 53.81,32.5 53.72,32.41 53.16,32.41 53.12,32.45 52.44,32.45 52.27,32.62 52.27,32.92 52.44,33.09 52.92,33.09
LG_+1VALWP on TOP (solid shape): 136.4,31.71 136.4,31.08 136.33,31.02 135.06,31.02 134.94,31.14 134.94,31.78 135.13,31.97 136.14,31.97
LG_+1VALWP on BOTTOM (solid shape): 132.71,37.94 132.71,35.7 133.01,35.4 133.01,35.37 133.73,34.65 133.73,32.73 134.56,31.9 136.02,31.9 136.14,31.78 136.14,31.52 135.89,31.27 133.16,31.27 132.52,31.9 132.52,33.77 132.3,34 132.12,34 131.78,34.34 131.78,36.43 131.13,37.07 131.13,37.87 131.32,38.06 132.59,38.06
LG_CHG on BOTTOM (solid shape): 42.11,17.97 43.65,17.97 43.69,17.93 43.69,17.81 43.65,17.77 42.63,17.77 42.38,17.52 42.19,17.52 42.06,17.64 41.83,17.64 41.55,17.92 41.55,18.1 41.66,18.2 41.88,18.2
LG_CHG on IN1: 41.47,18.38 41.97,18.38 42.48,17.87 42.48,17.62 42.35,17.49 42.16,17.49 41.97,17.68 40.7,17.68 32.6,25.79 31.5,25.79 31.21,26.08 31.21,26.56 31.39,26.75 33.1,26.75
LX1_ISL95338_1 on GND2 (solid shape): 54.85,34.39 54.85,34.2 54.65,34 54.01,34 53.21,34.8 53.21,35.16 53.28,35.22 54.03,35.22
LX1_ISL95338_1 on GND2 (solid shape): 52.03,27.59 52.29,27.59 52.5,27.38 52.5,26.38 52.32,26.2 52.31,26.2 52.25,26.14 51.32,26.14 50.76,26.7 50.76,27.33 51.03,27.6 52.02,27.6
LX1_ISL95338_1 on IN3 (solid shape): 54.83,34.36 54.83,34.17 54.42,33.76 53.64,33.76 53.63,33.77 53.37,33.77 53.24,33.9 53.24,34.32 53.42,34.5 54.69,34.5
LX1_ISL95338_1 on GND4 (solid shape): 51.86,27.53 52.34,27.53 52.51,27.36 52.51,26.67 51.93,26.09 51.35,26.09 51.09,26.34 51.09,27.45 51.18,27.54 51.85,27.54
LX1_ISL95338_1 on TOP: 40.53,37.25 42.82,37.25 44.64,35.44 45.26,35.44 45.33,35.37 45.33,32.24 45.15,32.06 44.74,32.06 44.26,31.57 44.26,30.24 44.62,29.89 45.87,29.89 45.99,29.77 45.99,26.69 45.81,26.51 44.95,26.51 44.39,25.95 40.54,25.95 40.21,26.28 40.21,36.93
LX1_ISL95338_1 on BOTTOM: 55.5,33.75 55.5,32.86 55.44,32.79 55.31,32.79 55.24,32.86 55.24,33.62 55.05,33.81 54.55,33.81 54.5,33.86 54.5,34.06 54.53,34.1 55.14,34.1
LX1_NVVDD on TOP (solid shape): 27.3,50.3 28.01,50.3 28.01,51.11 29.5,51.11 29.72,50.89 29.72,47.21 29.43,46.92 24.09,46.92 23.81,46.64 23.81,45.49 23.75,45.43 23.11,45.43 23.05,45.49 23.05,50.64 23.52,51.11 27.3,51.11
LX1_NVVDD on BOTTOM (solid shape): 27.05,50.66 27.05,48.92 26.99,48.86 25.4,48.86 25.12,49.14 25.12,50.56 25.36,50.8 26.91,50.8
LX2_ISL95338_1 on TOP (solid shape): outline of 115 points within 34.48,23.56 40.51,37.99
LX2_ISL95338_1 on IN3 (solid shape): 53.11,32.06 53.11,31.64 52.98,31.51 51.54,31.51 51.4,31.65 51.4,31.89 51.64,32.13 53.04,32.13
LX2_ISL95338_1 on BOTTOM: 38.5,28.52 38.25,28.77 37.85,28.77 37.74,28.88 37.74,32.28 37.91,32.45 38.38,32.45 38.56,32.63 38.56,34.13 38.44,34.24 38.16,34.24 37.73,34.67 37.73,37.9 38.05,38.22 40.36,38.22 40.92,37.66 40.92,27.82 40.83,27.73 38.84,27.73 38.5,28.06
LX2_ISL95338_1 on GND2: 53.52,31.03 53.19,31.37 52.25,31.37 52.1,31.52 52.1,32.12 52.2,32.22 53.68,32.22 53.78,32.12 53.78,31.16 53.66,31.03
LX2_NVVDD on TOP (solid shape): 34.86,50.25 35.57,50.25 35.57,51.11 37.06,51.11 37.27,50.89 37.27,47.21 36.98,46.92 31.65,46.92 31.37,46.64 31.37,45.49 31.31,45.43 30.67,45.43 30.61,45.49 30.61,50.64 31.08,51.11 34.86,51.11
