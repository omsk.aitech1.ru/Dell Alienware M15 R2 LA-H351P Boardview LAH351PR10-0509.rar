# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPPJ_RCOMP_1P8: length 5.7
  TOP w0.254: UH1.BE2 93.16,26.34 UH1.BE1 ; UH1.BE1 92.73,26.34 92.08,25.68 RH216.1 ; UH1.BE1 UH1.BD1
GPU_B+: length 16.2
  TOP w0.081: PRW33.1 7.79,25.73 8.18,26.13 8.18,26.52 v2(8.34,26.69)
  TOP w0.254: PRW33.1 7.7,26.43 v5(7.56,26.57)
  IN3 w0.508: v6(14.73,35.09) 14.73,29.5 11.73,26.5 7.63,26.5 7.62,26.52 7.61,26.52 v5(7.56,26.57)
  vias: v1(14.8,35.59) v1(14.8,35.27) v1(14.8,34.95) v1(15.11,35.59) v1(15.11,35.27) v1(15.11,34.95) v1(15.43,35.59) v1(15.43,35.27) v1(15.43,34.95) v3(15.07,37.51) v3(15.19,37.07) v3(15.19,36.57) v3(15.19,36.06) v3(15.85,37.06) v3(15.85,36.55) v3(15.85,36.05) v3(16.37,37.09) v3(16.37,36.58) v3(16.37,36.07) v4(12.45,38.64) v4(12.45,38.32) v4(12.45,38) v4(12.45,37.68) v4(12.45,37.37) v4(12.83,38.64) v4(12.83,38.32) v4(12.83,38) v4(12.83,37.68) v4(12.83,37.37) v4(13.21,38.64) v4(13.21,38.32) v4(13.21,38) v4(13.21,37.68) v4(13.21,37.37) v4(13.59,38.64) v4(13.59,38.32) v4(13.59,38) v4(13.59,37.68) v4(13.59,37.37) v4(14.16,38.83) v4(14.16,38.51) v4(14.16,38.19) v4(14.16,37.87) v4(14.16,37.56) v4(14.54,38.83) v4(14.54,38.51) v4(14.54,38.19) v4(14.54,37.87) v4(14.54,37.56) v5(14.54,37.1) v5(14.54,36.54) v5(14.54,35.98) v6(15.07,37.51) v6(15.19,37.07) v6(15.19,36.57) v6(15.19,36.06) v6(15.85,37.06) v6(15.85,36.55) v6(15.85,36.05) v6(16.37,37.09) v6(16.37,36.58) v6(16.37,36.07)
GPU_BUFRST#: length 9.6
  TOP w0.081: UG1.BF9 54.75,89.53 55.16,89.93 55.16,90.36 55.32,90.53 59.68,90.53 61.24,88.97 61.24,88.53 61.35,88.42 T6.1
GPU_DP_AUXN: length 122.8
  IN4 w0.069: v7(118.71,139.07) 118.42,139.36 118.42,139.84 118.64,140.05 119.76,140.05 119.82,139.99 119.82,139.09 119.47,138.74 117.84,138.74 117.53,139.04 112.09,139.04 111.77,139.36 111.37,139.36 111.02,139.01 110.89,139.01 110.82,139.08 v7(110.82,139.35) 110.52,139.04 109.93,139.04 109.22,139.75 100,139.75 98.27,138.02 90.28,138.02 89.74,138.56 89.74,139.45 88.19,141 86.6,141 85.4,142.2 83.06,142.2 82.87,142.39 81.93,142.39 81.58,142.05 81.58,141.41 81.23,141.06 73.09,141.06 69.82,137.8 67,137.8 64.74,135.54 64.74,120.53 62.71,118.49 62.71,112.62 60.89,110.8 60.89,102.06 60.25,101.42 60.25,94.2 56.82,90.77 56.82,87.33 57.13,87.02 57.58,87.02 57.84,87.28 57.84,87.9 57.99,88.05 v6(58.25,88.05)
  BOTTOM w0.081: UV3.13 111.02,140.37 RV665.1 v7(110.82,139.35)
GPU_DP_AUXN_C: length 13.9
  IN2 w0.069: v4(118.71,139.72) 118.71,140.7 118.59,140.82 117.28,140.82 117.19,140.9 108.68,140.9 108.06,140.29 108.06,139.31 108.43,138.93 108.56,138.93 108.67,139.05 v4(108.67,139.22)
GPU_DP_AUXN_R: length 0.7
  BOTTOM w0.081: RV618.2 109.39,139.35 CV25.2
GPU_DP_AUXP: length 124.6
  IN4 w0.069: v4(118.71,141.02) 118.71,140.59 119.04,140.26 119.84,140.26 120.03,140.07 120.03,139 119.56,138.53 117.75,138.53 117.45,138.84 112,138.84 111.69,139.15 111.45,139.15 111.11,138.81 110.94,138.81 110.82,138.69 v7(110.82,138.46) 110.44,138.84 109.85,138.84 109.14,139.55 100.09,139.55 98.35,137.81 90.2,137.81 89.53,138.48 89.53,139.36 88.1,140.79 86.52,140.79 85.31,142 82.98,142 82.79,142.19 82.02,142.19 81.79,141.96 81.79,141.33 81.32,140.86 73.17,140.86 69.91,137.6 67.08,137.6 64.94,135.46 64.94,120.44 62.91,118.41 62.91,112.53 61.09,110.71 61.09,101.98 60.45,101.34 60.45,94.12 57.02,90.69 57.02,87.42 57.21,87.23 57.5,87.23 57.63,87.36 57.63,87.98 57.56,88.05 v6(57.55,88.05)
  BOTTOM w0.081: UV3.10 113.83,138.42 113.94,138.31 113.94,137.44 113.72,137.21 111.24,137.21 RV664.1 v7(110.82,138.46)
GPU_DP_AUXP_C: length 14
  IN2 w0.069: v4(118.71,141.67) 118.71,141.14 118.59,141.02 117.36,141.02 117.28,141.11 108.59,141.11 107.86,140.37 107.86,139.22 108.35,138.73 108.53,138.73 v4(108.67,138.58)
GPU_DP_AUXP_R: length 0.7
  BOTTOM w0.081: CV24.2 109.39,138.46 RV619.2
GPU_DP_HPD#: length 133.9
  TOP w0.081: RX5.2 126.11,138.79 126.03,138.87 v3(126.03,139.34)
  IN1 w0.058: v8(54.05,84.55) 53.93,84.55 52.42,86.06 52.42,88.4 55.08,91.06 57.63,91.06 58.11,91.54 v11(59.08,91.54)
  GND2 w0.081: v11(59.08,91.54) v3(59.09,91.54)
  IN2 w0.058: v5(65.54,119.47) 63.88,117.81 63.88,116.68 65.02,115.53 66.24,115.53 66.84,116.13 70.79,116.13 71.38,115.54 79.96,115.54 v3(80.17,115.75)
  IN3 w0.058: v3(80.17,115.75) 80.17,115.9 80.44,116.18 80.44,117.17 79.71,117.9 79.71,120.24 80.47,121 80.47,131.52 80.47,131.78 83.2,134.51 85.6,134.51 86.37,135.27 88.12,135.27 90.32,137.47 96.35,137.47 97.52,138.63 107.28,138.63 108.22,137.69 109.84,137.69 110.25,138.1 114.39,138.1 114.96,138.66 124.95,138.66 125.63,139.34 v3(126.03,139.34)
  GND4 w0.081: v3(59.09,91.54) v6(59.43,91.54)
  IN4 w0.058: v5(65.54,119.47) 63.82,117.75 63.82,112.02 62.42,110.62 62.42,99.13 62.42,99.13 62.42,97.26 62.22,97.07 62.22,93.44 60.32,91.54 v6(59.43,91.54)
GPU_DP_HPD_R: length 15.3
  TOP w0.081: v8(119.35,145.39) 119.57,145.18 121.23,145.18 v2(122.06,144.35) 122.06,143.63 121.87,143.44 CX1.1 RX2.2
  IN1 w0.058: v8(119.35,145.39) 117.47,147.27 112.71,147.27 112.2,147.78 JDP.2
GPU_DP_N0: length 103.5
  TOP w0.081: v6(55.7,93.98) 55.45,94.25 UG1.BG17
  IN4 w0.069: v6(55.7,93.98) 55.67,94.02 55.67,94.65 55.91,94.9 56.78,94.9 58.27,96.39 58.27,102.22 58.93,102.87 58.93,117.49 62.77,121.33 62.77,136.35 67.06,140.63 69,140.63 72.09,143.72 76.63,143.72 77.53,144.62 77.53,145.36 78.41,146.24 80.69,146.24 81.23,145.7 84.48,145.7 84.94,145.24 94.2,145.24 94.53,145.57 96.86,145.57 97.9,144.53 98.96,144.53 99.8,143.69 111.19,143.69 111.35,143.86 112.89,143.86 113.23,143.51 113.23,143.09 v6(113.37,142.95)
GPU_DP_N0_C: length 2.4
  TOP w0.081: CV27.2 113.2,143.71 113.2,144.5 113.4,144.7 JDP.5
GPU_DP_N1: length 105.2
  IN4 w0.069: v6(54.75,92.95) 54.98,93.18 54.98,93.23 55.34,93.59 56.76,93.59 58.93,95.76 58.93,101.95 59.58,102.6 59.58,117.21 63.43,121.07 63.43,136.08 66.46,139.11 69.28,139.11 73.24,143.06 78.93,143.06 79.67,143.8 80.6,143.8 81.61,144.82 82.54,144.82 83.24,144.12 84.45,144.12 84.9,144.58 92.71,144.58 92.96,144.33 93.69,144.33 93.95,144.58 96.93,144.58 97.61,143.89 98.67,143.89 99.79,142.78 110.95,142.78 111.47,142.26 113.44,142.26 113.95,142.76 114.89,142.76 115.07,142.58 115.07,142.31 v6(115.19,142.19)
GPU_DP_N1_C: length 3.2
  TOP w0.081: JDP.11 115.2,144.7 115,144.5 115,142.96 CV30.2
GPU_DP_N2: length 112.4
  IN4 w0.069: v6(54.75,92.25) 54.61,92.11 54.61,91.91 54.29,91.59 53.85,91.59 53.34,92.1 53.34,92.74 53.59,92.99 53.7,92.99 54.15,93.45 54.54,93.45 55.04,93.95 55.04,94.85 55.76,95.57 56.21,95.57 57.29,96.66 57.29,102.16 58.28,103.14 58.28,117.76 62.12,121.6 62.12,136.62 66.78,141.28 68.73,141.28 72.26,144.82 75.2,144.82 75.72,145.33 76.12,145.33 77.88,147.09 82.83,147.09 83.03,147.3 83.57,147.3 83.77,147.09 87.25,147.09 88.06,146.28 92.99,146.28 93.34,145.93 93.92,145.93 94.3,146.31 97.06,146.31 98.19,145.18 99.23,145.18 100.07,144.34 110.74,144.34 110.9,144.51 115.68,144.51 116.83,143.36 116.83,143.12 v6(116.99,142.95)
GPU_DP_N2_C: length 2.4
  TOP w0.081: JDP.17 117,144.7 116.8,144.5 116.8,143.73 CV33.2
GPU_DP_N3: length 101.9
  IN4 w0.069: v6(110.71,141.81) 110.62,141.72 110.62,141.4 110.4,141.18 109.25,141.18 108.77,141.66 98.61,141.66 97.91,142.36 94.46,142.36 93.54,143.28 92.76,143.28 92.33,143.72 92.02,143.72 91.8,143.49 91.8,143.19 91.52,142.9 89.52,142.9 88.06,141.45 86.92,141.45 85.62,142.75 83.67,142.75 83.19,143.23 82.91,143.23 82.52,142.84 81.68,142.84 80.64,141.81 74.66,141.81 74.42,141.57 72.96,141.57 69.64,138.25 66.81,138.25 64.29,135.73 64.29,120.71 62.26,118.68 62.26,117.15 60.44,115.33 60.44,102.25 59.78,101.59 59.78,95.18 57.48,92.88 57.48,92.2 56.93,91.65 55.76,91.65 55.55,91.86 55.55,92.15 v6(55.45,92.25)
GPU_DP_N3_C: length 10.5
  TOP w0.081: JDP.12 115,148.93 115,147.77 114.52,147.28 111.91,147.28 110.56,145.93 v13(110.56,143.23) 110.56,142.54 CV31.2
GPU_DP_P0: length 103.4
  IN4 w0.069: v6(56.15,94.35) 56.45,94.35 56.52,94.28 56.52,94.14 56.43,94.06 56.02,94.06 55.87,94.21 55.87,94.57 55.99,94.69 56.87,94.69 58.48,96.3 58.48,102.13 59.13,102.79 59.13,117.4 62.97,121.24 62.97,136.26 67.14,140.43 69.08,140.43 72.17,143.51 76.72,143.51 77.74,144.53 77.74,145.28 78.5,146.04 80.6,146.04 81.14,145.49 84.4,145.49 84.85,145.04 94.28,145.04 94.61,145.37 96.77,145.37 97.81,144.33 98.87,144.33 99.71,143.49 111.27,143.49 111.44,143.65 112.8,143.65 113.03,143.42 113.03,143.09 112.89,142.95 v6(112.8,142.95)
GPU_DP_P0_C: length 2.5
  TOP w0.081: CV26.2 113,143.73 113,144.5 112.8,144.7 JDP.3
GPU_DP_P1: length 105.2
  IN4 w0.069: v6(55.45,92.95) 55.45,92.92 55.33,92.79 55.2,92.79 55.13,92.86 55.13,93.13 55.38,93.39 56.67,93.39 56.84,93.39 59.13,95.67 59.13,101.86 59.78,102.52 59.78,117.13 63.64,120.98 63.64,136 66.54,138.9 69.37,138.9 73.33,142.86 79.02,142.86 79.76,143.6 80.68,143.6 81.7,144.62 82.45,144.62 83.15,143.92 84.53,143.92 84.99,144.38 92.63,144.38 92.88,144.12 93.78,144.12 94.03,144.38 96.84,144.38 97.53,143.69 98.59,143.69 99.71,142.57 110.86,142.57 111.38,142.05 113.53,142.05 114.03,142.56 114.8,142.56 114.87,142.49 114.87,142.26 114.8,142.19 v6(114.62,142.19)
GPU_DP_P1_C: length 3.2
  TOP w0.081: CV28.2 114.8,142.96 114.8,143.38 114.8,143.39 114.8,144.5 114.6,144.7 JDP.9
GPU_DP_P2: length 112.3
  IN4 w0.069: v6(116.42,142.95) 116.62,143.16 116.62,143.28 115.6,144.31 110.99,144.31 110.82,144.14 99.98,144.14 99.14,144.98 98.1,144.98 96.98,146.1 94.39,146.1 94.01,145.73 93.26,145.73 92.91,146.08 87.98,146.08 87.16,146.89 83.68,146.89 83.48,147.09 83.12,147.09 82.91,146.89 77.97,146.89 76.2,145.13 75.8,145.13 75.29,144.61 72.35,144.61 68.81,141.08 66.87,141.08 62.32,136.53 62.32,121.52 58.48,117.67 58.48,103.06 57.49,102.07 57.49,96.57 56.29,95.37 55.84,95.37 55.24,94.77 55.24,93.86 54.63,93.24 54.24,93.24 53.78,92.79 53.68,92.79 53.54,92.65 53.54,92.19 53.93,91.8 54.21,91.8 54.41,92 54.41,92.61 54.39,92.62 54.39,92.71 54.3,92.8 54.15,92.8 54.07,92.71 54.07,92.62 54.05,92.61 v6(54.05,92.25)
GPU_DP_P2_C: length 2.4
  TOP w0.081: CV32.2 116.6,143.72 116.6,144.5 116.4,144.7 JDP.15
GPU_DP_P3: length 102
  IN4 w0.069: v6(110.13,141.81) 110.21,141.89 110.35,141.89 110.41,141.82 110.41,141.48 110.31,141.38 109.33,141.38 108.85,141.86 98.7,141.86 98,142.56 94.55,142.56 93.62,143.49 92.85,143.49 92.41,143.92 91.94,143.92 91.6,143.58 91.6,143.27 91.43,143.11 89.43,143.11 87.98,141.65 87,141.65 85.7,142.95 83.75,142.95 83.27,143.44 82.82,143.44 82.44,143.05 81.59,143.05 80.56,142.01 74.58,142.01 74.34,141.77 72.87,141.77 69.55,138.45 66.73,138.45 64.09,135.81 64.09,120.8 62.05,118.76 62.05,117.24 60.23,115.42 60.23,102.33 59.58,101.68 59.58,95.26 57.28,92.96 57.28,92.28 56.85,91.85 55.84,91.85 55.75,91.94 55.75,92.23 55.86,92.34 56.06,92.34 v6(56.15,92.25)
GPU_DP_P3_C: length 10.6
  TOP w0.081: JDP.10 114.8,148.94 114.8,147.85 114.43,147.49 111.83,147.49 110.36,146.02 110.36,143.5 110.34,143.48 110.34,142.6 CV29.2
GPU_DRVON: length 173.6
  TOP w0.254: PUV1.36 73.97,31.99 73.91,32.04 73.91,33.42 PRV51.1 73.13,33.86 72.86,34.13 72.86,36.01 73.34,36.49 v8(73.34,37.75) 73.42,37.82 79.49,37.82 80.38,38.71 v1(80.38,41.01) ; v5(78.18,70.11) v2(77.56,70.11) ; v8(71.31,19.32) 70.88,18.89 70.88,18.39 71.14,18.14 PQV1.3
  IN1 w0.254: v8(73.34,37.75) 73.03,38.06 72.58,38.06 71.25,39.4 69.47,39.4 v11(69.34,39.27) ; v8(71.31,19.32) 66.87,19.32 66.19,19.99 56.83,19.99 53.37,23.45 49.92,23.45 v5(49.21,24.16)
  GND2 w0.254: v1(80.38,41.01) 80.39,41.02 v12(80.39,41.3) ; v11(69.34,39.27) v3(69,39.27)
  IN2 w0.254: v5(78.18,70.11) 78.79,70.11 79.04,69.85 79.04,68.91 79.22,68.73 79.22,68.14 79.25,68.11 79.25,67.73 79.04,67.53 79.04,57.53 80.1,56.48 80.1,41.86 80.39,41.57 v12(80.39,41.3) ; v3(68.96,41.57) 68.11,40.72 v3(66.24,40.72) ; v3(45.62,40.02) 48.63,40.02 50.5,38.15 50.5,34.5 50.05,34.05 50.05,32.12 50.95,31.22 50.95,24.82 50.55,24.41 49.47,24.41 v5(49.21,24.16)
  IN3 w0.254: v9(38.62,41.67) 38.62,41.63 37.82,40.83 33.73,40.83 31.9,42.66 30.62,42.66 v9(30.37,42.92) ; v9(45.92,41.61) 45.62,41.3 v3(45.62,40.02)
  GND4 w0.254: v4(30.05,42.92) v9(30.37,42.92) ; v3(69,39.27) v6(69,39.61) ; v4(46.25,41.99) 45.92,41.66 v9(45.92,41.61) ; v4(69.37,41.86) 69.25,41.86 v3(68.96,41.57) ; v4(38.62,42.06) v9(38.62,41.67) ; v6(65.77,40.72) v3(66.24,40.72)
  IN4 w0.254: v7(55.52,41.73) 57.53,41.73 58.14,41.13 61.19,41.13 v7(61.58,41.52) 64.07,41.52 64.87,40.72 v6(65.77,40.72) ; v4(38.62,42.06) 38.85,42.06 38.93,42.14 39.04,42.14 39.17,42.27 41.27,42.27 41.76,42.76 45.45,42.76 46.22,41.99 v4(46.25,41.99) 46.47,41.99 46.78,42.29 52.16,42.29 52.87,41.58 v7(53.34,41.58) ; v4(69.37,41.86) 69.37,40.07 69,39.7 v6(69,39.61) ; v7(22.42,42.85) 22.77,43.21 23.48,43.21 23.77,42.92 25.2,42.92 25.23,42.89 25.52,42.89 25.55,42.92 v4(30.05,42.92)
  BOTTOM w0.254: PRV183.1 72.87,79.63 73.71,80.47 76.77,80.47 79.18,78.06 79.18,75.24 78.6,74.65 78.6,73.43 78.19,73.03 78.19,70.12 v5(78.18,70.11) ; PRV171.1 v7(61.58,41.52) ; v7(53.34,41.58) 53.38,41.58 53.77,41.98 PRV160.1 55.28,41.98 v7(55.52,41.73)
GPU_FAN_FB: length 6.4
  TOP w0.081: DF2.2 87.25,19.02 87.25,17.61 87.12,17.48 86.19,17.48 RF4.1 85.67,17.05 84.99,16.36 UE5.N11
GPU_FAN_PWM: length 97
  TOP w0.081: v2(142.75,41.47) 143.21,41.93 v5(143.48,41.93) ; RF5.1 85.76,15.45 85.41,15.8 85.36,15.8 85.29,15.86 v8(83.17,15.86)
  IN1 w0.058: 84.2,15.33 84.55,14.98 84.55,14.33 84.87,14.01 84.87,11.66 85.1,11.43 85.6,11.43 86.11,11.94 86.86,11.94 88.33,13.42 88.67,13.42 91.49,16.24 102.09,16.24 102.55,15.78 104.27,15.78 104.97,15.08 105.68,15.08 106.27,15.67 107.52,15.67 108.08,16.23 109.6,16.23 109.97,15.86 112.41,15.86 112.9,16.36 113.18,16.36 113.73,15.81 124.85,15.81 125.4,16.36 133.6,16.36 136.43,19.19 136.43,25.97 139.24,28.78 139.24,29.42 v6(139.93,30.1)
  IN1 w0.076: 84.2,15.33 83.67,15.86 v8(83.17,15.86)
  IN4 w0.058: v6(139.93,30.1) 140.23,30.41 140.23,31.47 139.08,32.62 139.08,38.78 141.58,41.28 142.84,41.28 v5(143.48,41.93) 145.31,43.75 145.31,44.92 v7(145.05,45.18)
GPU_FBVDD_PSI: length 17.2
  TOP w0.081: v2(57.73,75.54) 57.99,75.29 RG1596.2 59.05,75.29 RG1583.1 59.8,76.49 RG1581.1 ; UG1.BB2 51.95,83.6 52.42,83.13 52.42,81.91 52.73,81.6 52.73,79.94 52.96,79.71 53.29,79.71 53.66,80.08 54.44,80.08 55.33,79.19 56.03,79.19 56.71,78.51 57.45,78.51 58.56,77.41 59.42,77.41 RG1581.1 ; RG1582.2 RG1581.1
GPU_GC6_FB_EN: length 77.1
  TOP w0.081: v5(69.81,90.46) 69.85,90.43 69.85,89 v2(69.28,88.43) 68.72,87.87 68.22,87.87 68.05,88.04 v8(67.11,88.04) 66.52,88.04 66.27,87.78 65.15,87.78 64.96,87.98 RG22.1
  IN1 w0.058: v5(78.61,75.39) 78.44,75.57 78.44,83.19 71.22,90.4 69.98,90.4 69.92,90.46 v5(69.81,90.46) ; v8(51.95,85.95) 52.1,86.1 52.1,88.53 54.95,91.38 57.5,91.38 58.13,92.01 59.08,92.01 59.28,92.21 63.1,92.21 67.11,88.2 v8(67.11,88.04)
  BOTTOM w0.081: UG44.2 71.07,61.7 71.63,62.26 73.79,62.26 73.99,62.46 UG27.1 74.42,63.57 RG553.1 75.12,64.48 76.2,65.56 76.2,66.96 75.99,67.16 QG511.3 76.19,67.85 76.19,68.82 77.81,70.45 77.81,73.68 78.3,74.16 78.3,75.07 v5(78.61,75.39) ; UG41.1 74.38,93.59 72.82,92.03 70.53,92.03 70.12,91.62 69.68,91.62 69.46,91.39 69.46,91.09 69.81,90.73 v5(69.81,90.46)
GPU_GC6_FB_FGC6_EN: length 40.9
  IN4 w0.058: v7(79.83,69.24) 79.83,67.85 79.4,67.41 v7(78.87,67.41)
  BOTTOM w0.081: v7(79.83,69.24) 79.83,69.4 78.69,70.54 78.69,72.88 79.05,73.25 79.05,74.42 79.79,75.16 79.79,79.05 81.56,80.83 81.56,84.8 80.13,86.23 v2(80.13,87.27) 79.77,87.63 75.51,87.63 75.12,88.03 UG39.2 75.12,91.54 RG1511.2 ; UG43.1 76.47,61 76.58,61.11 76.58,61.76 CG7090.1 76.15,62.92 76.58,63.35 76.58,66.58 77.22,67.21 78.66,67.21 v7(78.87,67.41)
GPU_HDMI_CLKN: length 140.7
  IN4 w0.056: v6(54.75,94.35) 54.63,94.23 54.63,93.98 54.39,93.75 53.81,93.75 53.07,94.49 53.07,94.92 52.87,95.11 52.87,97.64 54.77,99.54 54.77,103.12 55.91,104.26 55.91,118.74 59.56,122.39 59.56,138.17 66.22,144.83 67.44,144.83 68.13,145.52 68.13,146.83 71.43,150.13 85.46,150.13 85.83,149.76 90.49,149.76 91.47,148.79 93.6,148.79 94.21,149.4 99.54,149.4 101.1,147.84 103.77,147.84 104.73,146.88 122.33,146.88 124.96,144.24 135.12,144.24 138.49,140.87 138.49,139.01 138.87,138.63 138.87,138.3 v7(138.94,138.23)
GPU_HDMI_CLKP: length 140.7
  IN4 w0.056: v6(54.05,94.35) 54.05,94.74 54.12,94.81 54.36,94.81 54.42,94.74 54.42,94.07 54.31,93.96 53.9,93.96 53.28,94.58 53.28,95 53.08,95.2 53.08,97.56 54.98,99.45 54.98,103.03 56.12,104.17 56.12,118.65 59.77,122.31 59.77,138.09 66.31,144.62 67.53,144.62 68.34,145.43 68.34,146.75 71.52,149.92 85.37,149.92 85.75,149.55 90.41,149.55 91.38,148.58 93.68,148.58 94.3,149.19 99.45,149.19 101.01,147.63 103.68,147.63 104.64,146.67 122.24,146.67 124.87,144.03 135.03,144.03 138.28,140.78 138.28,138.92 138.66,138.55 138.66,138.39 138.5,138.23 v7(138.3,138.23)
GPU_HDMI_CTRL_CLK: length 136.8
  IN1 w0.056: v8(135.06,143.23) 135.33,142.97 135.33,142.53 135.8,142.06 137.07,142.06 137.61,141.52 137.61,140.83 137.56,140.77 137.42,140.74 v6(136.65,141.27)
  IN4 w0.056: v6(57.55,88.75) 57.84,88.75 57.9,88.81 57.9,90.94 61.33,94.37 61.33,98.52 61.98,99.16 61.98,110.89 63.35,112.27 63.35,118.23 65.38,120.26 65.38,134.61 66.74,135.96 69.79,135.96 72.1,138.27 72.1,139.16 72.87,139.93 73.75,139.93 74.24,140.42 79.1,140.42 79.28,140.24 81.81,140.24 82.44,140.87 82.95,140.87 83.42,141.34 85.34,141.34 86.35,140.32 87.74,140.32 89.09,138.97 89.09,138.27 89.99,137.37 98.62,137.37 100.29,139.03 107.7,139.03 108.64,138.08 121.77,138.08 122.83,137.02 129.61,137.02 130.19,137.59 135.92,137.59 136,137.68 136,139.45 137.19,140.65 137.19,140.73 v6(136.65,141.27)
GPU_HDMI_CTRL_DAT: length 136.8
  TOP w0.066: QV96.1 v6(137.99,139.97)
  IN1 w0.056: v6(137.99,139.97) 137.9,140.41 137.73,140.53 137.71,140.61 137.71,140.63 137.82,140.76 137.82,141.61 137.16,142.27 135.89,142.27 135.54,142.62 135.54,142.93 135.84,143.23 v8(135.87,143.23)
  IN4 w0.056: v6(58.25,88.75) 58.11,88.89 58.11,90.85 61.54,94.28 61.54,98.43 62.19,99.08 62.19,110.81 63.56,112.18 63.56,118.14 65.6,120.17 65.6,134.52 66.83,135.75 69.87,135.75 72.31,138.18 72.31,139.07 72.95,139.72 73.84,139.72 74.33,140.2 79.01,140.2 79.19,140.03 81.9,140.03 82.53,140.66 83.04,140.66 83.5,141.12 85.25,141.12 86.26,140.11 87.65,140.11 88.88,138.88 88.88,138.18 89.9,137.16 98.71,137.16 100.37,138.82 107.61,138.82 108.56,137.87 121.68,137.87 122.75,136.81 129.7,136.81 130.27,137.38 136,137.38 136.21,137.59 136.21,139.37 137.27,140.43 137.53,140.43 v6(137.99,139.97)
GPU_HDMI_HPD#: length 137.3
  TOP w0.081: QV97.6 128.86,137.44 129.22,137.81 RX7.2 129.71,137.85 v2(130.19,138.33) 130.19,139.36 v3(130.15,139.4) ; v8(52.37,84.94) 52.35,84.91 51.59,84.91 UG1.BA4
  IN1 w0.058: v8(52.37,84.94) 52.37,84.13 53.04,83.46 59.31,83.46 v5(60.12,84.28)
  IN2 w0.058: v3(80.11,116.31) 80.11,116.2 79.6,115.7 71.45,115.7 70.86,116.29 65.16,116.29 v5(64.96,116.49)
  IN3 w0.058: v3(130.15,139.4) 129.11,139.4 128.55,139.96 126.01,139.96 124.88,138.82 114.89,138.82 114.33,138.26 110.18,138.26 109.77,137.85 108.29,137.85 107.35,138.79 97.45,138.79 96.29,137.63 90.25,137.63 88.05,135.43 86.3,135.43 85.53,134.67 83.13,134.67 80.31,131.85 80.31,131.45 80.31,121.07 79.55,120.3 79.55,117.5 80.11,116.95 v3(80.11,116.31)
  IN4 w0.058: v5(60.12,84.28) 60.68,84.84 62.1,84.84 62.39,85.13 63.13,85.13 63.74,85.74 63.74,91.92 62.54,93.11 62.54,96.94 62.74,97.13 62.74,110.49 64.2,111.95 64.2,115.72 v5(64.96,116.49)
GPU_HDMI_TX_N0: length 132.9
  TOP w0.066: UG1.BF18 v6(54.41,95.39)
  IN4 w0.056: v6(54.41,95.39) 54.41,95.5 54.05,95.85 53.84,95.85 53.53,96.16 53.53,97.33 55.4,99.2 55.4,102.81 56.48,103.89 56.48,118.5 60.13,122.16 60.13,137.94 66.23,144.03 68.18,144.03 69.26,145.1 69.26,147.15 71.67,149.56 84.95,149.56 85.32,149.19 90.26,149.19 91.27,148.17 93.81,148.17 94.44,148.81 98.93,148.81 101.24,146.49 104.3,146.49 104.49,146.31 121.69,146.31 125.21,142.79 132.11,142.79 134.11,140.79 134.11,138.36 v7(134.18,138.29)
GPU_HDMI_TX_N1: length 117.9
  IN4 w0.056: v7(124.71,138.17) 124.59,138.29 124.59,141.37 120.79,145.16 104.02,145.16 103.84,145.34 100.78,145.34 100.27,145.85 98.48,145.85 98.07,146.25 98.07,146.48 97.31,147.24 96.3,147.24 96.04,146.99 88.28,146.99 87.52,147.75 85.58,147.75 84.99,147.75 84.32,148.42 83.22,148.42 82.54,147.75 75.48,147.75 74.66,146.93 74.66,145.97 74.21,145.53 72.05,145.53 68.46,141.94 66.51,141.94 61.43,136.86 61.43,121.84 57.62,118.03 57.62,103.42 56.63,102.43 56.63,98.82 55.61,97.79 55.61,96.61 v6(55.45,96.45)
GPU_HDMI_TX_N2: length 125.6
  IN4 w0.056: v7(129.48,138.23) 129.28,138.03 129.28,137.63 129.03,137.38 128.09,137.38 127.87,137.6 127.87,140.47 126.35,141.98 124.84,141.98 121.3,145.52 104.16,145.52 103.99,145.7 100.93,145.7 98.67,147.96 94.77,147.96 94.15,147.35 90.99,147.35 89.93,148.41 84.98,148.41 84.61,148.78 83,148.78 82.33,148.11 71.32,148.11 70.04,146.83 70.04,144.63 68.05,142.65 66.72,142.65 60.98,136.91 60.98,121.9 57.26,118.18 57.26,103.57 56.23,102.54 56.23,98.92 54.48,97.17 54.48,96.51 54.55,96.45 v6(54.75,96.45)
GPU_HDMI_TX_P0: length 132.9
  TOP w0.066: v6(55.05,95.4) 55.09,95.4 UG1.BG18
  IN4 w0.056: v7(133.6,138.29) 133.66,138.23 133.78,138.23 133.9,138.36 133.9,140.7 132.02,142.58 125.12,142.58 121.61,146.09 104.4,146.09 104.22,146.28 101.16,146.28 98.84,148.6 94.53,148.6 93.9,147.96 91.19,147.96 90.17,148.98 85.24,148.98 84.86,149.35 71.76,149.35 69.47,147.06 69.47,145.02 68.27,143.82 66.31,143.82 60.35,137.85 60.35,122.07 56.69,118.41 56.69,103.8 55.61,102.73 55.61,99.11 53.74,97.24 53.74,96.25 53.92,96.07 54.14,96.07 54.8,95.4 v6(55.05,95.4)
GPU_HDMI_TX_P1: length 117.8
  IN4 w0.056: v7(124.08,138.17) 124.16,138.08 124.32,138.08 124.38,138.14 124.38,141.28 120.7,144.95 103.93,144.95 103.75,145.13 100.69,145.13 100.18,145.64 98.39,145.64 97.86,146.17 97.86,146.4 97.23,147.03 96.39,147.03 96.13,146.78 88.19,146.78 87.43,147.54 85.66,147.54 84.9,147.54 84.23,148.21 83.3,148.21 82.63,147.54 75.56,147.54 74.87,146.84 74.87,145.89 74.3,145.32 72.13,145.32 68.54,141.73 66.6,141.73 61.64,136.77 61.64,121.75 57.83,117.94 57.83,103.33 56.85,102.34 56.85,98.73 55.82,97.7 55.82,96.5 55.94,96.38 56.08,96.38 v6(56.15,96.45)
GPU_HDMI_TX_P2: length 125.6
  IN4 w0.056: v6(54.05,96.45) 54.25,96.45 54.27,96.47 54.27,97.26 56.02,99.01 56.02,102.62 57.05,103.65 57.05,118.26 60.77,121.98 60.77,137 66.63,142.86 67.97,142.86 69.83,144.72 69.83,146.91 71.23,148.32 82.25,148.32 82.92,148.99 84.7,148.99 85.07,148.62 90.02,148.62 91.08,147.56 94.06,147.56 94.68,148.17 98.75,148.17 101.02,145.91 104.08,145.91 104.25,145.73 121.39,145.73 124.93,142.19 126.44,142.19 128.08,140.55 128.08,137.69 128.18,137.59 128.94,137.59 129.07,137.71 129.07,138 v7(128.84,138.23)
GPU_NVVDD_PSI#: length 48.1
  TOP w0.081: RG1579.1 63.63,76.02 63.63,74.32 63.06,73.75 63.06,72.62 RG1595.2 ; RG1579.1 62.82,76.23 RG15.1 ; RG1579.1 63.59,76.39 RG1578.2 63.59,77.17 63.67,77.25 v2(66.13,77.25) 67.64,77.25 67.87,77.47 v8(67.87,77.55)
  IN1 w0.058: v8(53.35,83.85) 53.28,83.85 52.7,84.42 52.7,85.05 52.25,85.51 51.72,85.51 51.5,85.73 51.5,88.38 54.81,91.7 57.37,91.7 58,92.33 58.75,92.33 59.16,92.74 61.73,92.74 61.92,92.54 63.22,92.54 66.38,89.39 67.03,89.39 67.36,89.06 67.36,88.4 69.16,86.61 69.16,82.6 67.92,81.36 67.92,78.93 67.65,78.66 67.65,77.76 v8(67.87,77.55)
GPU_OVERT#: length 52.7
  TOP w0.076: v6(78.36,14.6) 78.38,14.6 78.38,14.6 78.38,15.04 78.46,15.12 79,15.12 79.6,14.52 79.6,13.97 79.17,13.53 UE5.E5
  IN3 w0.058: v9(80.09,38.38) 80.11,38.4 80.11,38.99 79.9,39.21 79.9,41.14 79.9,41.27 80.11,41.49 80.11,43.03 79.88,43.26 79.88,43.82 79.88,43.83 79.88,43.93 79.61,44.2 79.61,53.36 79.42,53.55 79.42,53.55 79.04,53.93 79.04,57.03 v9(79.02,57.05)
  GND4 w0.081: v9(79.02,57.05) 78.99,57.05 78.81,57.24 v4(78.81,57.38) ; v6(79.92,38.19) 80.09,38.37 v9(80.09,38.38)
  IN4 w0.058: v6(79.92,38.19) 79.92,38.06 79.73,37.87 79.73,35.13 80.24,34.62 80.24,25.36 80.58,25.03 80.58,20.65 79.12,19.19 79.12,18.44
  IN4 w0.076: v6(78.36,14.6) 78.7,14.94 78.7,15.14 79.15,15.59 79.15,18.42 79.12,18.44
  BOTTOM w0.081: RG534.2 76.96,58.17 76.96,57.9 DG3.1 78.69,57.27 v4(78.81,57.38) 79.12,57.7 79.12,58.37 QG521.3
GPU_PWM1: length 72.8
  TOP w0.203: PUV1.11 72.22,26.21 71.93,26.21 71.73,26.41 v5(71.73,26.53)
  TOP w0.254: v1(69.1,24.09) 69.63,24.09 69.89,24.35 69.89,24.68 71.06,25.85 71.06,26.19 71.4,26.53 v5(71.73,26.53) ; PUV4.1 24.09,42.07 v5(23.85,41.82)
  GND2 w0.203: v1(69.1,24.09) v12(68.77,24.09)
  IN2 w0.203: v5(23.85,41.82) 24.7,41.82 24.96,41.57 24.96,37.56 26.37,36.15 28.44,36.15 29.59,37.3 29.59,39.27 30.7,40.38 32.06,40.38 32.08,40.35 45.37,40.35 45.45,40.43 45.79,40.43 45.86,40.35 48.82,40.35 50.89,38.28 50.89,34.37 50.5,33.98 50.5,32.35 51.33,31.51 51.33,30.72 52.78,29.27 52.78,27.62 53.34,27.07 56.11,27.07 56.4,26.77 57.38,26.77 60.86,23.29 62.79,23.29 64.41,24.92 67.94,24.92 v12(68.77,24.09)
  BOTTOM w0.081: v5(71.73,26.53) v2(71.06,26.53)
GPU_PWM2: length 54.4
  TOP w0.203: v1(69.1,24.92) 69.66,24.92 70.69,25.95 70.69,26.86 70.93,27.1 PUV1.10
  TOP w0.254: PUV5.1 31.65,41.78 v5(31.56,41.68)
  GND2 w0.203: v1(69.1,24.92) v12(68.71,24.92)
  IN2 w0.203: v5(31.56,41.68) 31.56,41.3 32.21,40.66 45.25,40.66 45.32,40.73 45.91,40.73 45.99,40.66 49.07,40.66 51.64,38.09 51.64,35.84 52.15,35.33 52.15,33.38 53.84,31.69 53.84,29.77 56.53,27.08 57.7,27.08 61.04,23.74 62.6,23.74 64.23,25.36 68.26,25.36 v12(68.71,24.92)
GPU_PWM3: length 46.3
  TOP w0.203: PUV1.9 70.9,27.5 70.28,26.89 v2(70.28,26.34) 70.28,25.97 70.05,25.75 v1(69.1,25.75)
  TOP w0.254: v5(39.24,41.72) 39.21,41.76 PUV6.1
  GND2 w0.203: v1(69.1,25.75) v12(68.77,25.75)
  IN2 w0.203: v5(39.24,41.72) 39.12,41.6 39.12,41.29 39.31,41.1 49.12,41.1 52.84,37.38 52.84,33.42 54.29,31.97 54.29,29.86 56.4,27.75 57.61,27.75 61.05,24.31 62.37,24.31 63.99,25.94 68.58,25.94 v12(68.77,25.75)
GPU_PWM4: length 36.3
  TOP w0.203: v1(69.1,26.57) 69.77,26.57 69.98,26.77 69.98,27.02 70.87,27.9 PUV1.8
  TOP w0.254: PUV7.1 46.83,41.77 v5(46.86,41.73)
  GND2 w0.203: v1(69.1,26.57) v12(68.71,26.57)
  IN2 w0.203: v12(68.71,26.57) 67.22,28.06 56.53,28.06 54.86,29.72 54.86,32.04 54.78,32.12 54.78,32.12 53.49,33.4 53.49,37.67 49.51,41.66 46.94,41.66 v5(46.86,41.73)
GPU_PWM5: length 28.5
  TOP w0.203: PUV1.7 70.64,28.3 v2(70.2,27.86) 69.74,27.4 v1(69.1,27.4)
  GND2 w0.203: v1(69.1,27.4) v12(68.77,27.4)
  GND2 w0.254: v1(54.51,42.42) v12(54.51,41.94)
  IN2 w0.203: v12(68.77,27.4) 67.75,28.41 60.33,28.41 58.05,30.69 58.05,33.51 57.8,33.76 57.8,38.37 54.51,41.66 v12(54.51,41.94)
GPU_PWM6: length 29
  TOP w0.203: v1(69.1,28.22) 69.57,28.22 70.05,28.7 PUV1.6
  TOP w0.254: v5(60.95,42.06) 61.3,42.42 PUV8.1
  GND2 w0.203: v1(69.1,28.22) v12(68.71,28.22)
  IN2 w0.203: v12(68.71,28.22) 66.78,30.15 64.24,30.15 63.59,29.5 60.06,29.5 58.52,31.04 58.52,33.77 58.24,34.05 58.24,34.36 58.24,34.36 58.24,39.79 59.05,40.6 59.49,40.6 v5(60.95,42.06)
GPU_PWM7: length 35.5
  TOP w0.203: PUV1.5 69.16,29.1 v1(69.1,29.05)
  GND2 w0.203: v1(69.1,29.05) v12(68.77,29.05) ; v1(69.81,42.42) v12(69.81,42.16)
  IN2 w0.203: v12(68.77,29.05) 67.28,30.53 63.8,30.53 63.13,29.86 60.21,29.86 58.83,31.24 58.83,33.9 58.55,34.18 58.55,39.4 59.31,40.16 68.33,40.16 69.81,41.65 v12(69.81,42.16)
GPU_PWM8: length 94.9
  TOP w0.203: v8(69.1,29.87) 69.28,29.87 69.65,29.5 v2(70.21,29.5) PUV1.4
  TOP w0.254: v5(71.35,79.53) 72.27,78.61 PUV11.1
  IN1 w0.203: v8(69.1,29.87) 69.1,29.63 69.62,29.11 69.62,22.33 71.26,20.69 75.5,20.69 75.76,20.94 78.49,20.94 78.68,21.14 80.03,21.14 80.25,20.92 80.66,20.92 81.79,22.05 82.11,22.05 83.36,23.3 83.36,26.57 83.9,27.1 83.9,35.33 83.22,36.01 82.11,36.01 81.48,36.63 81.48,38.05 v11(80.96,38.57)
  GND2 w0.203: v11(80.96,38.57) v12(80.77,38.76)
  IN2 w0.203: v5(71.35,79.53) 71.87,79.53 72.25,79.15 73.41,79.15 73.48,79.07 79.17,79.07 80.54,77.7 80.54,70.17 79.83,69.45 79.83,57.27 79.97,57.13 79.97,57.07 80.45,56.6 80.45,41.98 80.72,41.71 80.72,41.07 80.42,40.77 80.42,39.12 v12(80.77,38.76)
GPU_STRAP5_EC: length 22.7
  TOP w0.076: UE5.F10 79.67,15.94 79.91,16.19 79.91,16.97 79.77,17.11 79.56,17.11 79.42,17.26 79.42,17.51 79.12,17.81 79.12,18.44
  TOP w0.081: 79.12,18.44 v1(79.12,18.79) ; v2(85.94,29.18) 85.97,29.15 85.97,29.15 86.06,29.07 v1(86.06,28.78) 84.25,28.78 84.03,28.55 QG516.2
  GND2 w0.081: v12(85.88,28.59) 86.06,28.76 v1(86.06,28.78) ; v1(79.12,18.79) v12(79.12,19.2)
  IN2 w0.058: v12(79.12,19.2) 78.73,19.6 78.73,20.61 80.04,21.92 83.92,21.92 84.45,22.46 84.45,23.37 85.78,24.7 85.78,28.51 85.86,28.59 v12(85.88,28.59)
GSYNC_ID: length 5.8
  TOP w0.081: 101.29,22.69 RH30.1 RH29.1
  TOP w0.089: 101.29,22.69 101.41,22.81 101.41,23.14 100.84,23.71 100.84,24.16 101.48,24.8 101.48,25.67 100.7,26.45 UH1.BE17
GT_SW1: length 2.7
  TOP w0.081: 150.6,91.57 150.6,91.29 v2(151.27,90.62)
  BOTTOM w0.508: PRG04.1 144.89,89.8 v5(145.54,90.45)
H_CATERR#: length 5.4
  TOP w0.081: RC693.2 138.81,106.33 138.4,105.92 134.5,105.92 UC1.BM30
H_CPUPWRGD: length 150.6
  TOP w0.081: v1(139.31,108.04) 138.34,108.04 137.94,107.64 137.5,107.64 UC1.BT31
  TOP w0.122: UH1.AE3 94.24,36.41 v5(94.36,36.53)
  GND2 w0.081: v1(139.31,108.04) v12(139.78,108.04)
  IN2 w0.058: v12(139.78,108.04) 140.13,108.39 140.13,112.34 137.18,115.28 128.41,115.28 127.74,115.94 126.16,115.94 125.51,115.3 115.09,115.3 113.93,116.46 101.04,116.46 100.95,116.36 100.95,116.36 100.85,116.27 99.95,115.37 91.17,115.37 90.64,114.84 v3(87.11,114.84)
  IN3 w0.058: v3(87.11,114.84) 87.11,114.18 86.73,113.81 86.73,106.83 89.64,103.92 89.64,101.15 90.59,100.19 90.59,97.26 89.29,95.96 89.29,91.57 90.65,90.21 90.65,84.43 86.94,80.72 86.94,53.4 89.23,51.11 89.23,48.53 89.74,48.02
  IN3 w0.089: 89.74,48.02 90.93,46.82 90.93,39.95 v5(94.36,36.53)
  BOTTOM w0.089: v5(94.36,36.53) 94.19,36.7 v10(93.81,36.7)
H_DRAMRST#: length 52.8
  TOP w0.089: v8(115.98,27.04) 115.98,27.17 115.71,27.44 115.71,27.44 115.63,27.53 UH1.BB46
  IN1 w0.058: v6(123.34,35.11) 121.97,35.11 121.06,34.19 119.61,34.19 119.3,33.89 119.3,29.92 119.04,29.66 117.29,29.66 117.24,29.7
  IN1 w0.089: 117.24,29.7 116.99,29.95 115.75,29.95 115.34,29.54 115.34,28.98 115.98,28.34 v8(115.98,27.04)
  IN4 w0.058: v7(139.52,56.86) 138.88,56.22 v7(138.88,55.93) ; v6(123.34,35.11) 122.81,35.64 122.81,44.22 124.49,45.9 136.04,45.9 138.31,48.18 138.31,49.26 138.76,49.7 138.76,55.36 v7(138.88,55.49)
  BOTTOM w0.081: RD31.2 v7(139.52,56.86) ; v7(138.88,55.93) v7(138.88,55.49)
H_PECI: length 154.1
  TOP w0.081: RH73.2 87.76,35.52 87.12,36.16 87.12,37.04 87.12,37.49 84.86,39.75 84.86,43.65 83.11,45.41 83.11,52.53 83.11,52.53 83.11,52.98 83.11,53.21 83.04,53.28 83.04,53.37 81.93,54.47 81.93,60.96 81.93,60.96 81.93,67.81 v8(82.07,67.95) ; v8(81.45,71.16) 81.45,72.15 82.04,72.75 82.04,72.99 85.12,76.07 85.12,87.36 v2(84.94,87.54) 83.69,88.79 83.69,101.6 79.78,105.51 79.78,108.8 78.69,109.9 v1(78.69,112.78)
  TOP w0.089: RH1022.2 139.76,109.15 v1(138.42,109.15) 137.75,108.48 UC1.BT34
  IN1 w0.058: v8(81.45,71.16) 81.45,70.83 81.69,70.59 81.69,68.33 v8(82.07,67.95)
  GND2 w0.081: v12(138.56,109.5) 138.56,109.29 v1(138.42,109.15) ; v1(78.69,112.78) 78.84,112.93 78.99,112.93 v12(78.99,112.93)
  IN2 w0.058: v12(138.56,109.5) 138.65,109.5 138.71,109.56 138.71,110.12 137.7,111.12 137.7,112.75 136.43,114.02 114.56,114.02 113.4,115.18 102.95,115.18 101.02,113.24 95.97,113.24 95.45,112.72 81.87,112.72 81.64,112.48 80.1,112.48 79.65,112.93 79,112.93 v12(78.99,112.93)
H_PM_DOWN: length 233.8
  TOP w0.089: v5(94.59,35.55) 94.63,35.6 94.63,35.72 94.51,35.85 94.07,35.85 93.7,36.22 UH1.AE2
  IN1 w0.058: v3(143.76,112.63) 143.76,111.18 142.06,109.47 142.06,108.32 142.05,108.3 v8(142.05,108.05)
  IN2 w0.058: v3(81.46,115.07) 81.29,114.9 70.99,114.9 70.47,114.38 v6(70.47,114.33)
  IN3 w0.058: v3(81.46,115.07) 81.46,115.18 81.78,115.5 81.78,116.02 81.12,116.68 81.12,130.01 81.12,130.15 83.29,132.33 83.38,132.33 84.92,133.87 85.87,133.87 86.63,134.63 88.38,134.63 89.87,136.11 92.52,136.11 93.23,136.83 96.69,136.83 97.86,137.99 100.43,137.99 101.18,137.24 105.02,137.24 105.91,136.36 107.71,136.36 108.4,137.05 120.47,137.05 121.2,137.78 144.24,137.78 144.56,137.46 146.08,137.46 146.63,136.91 146.63,135.89 147.83,134.7 149.66,134.7 150.47,133.88 150.47,132.97 150.14,132.64 150.14,131.3 149.63,130.79 149.63,121.35 146.18,117.91 145.59,117.91 144.31,116.63 144.31,113.07 143.87,112.63 v3(143.76,112.63)
  IN4 w0.058: v6(70.47,114.33) 70.42,114.33 69.91,113.82 67.5,113.82 66.28,112.6 66.28,111.01 64.66,109.4 64.66,100.82 67.89,97.59 67.89,93.28 68.24,92.93 68.24,90 68.88,89.36 68.88,87.86 68.51,87.48 68.51,82.81 69.11,82.21 69.11,80.79 70.79,79.11 70.79,75.65 71.55,74.9 71.55,72.94 79.7,64.78 79.7,58.11 80.25,57.56 80.25,49.41 79.91,49.07 79.91,45.49 86.55,38.86 88.99,38.86 90.32,37.54
  IN4 w0.089: 90.32,37.54 91.47,36.39 93.31,36.39 94.15,35.55 v5(94.59,35.55)
  BOTTOM w0.089: RH14.1 93.9,35.55 v5(94.59,35.55) v2(95.25,35.55)
H_PM_SYNC: length 152.1
  TOP w0.076: UC1.BM34 134.61,108.95 135.89,108.95 135.97,108.86 137.34,108.86 v1(137.34,108.86)
  TOP w0.081: v8(82.12,68.38) 82.34,68.16 82.34,67.1 82.12,66.88 82.12,54.69 83.22,53.59 83.22,53.35 83.29,53.28 83.29,53.06 83.29,52.45 83.29,52.45 83.29,45.48 85.04,43.73 85.04,39.83 87.31,37.57 87.31,36.96 87.31,36.66 87.62,36.35 RH15.2 ; v1(78.97,112.55) 79.15,112.37 79.15,110.34 v2(79.45,110.04) 79.97,109.52 79.97,105.58 83.9,101.65 83.9,89.11 85.3,87.7 85.3,75.9 82.4,73 82.4,72.71 81.72,72.04 v8(81.72,70.93)
  IN1 w0.058: v8(82.12,68.38) 82.04,68.46 82.04,70.61 v8(81.72,70.93)
  GND2 w0.081: v12(137.54,109.06) v1(137.34,108.86) ; v12(79.25,112.58) 79.25,112.56 78.98,112.56 v1(78.97,112.55)
  IN2 w0.058: v12(137.54,109.06) 137.54,110.27 137.56,110.29 137.56,112.65 137.54,112.66 137.54,112.68 136.37,113.86 114.5,113.86 113.34,115.02 103.02,115.02 101.1,113.09 96.03,113.09 95.5,112.56 81.94,112.56 81.7,112.32 80.04,112.32 79.8,112.56 79.25,112.56 v12(79.25,112.58)
H_PM_SYNC_R: length 4.8
  TOP w0.089: 90.62,36.39 92.89,36.39 93.1,36.18 93.15,36.18 93.48,35.86 93.75,35.86 93.99,35.61 UH1.AF3
  TOP w0.114: 90.62,36.39 89.71,36.39 RH15.1
H_PROCHOT#: length 299.6
  TOP w0.081: RH158.1 140.27,107.1 PCB35.1 ; RH165.2 141.54,106.64 141.14,107.05 141.14,107.06 PCB35.1 ; PRB17.1 v2(50.18,15.89) v1(50.8,15.27) ; QE2.1 77,6.91 77.1,7.01 v4(77.39,7.01) ; v1(137.55,107.33) 137.54,107.33 137.54,107.34 138.13,107.34 138.38,107.6 140.6,107.6 PCB35.1
  TOP w0.254: PRZ28.2 148.34,123.52 v5(148.34,123.05) ; v5(20.83,2.25) PR34.2 20.08,2.87 19.19,3.76 19.19,3.91 PQ5.1
  IN1 w0.058: v1(137.55,107.33) 137.54,107.33 137.54,107.34 137.56,107.34 137.62,107.4 137.62,109.12 138.38,109.88 138.38,111.06 138.57,111.25 138.57,111.94 140.58,113.94 140.58,116.96 140.71,117.09 140.71,120.21 142.67,122.18 147.46,122.18 v5(148.34,123.05)
  GND2 w0.081: v12(137.37,107.51) 137.41,107.51 137.41,107.47 137.54,107.34 137.54,107.33 v1(137.55,107.33) ; v12(50.55,15.01) v1(50.8,15.27)
  IN2 w0.058: v12(50.55,15.01) 50.42,14.89 50.42,11 48.49,9.07 45.92,9.07 45.52,8.66 45.52,5.5 47.13,3.89 v3(47.98,3.89) ; v12(137.37,107.51) 136.83,108.05 136.83,110.82 137.26,111.25 137.26,112.51 136.23,113.54 114.37,113.54 113.2,114.7 103.15,114.7 101.26,112.8 96.16,112.8 95.59,112.24 82.26,112.24 82,111.98 v3(79.31,111.98) ; 80.54,10.57 79.17,9.2 79.17,8.21 78.28,7.32 77.7,7.32 v4(77.39,7.01) ; 83.8,18.44 83.8,20.38 86.84,23.42 86.84,29.68 86.56,29.95 86.56,30.94 86.71,31.09 86.71,43.37 84.59,45.48 84.59,51.12 87,53.53 87,56.09 85.43,57.66 85.43,57.75 84.89,58.29 84.89,81.4 85.43,81.95 85.43,83.9 85.1,84.24 85.1,85.4 v3(85.72,86.03)
  IN2 w0.076: 80.54,10.57 80.77,10.8 80.77,11.64 82.31,13.17 82.31,14.04 82.47,14.2 82.78,14.2 83.08,14.51 83.08,16.46 83.8,17.18 83.8,18.44
  IN3 w0.058: v5(20.83,2.25) 21.07,2.01 22.82,2.01 24.82,4.01 31,4.01 31.86,4.87 38.87,4.87 40.35,6.34 42.78,6.34 43.52,6.2 44.22,5.91 44.36,5.81 44.85,5.49 46.35,3.99 47.88,3.99 v3(47.98,3.89) 48.55,3.89 49.78,2.65 64.73,2.65 65.3,3.22 70.06,3.22 70.17,3.34 76.45,3.34 76.77,3.02 77.28,3.02 v9(77.47,3.2) ; v3(79.31,111.98) 79.58,111.71 79.58,108.27 85.57,102.28 85.57,87.33 86.08,86.83 86.08,86.39 v3(85.72,86.03)
  GND4 w0.081: v4(77.7,3.33) 77.7,3.3 77.6,3.2 v9(77.47,3.2)
  BOTTOM w0.081: v4(77.39,7.01) 77.39,6.45 77.7,6.15 v4(77.7,3.33)
  BOTTOM w0.254: PRZ73.2 148.54,123.26 v5(148.34,123.05)
H_THERMTRIP#: length 89.3
  TOP w0.076: v5(101.57,107.2) 101.24,106.86 UC1.J31
  TOP w0.081: RH79.2 88.28,37.2 88.15,37.33 87.94,37.33 85.23,40.05 85.23,43.8 83.47,45.56 83.47,52.37 83.47,52.38 83.47,53.13 83.47,53.36 83.4,53.43 83.4,53.89 82.32,54.97 82.32,66.65 82.52,66.86 82.52,69.09 84,70.57 84,71.02 84,71.02 84,72.22 84.28,72.5 88.85,72.5 91.15,74.8 v2(91.15,78.25) 91.15,79.09 v8(91.08,79.15)
  IN1 w0.097: v5(101.57,107.2) 101.57,106.82 101.46,106.71 101.46,95.2 100.08,93.82 96.86,93.82 96.65,93.61 96.65,88.36 96.33,88.04 96.33,86.1 96.76,85.67 96.76,85.24 94.42,82.9 92.2,82.9 91.19,81.88 91.19,79.25 v8(91.08,79.15)
  BOTTOM w0.254: RH163.2 102.15,106.62 v5(101.57,107.2)
H_THERMTRIP#_R: length 4.1
  TOP w0.089: UH1.AD3 93.88,36.8 93.64,36.57 91.88,36.57 91.63,36.82 v2(91.2,36.82) 90.95,37.07 90.41,37.07 90.32,37.16
  TOP w0.114: RH79.1 90.32,37.16
H_VCCST_PWRGD: length 104.3
  TOP w0.081: v4(90.02,88.72) 89.59,88.29 89.59,88.09 87.29,85.79 87.29,85.57 87.29,83 88.66,81.63 88.66,80.53 89.31,79.89 89.31,74.5 88.69,73.88 83.53,73.88 82.73,73.08 82.73,71.18 80.32,68.77 80.32,67.84 79.69,67.21 79.69,54.32 81.56,52.46 81.56,45.04 81.56,44.89 83.41,43.04 83.41,38.78 81.75,37.12 81.75,36 82.17,35.58 82.17,33.17 82.5,32.84 Q7.3 82.98,32.48 v6(82.98,32.24)
  IN4 w0.058: 84.2,13.71 86.36,15.87 86.36,26.19 83.24,29.31 83.24,31.98 v6(82.98,32.24)
  IN4 w0.076: v6(81.67,11.36) 81.89,11.58 82.08,11.58 84.2,13.71
  BOTTOM w0.081: RH154.1 97.03,91.21 97.46,90.78 CH193.1 ; v4(90.02,88.72) 90.62,88.72 93.04,91.14 v10(93.79,91.14) 95.32,91.14 96.14,90.32 CH193.1 ; RH164.2 97.46,89.63 CH193.1
HDA_BIT_CLK: length 6.4
  TOP w0.081: RH1031.2 96.33,22.23 96.77,22.67 96.95,22.67 96.97,22.69
  TOP w0.089: UH1.BD11 98.13,27.06 98.26,26.93 98.26,26.55 98.25,26.54 98.25,26.35 ; 96.97,22.69 v5(97.68,23.4)
  TOP w0.122: v5(97.68,23.4) 97.68,23.4 98.5,24.23 98.5,24.92 98.28,25.15 98.28,26.33 98.25,26.35
HDA_BIT_CLK_R: length 110.5
  TOP w0.081: RH1031.1 v1(96.33,20.55)
  GND2 w0.081: v1(96.33,20.55) v12(96.33,20.28)
  IN2 w0.058: v3(78.42,4.03) 80.93,4.03 81.15,3.81 84.52,3.81 85.74,5.02 87.66,5.02 89.13,6.49 89.13,8.41 89.73,9.01 89.73,11.01 89.92,11.2 93.54,11.2 95,12.66 97.92,12.66 98.49,13.24 98.49,15.99 96.93,17.54 96.93,18.54 96.19,19.28 96.19,20.15 v12(96.33,20.28)
  IN3 w0.058: v9(10.29,7.27) 11.41,7.27 12.11,6.57 12.11,6.01 12.89,5.22 21.47,5.22 21.64,5.39 26.3,5.39 26.92,6.01 31.55,6.01 31.73,5.83 38.48,5.83 39.97,7.33 44.36,7.33 44.39,7.35 44.71,7.35 44.74,7.38 45.49,7.38 45.83,7.72 50.56,7.72 54.67,3.61 64.09,3.61 64.68,4.2 69.68,4.2 69.78,4.3 78.15,4.3 v3(78.42,4.03)
  GND4 w0.081: v4(9.84,7.21) 9.9,7.27 v9(10.29,7.27)
  BOTTOM w0.081: JIO1.C4 8.86,8.19 v4(9.84,7.21)
HDA_RST#: length 5.7
  TOP w0.081: RP2.6 98.65,22.69
  TOP w0.089: 98.65,22.69 98.65,23.24 v5(98.74,23.34)
  TOP w0.122: v5(97.8,24.36) 97.83,24.39 97.83,25.67 97.43,26.06 97.43,26.45 97.52,26.53 UH1.BE10
  BOTTOM w0.089: v5(98.74,23.34) 98.74,23.46 98.34,23.86 v2(98.25,23.86) 98,23.86 97.91,23.95 97.91,24.24 v5(97.8,24.36)
HDA_RST#_R: length 111.5
  TOP w0.081: RP2.3 98.65,21.1 v3(98.56,21.19)
  IN3 w0.058: 77.34,18.44 77.77,18.88 80.6,18.88 80.72,19 85.14,19 86.96,20.82 98.13,20.82 98.5,21.19 v3(98.56,21.19) ; v9(10.03,13.74) 10.03,13.5 12.08,11.45 12.08,9.86 16.08,5.86 21.2,5.86 21.38,6.04 26.03,6.04 26.87,6.87 30.74,6.87 32.83,8.96 39.59,8.96 39.88,9.24 50.85,9.24 54.82,5.27 58.34,5.27 58.88,4.73 63.63,4.73 64.22,5.32 69.22,5.32 69.31,5.42 74.29,5.42 74.77,5.9 74.77,6.19 75.16,6.58 75.67,6.58 76.83,7.75 76.83,10.57
  IN3 w0.076: 77.34,18.44 77.12,18.22 77.12,11.21 76.83,10.93 76.83,10.57
  GND4 w0.081: v4(9.84,14.19) 10.03,14 v9(10.03,13.74)
  BOTTOM w0.081: JIO1.F3 9.46,13.81 v4(9.84,14.19)
HDA_SDIN: length 113.5
  TOP w0.089: 97.67,23.82 97.38,23.82 v2(97.33,23.78) 96.82,23.27 v5(96.2,23.27)
  TOP w0.122: UH1.BE11 98.04,25.09 98.29,24.84 98.29,24.32 97.8,23.82 97.67,23.82
  IN3 w0.058: 95.62,22.69 94.11,21.17 86.86,21.17 85.01,19.32 80.59,19.32 80.47,19.2 77.64,19.2 76.89,18.44 ; 76.58,11.29 76.41,11.13 76.41,7.78 75.81,7.18 73.03,7.18 72.77,6.92 72.77,6.63 72.04,5.9 69.11,5.9 69.02,5.81 58.71,5.81 58.6,5.91 55.08,5.91 51.12,9.88 39.61,9.88 39.33,9.6 28.25,9.6 27.18,8.53 21.94,8.53 20.32,6.91 15.72,6.91 12.56,10.06 12.56,11.65 11.05,13.16 11.05,14.76 10.94,14.86 10.94,15.58 v4(11.13,15.76)
  IN3 w0.076: 76.89,18.44 76.84,18.39 76.8,18.35 76.8,11.51 76.58,11.29
  IN3 w0.089: 95.62,22.69 v5(96.2,23.27)
  BOTTOM w0.081: v4(11.13,15.76) 10.97,15.76 10.66,16.08 JIO1.H1
HDA_SDOUT: length 8.5
  TOP w0.081: RH16.2 95.92,20.09 96.71,20.09 96.96,20.35 96.96,21.53 97.27,21.84 RP2.8 97.65,22.69
  TOP w0.089: 98.05,23.1 97.65,22.69
  TOP w0.122: 98.05,23.1 98.05,23.48 98.71,24.14 98.71,25.01 98.49,25.24 98.49,25.94 UH1.BF12
HDA_SDOUT_R: length 109
  TOP w0.081: RP2.1 97.65,21.01 v3(97.4,21.26)
  IN3 w0.058: v3(97.4,21.26) 97.13,21 86.91,21 85.08,19.16 80.66,19.16 80.53,19.04 77.71,19.04 77.11,18.44 ; 76.58,10.98 76.57,10.97 76.57,7.71 75.81,6.95 73.32,6.95 72.1,5.74 69.18,5.74 69.09,5.65 58.64,5.65 58.54,5.75 55.02,5.75 51.05,9.72 39.68,9.72 39.4,9.44 28.74,9.44 27.67,8.37 22,8.37 19.82,6.18 16.22,6.18 12.4,10 12.4,11.58 10.79,13.19 10.79,13.87 v9(10.79,13.87)
  IN3 w0.076: 76.58,10.98 76.96,11.35 76.96,18.28 77.11,18.44
  GND4 w0.081: v9(10.79,13.87) 10.79,13.87 10.79,14 v4(10.6,14.19)
  BOTTOM w0.081: v4(10.6,14.19) 10.66,14.13 JIO1.F1
HDA_SPKR: length 141.8
  TOP w0.122: v5(106.8,28.22) 106.7,28.32 106.7,29.08 UH1.AW29
  IN3 w0.058: v9(79.65,7) 79.41,7 78.79,6.38 78.79,3.92 78.56,3.69 78.28,3.69 77.84,4.14 69.84,4.14 69.75,4.04 64.75,4.04 64.16,3.45 50.42,3.45 46.95,6.92 45.66,6.92 45.36,7.22 44.8,7.22 44.78,7.19 44.46,7.19 44.43,7.17 40.04,7.17 38.54,5.67 31.66,5.67 31.48,5.85 26.98,5.85 26.36,5.23 21.71,5.23 20.78,4.3 15.75,4.3 15.1,4.95 12.94,4.95 11.95,5.94 11.95,6.51 11.44,7.01 9.81,7.01 8.59,8.23 6.34,8.23 5.59,8.98 5.59,12.47 5.71,12.6 v9(8.76,12.6)
  GND4 w0.081: v9(8.76,12.6) 8.83,12.6 v4(9.02,12.41) ; v6(79.95,7.25) 79.95,7.23 79.72,7 v9(79.65,7)
  IN4 w0.058: v6(79.95,7.25) 81.78,7.25 82.07,7.55 84.6,7.55 85.09,8.04 85.09,9.85 85.37,10.12 86.22,10.12 87.64,11.55 87.64,12.46 88.46,13.28 89.38,13.28 90.1,14 90.1,16.95 91.21,18.06 93.95,18.06 94.57,18.68 99.72,18.68 99.99,18.95 102.39,18.95 103.26,18.09 104.04,18.09 104.72,18.77 104.72,20.01 107.25,22.53 107.25,22.69
  IN4 w0.089: 107.25,22.69 107.25,22.95 107,23.21 107,25.85 106.45,26.39 105.94,26.39 105.66,26.67 105.66,28.45 105.92,28.7 106.32,28.7 v5(106.8,28.22)
  BOTTOM w0.081: v4(9.02,12.41) 8.86,12.57 JIO1.F4
  BOTTOM w0.089: v5(106.8,28.22) 106.99,28.04 v2(108.13,28.04) 108.26,28.04 108.63,27.67 RH600.1
HDA_SYNC: length 4.1
  TOP w0.081: 98.15,22.69 RP2.7
  TOP w0.114: 98.15,22.71 98.15,22.69
  TOP w0.122: 98.15,22.71 98.15,22.8 98.37,23.02 98.37,23.5 98.92,24.05 98.92,25.29 UH1.BG13
HDA_SYNC_R: length 110.9
  TOP w0.081: v3(97.92,20.16) 98.15,20.39 RP2.2
  IN3 w0.058: v3(97.92,20.16) 97.92,20.35 97.64,20.63 87,20.63 85.21,18.84 80.79,18.84 80.67,18.72 77.84,18.72 77.57,18.44 ; 78.74,10.57 78.74,7.78 79.2,7.32 79.2,7.01 78.63,6.44 78.63,5.32 77.76,4.46 69.71,4.46 69.61,4.36 64.61,4.36 64.03,3.77 58.17,3.77 57.79,4.15 54.35,4.15 50.62,7.88 45.77,7.88 45.43,7.54 44.67,7.54 44.64,7.51 44.32,7.51 44.3,7.49 39.9,7.49 38.41,5.99 31.79,5.99 31.61,6.17 26.85,6.17 26.23,5.55 21.57,5.55 21.4,5.38 12.96,5.38 12.27,6.08 12.27,6.64 11.42,7.49 11.26,7.49 11.1,7.65 10.55,7.65 v9(9.74,8.46)
  IN3 w0.076: 78.74,10.57 78.74,10.67 78.61,10.8 78.61,11.86 78.51,11.97 78.51,13.21 77.28,14.44 77.28,18.15 77.57,18.44
  GND4 w0.081: v9(9.74,8.46) v4(9.46,8.74)
HDMI_C_CLKN: length 2.3
  BOTTOM w0.066: RX33.1 CV1057.1 138.94,138.9 138.37,139.47 138.37,139.99 LV3.1 138.53,140.16 RV641.1
HDMI_C_CLKP: length 2.2
  BOTTOM w0.066: RX34.1 CV1058.1 138.3,139.03 137.92,139.41 137.92,139.93 LV3.4 137.69,140.16 RV640.1
HDMI_C_TX_N0: length 2
  BOTTOM w0.066: RV643.1 134.21,140.16 LV4.1 134.11,138.94 CV1060.1 RX31.1
HDMI_C_TX_N1: length 2.1
  BOTTOM w0.066: RV642.1 124.75,140.1 LV5.1 124.58,138.88 CV1062.1 RX35.1
HDMI_C_TX_N2: length 2.1
  BOTTOM w0.066: RX37.1 CV1064.1 129.35,138.94 LV6.1 129.51,140.16 RV645.1
HDMI_C_TX_P0: length 2
  BOTTOM w0.066: RV646.1 133.5,140.16 LV4.4 133.61,138.88 CV1059.1 RX32.1
HDMI_C_TX_P1: length 2
  BOTTOM w0.066: RX36.1 CV1061.1 124.08,138.75 LV5.4 123.91,140.1 RV639.1
HDMI_C_TX_P2: length 2
  BOTTOM w0.066: RV638.1 128.68,140.16 LV6.4 128.85,138.82 CV1063.1 RX38.1
HDMI_CLKN: length 8.4
  BOTTOM w0.066: RV673.2 138.18,144.37 138.18,145.85 137.49,146.54 132.93,146.54 132.85,146.61 132.85,146.73 JHDMI.12
HDMI_CLKP: length 8.4
  BOTTOM w0.066: JHDMI.10 132.65,146.83 132.65,146.52 132.84,146.33 137.41,146.33 137.97,145.76 137.97,145.28 v13(137.97,145.28) 137.97,145.28 137.97,144.43 RV674.2
HDMI_CTRL_CLK: length 9.3
  TOP w0.066: RV651.1 139.19,143.54 138.95,143.78 138.15,143.78 138.01,143.92 138.01,144.26 137.66,144.6 137.01,144.6 v5(136.82,144.8)
  IN2 w0.056: JHDMI.15 134.99,146.24 135.07,146.28 137.53,146.28 137.82,145.99 137.82,144.82 137.6,144.61 137.01,144.61 v5(136.82,144.8)
HDMI_CTRL_CLK_R: length 2
  TOP w0.066: RV651.2 RV649.1 138.55,142.13 QV96.3
HDMI_CTRL_DAT: length 9.5
  TOP w0.066: v5(136.82,144.21) 137.01,144.4 137.58,144.4 137.81,144.17 137.81,143.89 137.63,143.72 136.94,143.72 136.65,143.43 RV650.1
  IN2 w0.056: JHDMI.16 135.11,146.62 135.17,146.5 135.21,146.49 137.62,146.49 138.02,146.08 138.02,144.73 137.69,144.4 137.01,144.4 v5(136.82,144.21)
HDMI_CTRL_DAT_R: length 4.8
  TOP w0.066: RV650.2 RV653.1 137.48,142 137.21,141.73 136.4,141.73 v2(135.67,141.01) 135.67,140.95 QV96.6
HDMI_DOWN: length 26
  TOP w0.081: v5(131.8,139.58) 132.46,139.58 QX1.1
  IN3 w0.058: v9(140.14,138.95) 140.21,138.95 140.21,138.95 v9(136.84,138.95) 136.22,139.58 v5(131.8,139.58) 131.19,138.96 v9(127.64,138.96)
  GND4 w0.081: v9(140.14,138.95) 140.21,138.95 140.21,138.95 140.39,138.95 v4(140.4,138.96) ; v9(127.64,138.96) v4(127.38,138.96) ; v4(136.84,138.96) v9(136.84,138.95)
  IN4 w0.058: v4(127.38,138.96) 125.89,137.47 123.66,137.47 122.62,138.51 v7(122.62,138.96)
  BOTTOM w0.081: LX7.2 LX2.2 132.14,139.23 v5(131.8,139.58) 131.7,139.58 v2(131.2,140.07) ; LX1.2 v4(136.84,138.96) ; v4(127.38,138.96) LX5.2
HDMI_HPD: length 8.8
  TOP w0.081: v8(129.84,143.22) RX6.2
  IN1 w0.058: v8(129.84,143.22) 131.76,143.22 132.97,144.43 135.55,144.43 JHDMI.19
HDMI_HPD_PCH: length 199.3
  TOP w0.081: v3(128.37,139.37) 128.14,139.6 128.14,141 128.45,141.3 QX3.3 127.46,141.95 UX2.1 127.27,142.39 RX8.1
  TOP w0.089: UH1.BD21 102.98,27.15 102.55,27.58 102.11,27.58 101.51,28.18 v5(101.51,28.82)
  IN2 w0.058: v6(67.67,115.69) 67.75,115.78 70.9,115.78 71.3,115.38 80.28,115.38 80.65,115.75 v3(80.65,115.91)
  IN3 w0.058: v3(128.37,139.37) 127.05,139.37 126.59,138.92 125.43,138.92 125.01,138.5 115.02,138.5 114.46,137.94 110.31,137.94 109.91,137.53 108.2,137.53 108.2,137.53 107.51,136.84 106.1,136.84 104.47,138.47 97.58,138.47 96.42,137.31 90.38,137.31 88.19,135.11 86.43,135.11 85.67,134.35 83.26,134.35 80.63,131.72 80.63,131.58 80.63,116.49 80.7,116.42 80.7,115.97 v3(80.65,115.91)
  IN4 w0.058: 90.32,34.36 88.86,35.82 88.86,36.8 88.07,37.59 86.46,37.59 78.95,45.1 78.95,49.46 79.29,49.8 79.29,54.55 77.93,55.91 77.93,63.27 76.87,64.34 76.87,66.39 70.42,72.83 70.42,75.12 70.15,75.39 70.15,78.84 68.47,80.53 68.47,81.95 67.81,82.61 67.81,84.53 67.35,84.99 67.35,88.25 67.58,88.48 67.58,92.69 67.25,93.02 67.25,96.74 64.15,99.85 64.15,109.77 65.69,111.31 65.69,113.72 v6(67.67,115.69)
  IN4 w0.089: v5(101.51,28.82) 101.51,29.01 100.68,29.83 100.68,30.22 100.38,30.52 100.38,31.99 99.95,32.41 97.6,32.41 97.04,32.97 95.62,32.97 95.56,32.91 91.76,32.91 90.32,34.36
HDMI_L_CLKN: length 2.2
  BOTTOM w0.066: RV673.1 138.56,142.32 RV500.2 138.36,142.12 LV3.2 138.53,141.07 RV641.2
HDMI_L_CLKP: length 2.2
  BOTTOM w0.066: RV674.1 137.54,142.32 RV500.1 137.86,142 LV3.3 137.69,141.07 RV640.2
HDMI_L_TX_N0: length 2.2
  BOTTOM w0.066: RV27.1 134.32,143.13 RV501.2 134.11,142.12 LV4.2 134.11,141.27 RV643.2
HDMI_L_TX_N1: length 2.2
  BOTTOM w0.066: RV642.2 124.75,141.01 LV5.2 124.58,142 RV502.2 124.79,143 RV29.1
HDMI_L_TX_N2: length 2.1
  BOTTOM w0.066: RV645.2 129.51,141.07 LV6.2 129.35,142 RV503.2 129.54,142.22 RV33.1
HDMI_L_TX_P0: length 2.3
  BOTTOM w0.066: RV28.1 133.4,143.09 RV501.1 133.61,142.12 LV4.3 133.61,141.27 RV646.2
HDMI_L_TX_P1: length 2.2
  BOTTOM w0.066: RV639.2 123.92,141.01 LV5.3 124.08,142 RV502.1 123.88,143 RV30.1
HDMI_L_TX_P2: length 2.1
  BOTTOM w0.066: RV638.2 128.68,141.07 LV6.3 128.85,142 RV503.1 128.59,142.26 RV34.1
HDMI_TX_N0: length 4.3
  BOTTOM w0.066: RV27.2 133.93,144.43 133.93,144.74 133.72,144.95 132.65,144.95 132.65,144.95 132.01,144.95 132,144.95 131.53,144.95 131.4,145.08 131.4,145.28 JHDMI.9
HDMI_TX_N1: length 8.1
  BOTTOM w0.066: JHDMI.6 129.92,146.8 129.92,146.59 129.67,146.33 127.13,146.33 126.72,145.92 126.72,145.48 v13(126.15,144.91) 125.86,144.62 124.52,144.62 124.43,144.53 124.43,144.28 RV29.2
HDMI_TX_N2: length 2.5
  BOTTOM w0.066: RV33.2 129.17,144.3 129.17,144.58 128.87,144.88 128.67,144.88 128.41,145.15 128.41,145.29 JHDMI.3
HDMI_TX_P0: length 4.3
  BOTTOM w0.066: RV28.2 133.73,144.44 133.73,144.65 133.64,144.74 v13(132.3,144.74) 131.44,144.74 131.19,145 131.19,145.29 JHDMI.7
HDMI_TX_P1: length 8.1
  BOTTOM w0.066: RV30.2 124.23,144.27 124.23,144.61 124.44,144.82 125.77,144.82 125.84,144.89 125.84,144.89 126.42,145.47 126.42,145.47 126.52,145.57 126.52,146.01 v13(126.78,146.27) 127.04,146.54 129.58,146.54 129.72,146.67 129.72,146.76 JHDMI.4
HDMI_TX_P2: length 2.5
  BOTTOM w0.066: RV34.2 128.97,144.31 128.97,144.49 128.78,144.68 128.59,144.68 128.2,145.07 128.2,145.28 JHDMI.1
HPD_IFPA#: length 17.3
  TOP w0.081: RG523.1 64.29,87.1 64.33,87.14 v8(64.33,87.18)
  IN1 w0.058: v8(55.45,85.25) 55.18,85.25 54.32,86.1 54.32,88.06 55.74,89.47 59.65,89.47 60.2,90.02 62.85,90.02 63.78,89.1 63.78,87.4 64,87.18 v8(64.33,87.18)
HPD_IFPB#: length 4.1
  TOP w0.081: UG1.BG1 56.44,82.16 56.44,80.79 RG524.1
HT_EN: length 1.2
  GND2 w0.254: v1(80.67,17.37) 80.67,17.37 81,17.71 v3(81.03,17.71)
  GND4 w0.254: v4(80.39,17.62) 80.94,17.62 v3(81.03,17.71)
