# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_A_TRX_DTX_N1: length 27.5
  BOTTOM w0.081: UT1.B15 77.99,147.22 arc(77.9,147.35) 77.87,147.51 77.87,147.77 arc(77.88,147.85) 77.93,147.92 arc(77.95,147.95) 77.96,147.98 77.96,148.35 arc(78.04,148.75) 78.26,149.09 78.91,149.74 arc(79,149.8) 79.11,149.82 82.78,149.82 arc(82.84,149.82) 82.9,149.8 82.93,149.8 84.26,148.46 arc(84.29,148.45) 84.32,148.44 84.77,148.44 arc(84.77,148.44) 84.77,148.44 arc(84.83,148.43) 84.88,148.42 84.91,148.42 85.13,148.19 arc(85.15,148.18) 85.17,148.16 arc(85.23,148.1) 85.3,148.04 85.45,147.88 arc(86.19,147.39) 87.06,147.22 87.48,147.22 arc(87.54,147.21) 87.6,147.2 87.62,147.2 88.02,146.8 arc(88.05,146.78) 88.08,146.78 91.75,146.78 arc(91.77,146.78) 91.79,146.78 arc(91.8,146.79) 91.81,146.8 92.84,147.83 arc(92.99,147.93) 93.17,147.97 94.15,147.97 arc(94.21,147.98) 94.26,148.01 94.46,148.21 arc(94.72,148.38) 95.02,148.44 96.96,148.44 arc(96.96,148.44) 96.96,148.44 arc(97.02,148.43) 97.08,148.42 97.1,148.42 97.32,148.2 arc(97.35,148.18) 97.38,148.17 98.48,148.17 arc(98.61,148.23) 98.67,148.36 98.67,148.47 arc(98.62,148.69) DT9.1 arc(98.67,149.13) 98.73,149.43 98.73,150.08 arc(98.65,150.47) JUSBC.B10
TBT_A_TRX_DTX_P0: length 32.4
  TOP w0.081: v5(80.64,152.96) 80.78,153.09 arc(80.84,153.18) 80.86,153.29 80.86,153.53 arc(80.94,153.73) 81.15,153.81 82.03,153.81 arc(82.26,153.77) 82.45,153.64 arc(82.74,153.21) 82.84,152.7 82.84,152.58 arc(82.88,152.4) 82.98,152.25 83.67,151.56 83.67,151.54 arc(83.69,151.48) 83.69,151.42 arc(83.79,150.94) 84.06,150.54 85.35,149.25 arc(86.03,148.79) 86.84,148.63 90.19,148.63 arc(90.54,148.56) 90.84,148.36 90.96,148.25 arc(91.11,148.02) 91.16,147.75 91.16,146.52 arc(91.19,146.36) 91.28,146.22 91.68,145.82 arc(91.71,145.8) 91.74,145.8 93.85,145.8 arc(94.34,146) 94.54,146.49 94.54,146.66 arc(94.49,146.91) 94.35,147.11 DT4.1 94.4,147.38 94.47,147.45 arc(94.5,147.49) 94.51,147.52 94.51,147.53 arc(94.51,147.53) 94.51,147.54 arc(94.54,147.68) 94.61,147.79 94.66,147.84 arc(94.69,147.89) 94.7,147.94 94.7,148.15 arc(94.7,148.18) 94.68,148.21 94.63,148.26 arc(94.59,148.31) 94.58,148.38 JUSBC.A11
  BOTTOM w0.081: v5(80.64,152.96) 80.75,152.85 arc(80.78,152.82) 80.79,152.79 80.8,152.73 80.8,152.65 arc(80.8,152.63) 80.8,152.62 arc(80.79,152.58) 80.76,152.54 arc(80.73,152.52) 80.7,152.52 78.51,152.52 arc(78.43,152.51) 78.36,152.48 75.76,150.96 75.51,150.72 arc(75.28,150.37) 75.2,149.96 75.2,147.98 arc(75.19,147.95) 75.17,147.92 arc(75.12,147.85) 75.11,147.77 75.11,147.51 arc(75.14,147.35) 75.23,147.22 UT1.B21
TBT_A_TRX_DTX_P1: length 27.5
  BOTTOM w0.081: UT1.A15 78.11,147.51 arc(78.12,147.47) 78.14,147.43 arc(78.22,147.4) 78.31,147.43 78.31,147.44 arc(78.33,147.46) 78.34,147.5 78.34,147.7 arc(78.33,147.73) 78.31,147.75 78.24,147.83 arc(78.18,147.91) 78.16,148.01 78.16,148.35 arc(78.22,148.68) 78.41,148.95 79.05,149.6 arc(79.08,149.61) 79.11,149.62 82.78,149.62 arc(82.79,149.62) 82.79,149.62 arc(82.8,149.62) 82.82,149.61 arc(82.83,149.61) 82.84,149.6 84.12,148.32 arc(84.21,148.26) 84.32,148.24 84.77,148.24 arc(84.79,148.24) 84.8,148.23 arc(84.81,148.22) 84.83,148.21 84.99,148.05 arc(85.01,148.03) 85.03,148.01 arc(85.09,147.95) 85.16,147.89 85.31,147.74 arc(86.11,147.21) 87.06,147.02 87.48,147.02 arc(87.5,147.02) 87.51,147.01 arc(87.53,147) 87.54,146.99 87.88,146.66 arc(87.97,146.59) 88.08,146.57 91.75,146.57 arc(91.81,146.58) 91.87,146.6 91.9,146.6 92.99,147.69 arc(93.07,147.74) 93.17,147.76 94.15,147.76 arc(94.29,147.79) 94.4,147.87 94.6,148.06 arc(94.79,148.19) 95.02,148.24 96.96,148.24 arc(96.98,148.24) 96.99,148.23 arc(97.01,148.22) 97.02,148.21 97.18,148.05 arc(97.27,147.99) 97.38,147.97 98.48,147.97 arc(98.76,148.08) 98.87,148.36 98.87,148.39 arc(98.9,148.55) 98.99,148.69 DT8.1 arc(99,149.14) 98.93,149.47 98.93,150.08 arc(99.01,150.47) JUSBC.B11
TBT_A_TTX_C_DRX_N0: length 24
  BOTTOM w0.081: JUSBC.B3 95.12,150.69 arc(95.02,150.54) 94.98,150.35 94.98,149.94 arc(94.95,149.76) 94.85,149.61 93.81,148.58 93.79,148.58 arc(93.73,148.56) 93.67,148.55 92.88,148.55 arc(92.55,148.49) 92.27,148.3 arc(92.07,148.17) 91.84,148.12 91.46,148.12 arc(91.21,148.07) DT3.1 91,148.18 arc(90.99,148.21) 90.97,148.24 90.92,148.28 arc(90.88,148.31) 90.82,148.33 90.43,148.33 arc(90.28,148.36) 90.16,148.44 89.89,148.71 arc(89.78,148.78) 89.65,148.81 88.24,148.81 arc(88.2,148.8) 88.18,148.78 88.16,148.77 arc(88.07,148.7) 87.96,148.68 87.13,148.68 arc(86.74,148.76) 86.4,148.98 86.01,149.35 86.01,149.35 85.83,149.52 arc(85.7,149.6) 85.54,149.63 85.39,149.63 arc(85.11,149.69) 84.88,149.84 83.35,151.38 arc(83.32,151.39) 83.29,151.4 82.96,151.4 arc(82.68,151.52) 82.56,151.8 82.56,152.16 arc(82.35,152.36) 82.15,152.16 82.15,151.91 arc(82.03,151.62) 81.74,151.5 78.81,151.5 arc(78.65,151.47) 78.52,151.38 77.69,150.55 arc(77.45,150.39) 77.16,150.33 76.7,150.33 arc(76.66,150.33) 76.64,150.31 76.56,150.23 arc(76.5,150.09) 76.56,149.95 CT42.1
TBT_A_TTX_C_DRX_N1: length 25.7
  TOP w0.081: v5(89.4,147.97) 89.65,147.71 arc(89.7,147.68) 89.76,147.67 90,147.67 arc(90.23,147.57) 90.32,147.34 90.32,146.22 arc(90.36,146.04) 90.46,145.89 91.22,145.13 arc(91.39,145.01) 91.59,144.97 94.56,144.97 arc(94.66,144.99) 94.74,145.05 94.95,145.25 94.97,145.28 arc(95.1,145.36) 95.25,145.39 98.04,145.39 arc(98.29,145.44) 98.51,145.59 98.62,145.7 arc(98.88,146.09) 98.97,146.55 98.97,147.02 arc(98.95,147.1) 98.91,147.18 arc(98.86,147.21) 98.8,147.22 DT7.1 98.76,147.36 arc(98.83,147.44) 98.87,147.53 arc(98.89,147.6) 98.89,147.68 98.89,147.76 98.89,147.76 arc(98.89,147.82) 98.86,147.88 arc(98.85,147.91) 98.82,147.93 98.79,147.97 98.68,148.07 arc(98.61,148.19) 98.58,148.32 JUSBC.A3
  BOTTOM w0.081: v5(89.4,147.97) 89.23,147.8 arc(89.19,147.77) 89.14,147.76 88.91,147.76 arc(88.86,147.78) 88.81,147.81 88.72,147.89 arc(88.54,148.02) 88.32,148.06 87.27,148.06 arc(86.48,148.22) 85.8,148.67 85.48,148.99 85.45,148.99 arc(85.4,149.01) 85.34,149.01 84.89,149.01 arc(84.86,149.02) 84.83,149.04 83.42,150.45 arc(83.13,150.65) 82.79,150.71 80.44,150.71 arc(80.2,150.76) CT40.1
TBT_A_TTX_C_DRX_P0: length 24
  BOTTOM w0.081: JUSBC.B2 94.47,150.8 arc(94.59,150.78) 94.7,150.71 94.73,150.67 arc(94.77,150.62) 94.78,150.56 94.78,149.94 arc(94.76,149.84) 94.7,149.76 93.73,148.78 arc(93.72,148.77) 93.7,148.76 arc(93.69,148.76) 93.67,148.76 92.88,148.76 arc(92.47,148.68) 92.12,148.45 arc(91.99,148.36) 91.84,148.33 91.3,148.33 arc(91.11,148.39) 91,148.55 arc(91,148.59) 91,148.63 DT2.1 arc(90.91,148.6) 90.81,148.55 arc(90.73,148.54) 90.65,148.53 90.43,148.53 arc(90.36,148.54) 90.3,148.58 90.03,148.85 arc(89.86,148.97) 89.65,149.01 88.24,149.01 arc(88.13,148.99) 88.03,148.93 88.01,148.91 arc(87.99,148.89) 87.96,148.88 87.13,148.88 arc(86.81,148.95) 86.54,149.12 86.15,149.49 86,149.65 arc(85.79,149.79) 85.54,149.84 85.39,149.84 arc(85.19,149.88) 85.02,149.99 83.49,151.52 arc(83.4,151.58) 83.29,151.6 82.96,151.6 arc(82.82,151.66) 82.76,151.8 82.76,152.16 arc(82.35,152.57) 81.95,152.16 81.95,151.91 arc(81.89,151.76) 81.74,151.7 78.81,151.7 arc(78.57,151.66) 78.37,151.52 77.55,150.7 arc(77.37,150.58) 77.16,150.54 76.65,150.54 arc(76.58,150.52) 76.51,150.48 76.38,150.34 arc(76.32,150.25) 76.3,150.15 arc(76.3,150.14) 76.3,150.14 arc(76.26,149.97) 76.16,149.83 CT41.1
TBT_A_TTX_C_DRX_P1: length 25.7
  TOP w0.081: JUSBC.A2 99.08,148.35 arc(99.07,148.31) 99.05,148.28 99.03,148.26 arc(98.99,148.19) 98.97,148.11 arc(99,148.04) 99.04,147.97 arc(99.08,147.87) 99.1,147.76 99.1,147.57 arc(99.12,147.44) 99.2,147.33 99.26,147.27 arc(99.31,147.23) DT6.1 99.34,147.2 arc(99.22,147.01) 99.17,146.79 99.17,146.55 arc(99.07,146.01) 98.76,145.55 98.65,145.44 arc(98.37,145.25) 98.04,145.19 95.25,145.19 arc(95.18,145.17) 95.11,145.13 95.09,145.11 94.89,144.91 arc(94.74,144.81) 94.56,144.77 91.59,144.77 arc(91.32,144.82) 91.08,144.98 90.31,145.75 arc(90.17,145.96) 90.12,146.22 90.12,147.34 arc(90.08,147.43) 90,147.46 89.59,147.46 arc(89.48,147.44) v5(89.4,147.38)
  BOTTOM w0.081: v5(89.4,147.38) 89.3,147.48 arc(89.21,147.54) 89.1,147.56 88.91,147.56 arc(88.78,147.59) 88.67,147.66 88.6,147.73 arc(88.46,147.82) 88.3,147.86 87.27,147.86 arc(86.4,148.03) 85.66,148.53 85.4,148.78 arc(85.39,148.79) 85.37,148.8 arc(85.36,148.81) 85.34,148.81 84.89,148.81 arc(84.78,148.83) 84.69,148.89 83.27,150.31 arc(83.05,150.46) 82.79,150.51 80.2,150.51 arc(80.16,150.5) 80.14,150.49 CT39.1
TBT_A_TTX_DRX_N0: length 2.3
  BOTTOM w0.081: CT42.2 76.51,149.01 arc(76.45,148.93) 76.43,148.84 76.43,147.95 arc(76.45,147.89) 76.48,147.84 arc(76.49,147.8) 76.5,147.75 76.5,147.45 arc(76.48,147.34) 76.41,147.25 UT1.B19
TBT_A_TTX_DRX_N1: length 5.1
  BOTTOM w0.081: UT1.B17 77.13,147.16 arc(77.02,147.3) 76.96,147.47 arc(76.95,147.53) 76.95,147.59 76.95,148.49 arc(77.01,148.83) 77.21,149.11 arc(77.25,149.18) 77.3,149.24 77.31,149.24 arc(77.33,149.27) 77.35,149.29 arc(77.52,149.5) 77.71,149.69 78.75,150.73 arc(78.88,150.82) 79.04,150.85 79.28,150.85 arc(79.28,150.85) 79.28,150.85 arc(79.35,150.87) CT40.2
TBT_A_TTX_DRX_P0: length 2.3
  BOTTOM w0.081: UT1.A19 76.27,147.46 arc(76.27,147.46) 76.27,147.46 arc(76.19,147.35) 76.06,147.37 arc(76.05,147.4) 76.04,147.43 76.04,147.77 arc(76.05,147.8) 76.06,147.83 76.17,147.93 arc(76.21,148) 76.23,148.07 arc(76.23,148.08) 76.23,148.08 76.23,148.99 arc(76.21,149.11) CT41.2
TBT_A_TTX_DRX_P1: length 5.1
  BOTTOM w0.081: CT39.2 79.17,150.56 arc(79.02,150.62) 78.87,150.56 77.85,149.55 arc(77.6,149.28) 77.37,148.99 arc(77.21,148.75) 77.15,148.47 77.15,147.97 arc(77.17,147.92) 77.21,147.89 77.24,147.88 77.32,147.88 arc(77.39,147.85) 77.42,147.78 77.42,147.46 arc(77.41,147.43) 77.39,147.4 77.36,147.37 arc(77.29,147.34) 77.22,147.37 arc(77.2,147.41) 77.19,147.45 UT1.A17
TBT_A_USB20_L_NB: length 21.3
  TOP w0.089: LT3.3 97.76,143.92 97.76,144.33 v3(97.92,144.48)
  IN1 w0.076: v5(104.61,147.53) 104.8,147.72 104.8,148.03 104.73,148.11 104.46,148.11 104.08,147.73 103.63,147.73 103.39,147.97 96.92,147.97 96.73,148.17 96.73,148.64 v8(96.58,148.79)
  IN2 w0.076: v4(101.36,147.31) 101.52,147.14 101.65,147.14 101.9,146.89 101.9,146.1 101.33,145.52 98.32,145.52 97.71,144.91 97.71,144.68 v3(97.92,144.48)
  BOTTOM w0.089: v5(104.61,147.53) 104.78,147.37 104.78,147.24 104.62,147.08 104.39,147.08 104.34,147.13 v13(103.92,147.13) 103.28,147.13 103.12,147.29 DT10.4 DT10.7 101.86,147.29 101.71,147.14 101.52,147.14 v4(101.36,147.31)
TBT_A_USB20_L_NT: length 20.2
  TOP w0.089: v3(95.66,144.65) 95.66,144.57 95.75,144.48 95.98,144.48 96.24,144.22 96.24,143.92 96.31,143.85 LT2.3
  IN1 w0.076: v5(103.87,149.02) 103.68,148.82 100.79,148.82 100.72,148.76 97.87,148.76 96.93,149.69 96.93,150.02 97.01,150.1 JUSBC.B7
  IN2 w0.076: v4(101.31,148.81) 101.14,148.64 99.62,148.64 99,148.02 99,147.39 96.7,145.08 96.7,144.86 96.39,144.55 95.75,144.55 v3(95.66,144.65)
  BOTTOM w0.089: v5(103.87,149.02) 103.66,148.8 103.47,148.8 103.32,148.64 103.23,148.64 103.08,148.79 DT10.1 DT10.9 101.96,148.79 101.81,148.64 101.47,148.64 v4(101.31,148.81)
TBT_A_USB20_L_PB: length 21.3
  TOP w0.089: LT3.2 97.56,143.92 97.56,144.35 97.43,144.48 v3(97.38,144.48)
  IN1 w0.076: v5(105.2,147.53) 105.01,147.72 105.01,148.12 104.81,148.31 104.37,148.31 103.99,147.93 103.72,147.93 103.48,148.17 97.01,148.17 96.93,148.25 96.93,148.64 v8(97.08,148.79)
  IN2 w0.076: v3(97.38,144.48) 97.51,144.6 97.51,144.99 98.24,145.72 101.24,145.72 101.7,146.18 101.7,146.81 101.6,146.91 101.49,146.91 v4(101.36,146.78)
  BOTTOM w0.089: v4(101.36,146.78) 101.52,146.94 101.75,146.94 101.9,146.79 DT10.6 DT10.5 103.14,146.79 103.28,146.93 103.64,146.93 103.65,146.92 104.27,146.92 104.31,146.88 104.7,146.88 104.98,147.16 104.98,147.32 v5(105.2,147.53)
TBT_A_USB20_L_PT: length 20.3
  TOP w0.089: LT2.2 95.89,143.77 96.04,143.92 96.04,144.14 95.9,144.28 95.75,144.28 95.66,144.19 v3(95.66,144.11)
  IN1 w0.076: JUSBC.B6 96.73,149.8 96.73,149.61 97.78,148.55 100.81,148.55 100.88,148.62 103.68,148.62 v5(103.87,148.43)
  IN2 w0.076: v3(95.66,144.11) 95.89,144.35 96.48,144.35 96.9,144.77 96.9,145 99.21,147.3 99.21,147.94 99.71,148.44 101.14,148.44 v4(101.31,148.28)
  BOTTOM w0.089: v4(101.31,148.28) 101.47,148.44 101.78,148.44 101.93,148.29 DT10.8 DT10.2 103.12,148.29 103.26,148.44 103.4,148.44 103.55,148.59 103.71,148.59 v5(103.87,148.43)
TBT_A_USB20_N: length 34.1
  IN2 w0.076: v4(75.59,146.4) 75.66,146.33 75.66,146.22 75.55,146.12 75.22,146.12 75.11,146.23 75.11,146.89 77.29,149.08 77.29,151.03 78.11,151.84 80.87,151.84 84.4,148.31 88.57,148.31 88.73,148.48 89.9,148.48 90.06,148.31 97.17,148.31 97.76,147.72 97.76,146.99 97.08,146.31 96.04,146.31 95.82,146.09 95.82,145.1 95.75,145.02 95.45,145.02 95.38,144.95 95.16,144.95 v4(95.06,145.05)
TBT_A_USB20_NB: length 1.4
  IN4 w0.076: v7(96.7,143.62) 97.07,143.62 97.52,143.17 v6(97.91,143.17)
TBT_A_USB20_NT: length 1.3
  IN4 w0.076: v7(96.2,143.62) 95.96,143.62 95.76,143.43 95.76,143.25 95.84,143.17 v6(96.31,143.17)
TBT_A_USB20_P: length 34.1
  IN2 w0.076: v4(96.2,145.05) 96.02,145.23 96.02,146 96.13,146.1 97.17,146.1 97.97,146.9 97.97,147.81 97.26,148.52 90.14,148.52 89.98,148.68 88.65,148.68 88.48,148.52 84.49,148.52 80.96,152.05 78.02,152.05 77.09,151.12 77.09,149.16 74.9,146.98 74.9,146.15 75.14,145.91 75.42,145.91 v4(75.59,145.75)
TBT_A_USB20_PB: length 1.4
  TOP w0.089: LT3.1 97.35,143.17 97.32,143.21 97.14,143.21 97.05,143.12 v6(97.05,143.08)
  IN4 w0.076: v7(96.7,143.12) 96.7,143.26 96.88,143.44 96.99,143.44 97.13,143.29 97.13,143.16 v6(97.05,143.08)
TBT_A_USB20_PT: length 1.3
  TOP w0.089: LT2.1 95.78,143.17 95.5,142.9 v6(95.49,142.9)
  IN4 w0.076: v7(95.99,142.86) 95.95,142.9 v6(95.49,142.9)
  BOTTOM w0.089: v7(95.99,142.86) 95.99,142.89 UT4.K6
TBT_CIO_PLUG_EVENT#: length 159.9
  TOP w0.122: UH1.AV21 v5(102.24,30.12)
  IN4 w0.058: 90.32,37.79 89.09,39.02 86.61,39.02 80.07,45.56 80.07,49 80.41,49.34 80.41,57.62 79.86,58.17 79.86,64.85 71.71,73 71.71,74.96 70.95,75.72 70.95,79.17 69.27,80.86 69.27,82.28 68.67,82.88 68.67,84.74 69,85.08 69,86.54 68.67,86.88 68.67,87.41 69.04,87.79 69.04,89.36 69.25,89.57 69.25,91.1 69.39,91.24 69.39,91.63 69.58,91.82 69.58,93.13 68.15,94.56 68.15,101.49 69.78,103.12 72.29,103.12 72.48,103.3 72.48,108.14 72.01,108.61 72.01,109.82 70.84,110.99 70.84,115.53 67.56,118.8 67.56,121.95 67.07,122.44 67.07,125.57 66.52,126.11 66.52,134.33 67.02,134.83 69.83,134.83 70.26,134.83 73.05,137.62 73.05,138.76 73.26,138.97 74.24,138.97 74.69,139.42 78.45,139.42 78.89,138.98 78.89,138.48 79.42,137.95 81.79,137.95 82,138.16 83.73,138.16 83.89,138 84.45,138 85.85,139.4 v4(86.63,139.4)
  IN4 w0.089: 90.32,37.79 91.54,36.57 93.42,36.57 94.02,35.97 94.81,35.97 95.33,35.45 96.32,35.45 96.91,36.04 98.62,36.04 98.84,35.82 98.84,35.55 99.54,34.86 100.04,34.86 100.4,34.5 100.4,34.36 100.4,34.35 100.4,34.06 101.7,32.75 101.7,30.66 v5(102.24,30.12)
  BOTTOM w0.081: UT1.W2 84.13,139.28 84.35,139.5 84.85,139.5 85.12,139.23 86.45,139.23 v4(86.63,139.4)
  BOTTOM w0.089: v5(102.24,30.12) 102.2,30.12 v2(101.83,29.75)
TBT_EE_CLK: length 54.4
  TOP w0.081: UT2.6 65.54,120.11 v3(64.72,119.28) RT52.2 ; RT101.1 94.26,140.53 v3(93.95,140.22)
  IN2 w0.058: v3(93.95,140.22) 93.26,140.22 92.56,139.52 92.53,139.52 91.79,138.78 90.89,138.78 88.91,136.81 87.78,136.81 87.78,136.81 87.48,136.81 86.08,138.2 86.08,138.64 86.06,138.66 85.82,138.9 84.9,138.9 84.66,138.66 84.66,138.38 83.81,137.53 72.92,137.53 71.47,136.08 71.47,133.39 74.63,130.23 74.63,127.34 70.94,123.65 70.94,121.52 69.54,120.11 65.55,120.11 v3(64.72,119.28)
TBT_EE_CLK_R: length 37.4
  TOP w0.081: v3(67.06,120.82) 66.84,120.6 65.32,120.6 v2(64.83,121.08) 64.55,121.08 63.8,120.34 RT52.1
  IN2 w0.058: v3(67.06,120.82) 66.75,121.12 66.75,130.15 70.69,134.09 70.69,136.4 72.59,138.31 75.13,138.31 76.92,140.1 v4(82.46,140.1)
  BOTTOM w0.081: v4(82.46,140.1) 82.47,140.1 82.47,138.36 82.63,138.2 82.86,138.2 UT1.AB4
TBT_EE_CS_N: length 36.9
  TOP w0.081: RT50.2 75.4,117.64 v1(74.8,118.24) ; RT50.2 UT2.1 ; RT50.2 RT100.1 75.32,116.86 v2(75.32,116.02)
  GND2 w0.081: v12(74.8,118.52) v1(74.8,118.24)
  IN2 w0.058: v12(74.8,118.52) 75.03,118.75 75.03,119.26 75.54,119.76 75.54,120.45 75.86,120.77 75.86,130.74 72.7,133.9 72.7,135.78 73.32,136.39 83.6,136.39 83.61,136.38 84.08,136.38 v3(84.48,136.78)
  GND4 w0.081: v3(84.48,136.78) 84.35,136.78 84.1,137.04 v4(84.1,137.06)
  BOTTOM w0.081: UT1.AC3 83.63,137.44 84.01,137.06 84.1,137.06 v4(84.1,137.06)
TBT_EE_DI: length 49.9
  TOP w0.081: UT2.5 67.09,121.38 67.51,120.96 68.38,120.96 v1(68.83,121.41)
  GND2 w0.081: v12(94.87,140.36) 95.02,140.36 v1(95.19,140.53) ; v12(69.11,121.69) v1(68.83,121.41)
  IN2 w0.058: v12(69.11,121.69) 69.29,121.87 69.29,122.72 74.17,127.6 74.17,130.18 71.1,133.24 71.1,136.23 72.77,137.9 83.62,137.9 v4(83.63,137.9) 83.63,138.37 83.72,138.46 83.72,138.49 84.5,139.26 85.97,139.26 86,139.23 86.44,138.79 86.44,138.35 87.63,137.17 88.76,137.17 91.32,139.73 91.5,139.73 92.9,141.12 94.01,141.12 94.77,140.36 v12(94.87,140.36)
TBT_EE_DO: length 38.8
  TOP w0.081: v1(74.78,119.69) 74.99,119.47 RT49.2 RT99.1 UT2.2
  GND2 w0.081: v12(75.18,120.04) 74.83,119.69 v1(74.78,119.69)
  IN2 w0.058: v12(75.18,120.04) 75.16,120.02 75.16,120.7 74.78,121.08 74.78,122.53 74.84,122.59 75.25,122.59 75.31,122.65 75.31,122.77 75.25,122.83 74.84,122.83 74.78,122.89 74.78,123 74.84,123.06 75.25,123.06 75.31,123.12 75.31,123.24 75.25,123.29 74.84,123.29 74.78,123.35 74.78,123.47 74.84,123.53 75.25,123.53 75.31,123.59 75.31,123.7 75.25,123.76 74.84,123.76 74.78,123.82 74.78,123.94 74.84,124 75.25,124 75.31,124.05 75.31,124.17 75.25,124.23 74.84,124.23 74.78,124.29 74.78,124.45 74.84,124.51 75.21,124.51 75.27,124.56 75.27,124.68 75.21,124.74 74.84,124.74 74.78,124.8 74.78,126.05 75.37,126.65 75.37,130.72 72.2,133.89 72.2,135.79 73.22,136.81 83.69,136.81 v3(83.76,136.74)
  GND4 w0.081: v4(83.46,136.98) 83.52,136.98 v3(83.76,136.74)
  BOTTOM w0.081: v4(83.46,136.98) 83.46,137.04 83.17,137.33 UT1.AC4
TBT_EE_WP_N: length 37
  TOP w0.081: UT2.3 v1(74.8,120.11) RT48.2 75.4,120.91 v2(75.46,120.97)
  GND2 w0.081: v12(74.68,120.42) 74.68,120.23 v1(74.8,120.11)
  IN2 w0.058: v12(74.68,120.42) 74.21,120.89 74.21,125.99 74.99,126.78 74.99,130.38 71.83,133.54 71.83,135.93 73.07,137.17 84.4,137.17 85.14,137.91 v3(85.14,138.36)
  GND4 w0.081: v3(85.14,138.36) 85.12,138.36 85.12,139.33 v4(85.27,139.48)
  BOTTOM w0.081: v4(85.27,139.48) 85.08,139.67 84.62,139.67 UT1.V1
TBT_FORCE_PWR: length 140.6
  TOP w0.081: v5(87.88,74.26) 87.52,74.26 86.44,75.34 v2(86.44,86.82) 84.1,89.16 84.1,101.71 80.15,105.66 80.15,112.69 78.55,114.29 77.56,114.29 v1(77.37,114.11) ; RT13.2 88.54,137.47 88.01,136.93 82.61,136.93 80.39,134.71 80.39,133.3 v1(80.09,133)
  TOP w0.089: v5(110.93,40.8) 110.93,40.69 110.8,40.56 110.8,38.77 111.12,38.45 111.25,38.45 112.2,37.49 112.2,37.41 112.67,36.95 114.27,36.95 114.55,37.23 114.55,37.7 115.55,38.7 UH1.Y47
  GND2 w0.081: v1(77.37,114.11) 77.18,114.11 v12(77.09,114.2) ; v1(80.09,133) 80.14,132.95 v12(80.14,132.62)
  IN2 w0.058: v12(80.14,132.62) 80.42,132.34 80.42,128.07 81.24,127.24 81.24,123.36 81.7,122.9 81.7,116.09 82.59,115.21 82.59,114.43 82.27,114.11 81.19,114.11 80.9,114.4 77.29,114.4 v12(77.09,114.2)
  IN4 w0.058: v5(87.88,74.26) 87.33,73.71 87.33,55.62 93.27,49.68 94.54,49.68
  IN4 w0.089: v5(110.93,40.8) 110.94,40.81 110.94,41.9 110.61,42.23 109.24,42.23 108.06,43.41 106.65,43.41 103.11,46.94 102.51,46.94 101.24,48.21 98.88,48.21 97.41,49.68 94.54,49.68
TBT_FORCE_PWR_R: length 13.8
  TOP w0.203: RT35.1 83.25,147.88 v3(83.25,147.32)
  IN3 w0.058: v3(87.96,137.86) 87.94,137.86 87.38,138.43 87,138.43 86.18,139.25 86.18,141.3 84.84,142.65 83.9,142.65 82.96,143.59 82.96,144.45 v9(83.19,144.68) 82.96,144.91 82.96,145.57 82.68,145.85 82.68,146.75 v3(83.25,147.32)
  GND4 w0.081: v4(83.39,144.45) 83.19,144.65 v9(83.19,144.68)
TBT_HOLD_N: length 2.4
  TOP w0.081: RT51.2 64.54,118.65 65.14,118.65 65.33,118.84 UT2.7
TBT_I2C_SCL: length 9.2
  IN1 w0.058: v4(85.22,140.66) 85.47,140.41 86,140.41 86.3,140.12 86.3,139.61 86.35,139.56 86.46,139.56 v8(86.69,139.78) 86.77,139.7 86.89,139.7 87.46,140.27 88.23,140.27 88.54,139.96 89,139.96 90.16,141.12 91.14,141.12 v4(91.34,141.32)
  BOTTOM w0.081: UT1.U2 84.16,140.2 84.39,140.43 85,140.43 v4(85.22,140.66)
TBT_I2C_SCL_R: length 2.8
  BOTTOM w0.081: RT721.2 91.94,141.32 92.11,141.14 92.54,141.14 93.32,140.36 93.59,140.36 93.59,140.36 93.8,140.36 93.8,140.36 93.95,140.36 UT4.D2
TBT_I2C_SDA: length 8.7
  IN1 w0.058: v4(85.22,140.12) 85.33,140.23 85.93,140.23 86.11,140.04 86.11,139.54 86.28,139.37 86.46,139.37 v8(86.69,139.15) 86.91,139.37 86.91,139.46 87.54,140.08 88.16,140.08 88.46,139.78 89.08,139.78 90.23,140.93 91.15,140.93 v4(91.34,140.74)
  BOTTOM w0.081: v4(85.22,140.12) 85.13,140.22 84.57,140.22 UT1.U1
TBT_I2C_SDA_R: length 2.2
  BOTTOM w0.081: UT4.D1 93.27,140.12 93.24,140.15 92.46,140.93 92.11,140.93 RT720.2
TBT_PCIE_WAKE#: length 158.6
  TOP w0.076: v6(82.8,11.02) 82.67,11.15 UE5.M1
  IN3 w0.058: v9(82.89,38.64) 82.87,38.66 82.87,38.97 82.77,39.07 82.77,43.94 82.77,43.94 82.77,44.21 81.7,45.28 81.7,56.38 81.96,56.65 81.96,58.53 82.19,58.76 82.19,66.2 84.49,68.51 84.49,81.56 84.49,81.69 84.49,81.95 86.77,84.23 86.77,84.88 87.82,85.94 87.82,86.6 87.58,86.84 87.46,86.96 87.46,87.88 86.54,88.8 86.54,102.75 81.74,107.56 81.74,112.4 81.51,112.63 80.5,112.63 79.04,114.09 79.04,114.71 75.87,117.88 75.87,122.89 75.46,123.29 75.46,130.48 71.64,134.3 71.64,136.99 72.38,137.73 74.04,137.73 76.17,139.85 79.44,139.85 79.62,139.68 83.74,139.68 84.25,139.17 85.7,139.17 86.74,138.13 v9(86.96,138.13)
  GND4 w0.081: v9(82.89,38.64) 82.66,38.41 v6(82.56,38.41) ; v9(86.96,138.13) v4(87.21,138.13)
  IN4 w0.058: v6(82.56,38.41) 82.56,38.1 82.68,37.97 82.68,36.55 83.4,35.84 83.4,29.38 86.52,26.26 86.52,15.8 84.2,13.48
  IN4 w0.076: v6(82.8,11.02) 82.87,11.09 82.87,12.15 84.2,13.48
  BOTTOM w0.081: v2(88.19,138.03) 88.09,138.13 v4(87.21,138.13)
TBT_PCIE_WAKE_N: length 155.6
  IN3 w0.058: v9(87.38,135.87) 86.28,135.87 86.09,135.67 74.23,135.67 73.95,135.39 73.95,134.93 79.11,129.77 79.11,116.27 81.71,113.67 82.02,113.67 83.39,112.29 83.39,107.13 87.34,103.18 87.34,91.4 88.27,90.48 88.27,87.29 88.62,86.93 88.62,85.6 87.57,84.55 87.57,83.88 85.29,81.61 85.29,66.58 83.06,64.35 83.06,58.87 83.06,58.47 82.98,58.39 82.89,58.29 82.76,58.17 82.76,56.31 82.5,56.05 82.5,45.64 83.57,44.56 83.57,44.54 83.57,44.54 83.57,44.4 83.57,43.61 83.57,39.54 84.9,38.21 v9(84.9,36.65)
  GND4 w0.081: v6(84.71,36.48) 84.88,36.65 v9(84.9,36.65) ; v4(87.66,135.87) v9(87.38,135.87)
  IN4 w0.058: 90.32,25.72 89.47,26.57 89.09,26.57 84.68,30.98 84.68,36.45 v6(84.71,36.48) ; 93.61,22.69 94.27,22.03 95.25,22.03 95.79,21.49 v7(100.43,21.49)
  IN4 w0.089: 90.32,25.72 90.57,25.72 93.61,22.69
  BOTTOM w0.081: RT694.1 101.04,20.98 100.53,21.49 v7(100.43,21.49) ; UT1.W1 84.78,139.04 86.35,139.04 RT28.2 RT10.1 86.63,138.12 86.92,137.82 86.95,137.82 86.96,137.81 87.44,137.81 87.66,137.59 v2(87.66,136.31) v4(87.66,135.87)
TBT_RBIAS: length 1.2
  TOP w0.203: RT25.1 82.44,144.2 v4(82.35,144.28)
  BOTTOM w0.081: UT1.H6 v4(82.35,144.28)
TBT_RESET_N: length 24.5
  TOP w0.081: v3(87.96,139.77) 88.54,140.35 v1(88.54,140.4)
  IN1 w0.058: v1(88.54,140.4) 90.36,142.22 90.93,142.22 91.19,142.47 91.19,143.22 91.68,143.72 92.39,143.72 94.65,141.46 95.55,141.46 95.8,141.2 101.69,141.2 v4(101.89,141)
  IN3 w0.058: v3(84.07,144.53) 84.07,144.09 86.66,141.5 86.66,141.06 v3(87.96,139.77)
  GND4 w0.081: v3(84.07,144.53) 83.5,145.1 v4(83.39,145.1)
TBT_RESET_N_EC: length 150.6
  TOP w0.081: v3(90.07,139.47) 89.77,139.77 v2(89.55,139.77) RT23.2
  IN3 w0.058: v9(83.52,38.25) 83.48,38.29 83.48,38.81 83.28,39.01 83.28,39.01 83.19,39.1 83.09,39.2 83.09,43.81 83.09,44.34 82.02,45.42 82.02,56.25 82.19,56.42 82.28,56.51 82.28,58.37 82.58,58.67 82.58,64.55 82.67,64.64 82.77,64.73 84.81,66.78 84.81,81.69 84.81,81.82 87.09,84.1 87.09,84.75 88.14,85.8 88.14,86.73 87.9,86.97 87.9,86.98 87.78,87.09 87.78,88.02 86.86,88.94 86.86,102.88 82.07,107.67 82.07,112.52 81.64,112.95 81.49,112.95 78.44,115.99 78.44,123.11 77.37,124.18 77.37,129.95 72.81,134.51 72.81,135.69 73.27,136.15 85.89,136.15 86.21,136.47 88.18,136.47 90.07,138.35 v3(90.07,139.47)
  GND4 w0.081: v9(83.52,38.25) 83.27,38 v6(83.18,38)
  IN4 w0.058: v7(87.03,17.92) 87.03,19.97 87.3,20.24 87.3,22.23 86.84,22.69 86.84,26.39 83.72,29.51 83.72,35.97 83.13,36.56 83.13,37.95 v6(83.18,38)
TBT_RSENSE: length 1.4
  TOP w0.203: v4(81.72,144.24) 81.52,144.03 RT25.2
  BOTTOM w0.081: UT1.J6 81.72,144.16 v4(81.72,144.24)
TBT_RST#_R: length 9.4
  TOP w0.081: 83.02,142.94 83.01,142.95 83.01,143.25 RT693.1 ; 83.02,142.94 83.06,142.9 84.77,142.9 85.48,142.2 v2(85.78,142.2) 87.92,142.2 UT3.4 88.65,142.52 89.42,141.76 RT1.1 ; 83.02,142.94 v4(83.02,142.94)
  TOP w0.203: RT693.1 83.06,143.65 RT723.2
  BOTTOM w0.081: UT1.L4 83.32,143.15 83.12,142.95 83.01,142.95 83.01,142.95 v4(83.02,142.94)
TBT_RTD3_RST#: length 158.8
  TOP w0.081: v1(88.9,144.42) 88.9,144.82 88.92,144.84 88.92,144.95 RT695.2
  TOP w0.089: UH1.AM48 v1(116.12,32.38)
  GND2 w0.081: v1(88.9,144.42) 88.97,144.49 v3(88.97,144.81)
  GND2 w0.089: v1(116.12,32.38) 116.12,32.69 116.08,32.73 v3(116.08,32.79)
  IN3 w0.058: v3(88.97,144.81) 88.4,144.25 88.4,142.18 88.21,141.98 88.21,141.55 88.71,141.04 88.71,140.6 89.5,139.81 89.5,138.24 88.1,136.84 84.98,136.84 84.68,137.14 84.19,137.14 84.13,137.09 73.15,137.09 72.28,136.22 72.28,134.58 76.98,129.89 76.98,123.13 77.8,122.3 77.8,121.69 v9(77.8,121.69)
  GND4 w0.081: v9(77.8,121.69) 77.8,121.44 v4(77.83,121.41)
  GND4 w0.089: v6(115.7,33.11) 116.01,32.79 v3(116.08,32.79)
  IN4 w0.058: v7(86.38,69.5) 86.28,69.4 86.28,55.38 89.76,51.89 89.76,51.67 91.03,50.4 91.03,49.73 92.16,48.6
  IN4 w0.089: v6(115.7,33.11) 115.1,33.71 114.21,33.71 113.53,34.39 113.53,35.65 113.63,35.75 113.63,36.44 112.48,37.59 112.48,38.48 111.94,39.03 111.35,39.03 108.67,41.71 108.67,42.04 107.84,42.88 106.42,42.88 104.08,45.23 102.94,45.23 102.26,45.91 101.08,45.91 99.39,47.59 97.92,47.59 97.65,47.86 96.16,47.86 95.59,48.42 94.53,48.42 94.01,47.9 93.23,47.9 92.53,48.6 92.16,48.6
  BOTTOM w0.081: v7(86.38,69.5) 86.44,69.5 86.69,69.75 86.69,71.09 87.26,71.67 87.26,98.44 87.7,98.88 87.7,106.9 83.44,111.16 83.44,112.22 83.79,112.58 83.79,113.55 v2(80.79,116.55) 79.7,116.55 78.11,118.14 78.11,121.14 v4(77.83,121.41)
TBT_S5_OFF#: length 148.6
  TOP w0.081: v1(79.07,151.54) 79.82,151.54 UT8.4 ; v3(73.48,134.47) 73.81,134.8 73.81,137.42 v2(74.26,137.87) 74.69,138.29 v1(74.69,138.61)
  GND2 w0.081: v12(74.69,138.97) v1(74.69,138.61) ; v12(79.07,151.03) v1(79.07,151.54)
  IN2 w0.058: v12(79.07,151.03) 79.07,150.12 78.54,149.58 78.54,146.84 77.9,146.2 77.9,144.71 74.69,141.49 v12(74.69,138.97)
  IN3 w0.058: v3(73.48,134.47) 77.53,130.43 77.53,124.25 78.6,123.17 78.6,116.06 81.55,113.11 81.71,113.11 82.23,112.58 82.23,107.74 87.02,102.95 87.02,89 87.94,88.08 87.94,87.16 88.06,87.04 88.3,86.8 88.3,85.74 87.25,84.68 87.25,84.03 84.97,81.75 84.97,66.71 82.74,64.48 82.74,58.74 82.74,58.6 82.74,58.6 82.44,58.3 82.44,56.45 82.25,56.26 82.18,56.18 82.18,45.48 83.25,44.4 83.25,43.74 83.25,39.26 83.81,38.71 v9(83.81,38.03)
  GND4 w0.081: v9(83.81,38.03) 83.46,37.69 v6(83.39,37.69)
  IN4 w0.058: v7(88.03,17.92) 87.46,18.49 87.46,22.3 87,22.76 87,26.46 83.88,29.57 83.88,36.03 83.39,36.53 v6(83.39,37.69)
TBT_SRC_CFG1: length 3.6
  BOTTOM w0.081: v2(86.3,136.46) 86.39,136.46 86.63,136.7 RT11.1 86.62,137.37 85.54,137.37 UT1.AA1
TBT_SRC_HPD: length 4.6
  BOTTOM w0.081: UT1.G1 84.96,144.8 85.59,144.17 85.59,142.34 RT4.1
TBT_SVR_IND: length 1.6
  TOP w0.081: v2(69.75,148.49) v8(70.87,148.49) v8(71.25,148.49) LT1.1
  vias: v5(85.03,146.4) v5(85.6,146.4) v8(71.63,148.49)
TBT_TCK: length 1.1
  TOP w0.081: v4(83.69,140.24) 84.01,140.55 RT7.2
  BOTTOM w0.081: UT1.T4 v4(83.69,140.24)
TBT_TDI: length 0.9
  TOP w0.081: RT9.2 83.63,138.84 v4(83.39,138.6)
TBT_TDO: length 0.9
  TOP w0.081: v4(83.39,139.25) 83.66,139.25 83.82,139.41 RT6.2
TBT_TEST_EN: length 2.3
  BOTTOM w0.081: RT17.1 85.77,145.11 85.17,145.72 UT1.E1
TBT_TEST_PWG: length 2.8
  BOTTOM w0.081: UT1.AB5 82.49,137.68 82.49,137.21 83.68,136.02 RT18.1
TBT_TMS: length 1.9
  TOP w0.081: RT8.2 83.89,139.98 83.83,139.92 83.38,139.92 v2(83.35,139.95) v4(83.06,140.24)
  BOTTOM w0.081: v4(83.06,140.24) 83.31,140.24 83.39,140.16 UT1.V4
TBT_TMU_CLK_OUT: length 2.8
  BOTTOM w0.081: RT34.1 86.25,140.03 86.07,139.85 T2.1 85.48,139.85 85.46,139.84 84.84,139.84 84.72,139.96 84.33,139.96 84.11,139.74 UT1.V2
TBT_XTAL_25_IN: length 5.6
  IN4 w0.076: v7(70.99,146.71) 73.15,146.71 v7(73.53,146.33)
  BOTTOM w0.076: UT1.D22 74.89,146.31 74.8,146.4 74.22,146.4 74.02,146.6 73.61,146.6 73.53,146.52 v7(73.53,146.33)
  BOTTOM w0.081: RT116.1 70.57,146.29 v7(70.99,146.71)
TBT_XTAL_25_OUT: length 5.2
  IN4 w0.076: v7(73.91,146.34) 73.28,146.98 70.88,146.98 70.87,146.97 70.87,146.97 v7(70.61,146.71)
  BOTTOM w0.081: RT117.1 70.5,147.18 70.61,147.06 v7(70.61,146.71) ; v7(73.91,146.34) 74.08,146.18 UT1.D23
TBTA_DEBUG1: length 3.6
  BOTTOM w0.081: UT4.L2 94.19,143.77 93.4,144.57 93.4,146.42 93.74,146.76 RT71.1
TBTA_DEBUG2: length 7.2
  BOTTOM w0.081: RT72.1 94.37,146.89 94.11,147.16 93.34,147.16 v2(92.72,146.53) 92.05,145.86 92.05,144.84 92.25,144.63 92.74,144.63 93,144.38 93.32,144.38 93.94,143.76 93.94,143.38 UT4.K2
TBTA_DIG_AUD_N: length 2.3
  BOTTOM w0.081: UT4.K3 94.45,143.37 94.45,144.03 93.93,144.55 93.84,144.55 93.74,144.65 RT69.1
TBTA_DIG_AUD_P: length 1.5
  BOTTOM w0.081: RT68.1 94.37,144.44 94.7,144.12 UT4.L3
TBTA_HPD: length 17.5
  TOP w0.081: v4(97.38,139.47) 97.38,139.4 96.76,138.78 96.51,138.78 95.97,138.24 94.86,138.24 93.63,139.47 92.77,139.47 v2(91.61,140.63) 91.05,141.18 89.67,141.18 88.84,142.01 87.02,142.01 86.69,141.69 RT41.1 85.67,141.69 85.09,142.27 83.62,142.27 v4(83.39,142.5)
  BOTTOM w0.081: v4(97.38,139.47) 97.53,139.62 UT4.C10
TBTA_I2C_INT: length 10.7
  IN1 w0.058: v4(91.34,139.16) 89.89,139.16 89.6,138.86 88.23,138.86 v3(87.96,139.13)
  IN3 w0.058: v3(87.96,139.13) 87.96,139.24 86.5,140.69 86.5,141.44 84.88,143.05 84.08,143.05 v9(83.96,143.17)
  GND4 w0.081: v9(83.96,143.17) 83.72,143.42 v4(83.72,143.49)
  BOTTOM w0.081: UT1.J4 83.41,143.8 v4(83.72,143.49)
TBTA_I2C_INT_R: length 2
  BOTTOM w0.081: RT722.2 92.14,139.16 92.6,139.62 UT4.C1
TBTA_I2C_SCL1_R: length 1.2
  TOP w0.081: RT60.2 95.96,139.45 v4(95.8,139.45)
  BOTTOM w0.081: v4(95.8,139.45) 95.78,139.45 95.7,139.37 UT4.B5
TBTA_I2C_SDA1_R: length 1.7
  TOP w0.081: v4(95.7,138.62) 95.63,138.62 v2(95.35,138.9) 95.35,139.48 RT59.2
TBTA_LDO_BMC: length 1.9
  IN4 w0.058: v4(93.69,140.62) 92.79,140.62 v4(92.09,139.92)
TBTA_LSRX: length 18.9
  IN3 w0.058: v4(94.98,142.86) 94.98,143.46 94.22,144.22 94.22,144.81 90.68,148.35 85.61,148.35 84.99,148.97 82.28,148.97 v4(82.09,148.78)
  BOTTOM w0.081: UT1.A4 83.17,148.01 82.69,148.49 82.38,148.49 v4(82.09,148.78) 81.94,148.94 RT42.1 ; v4(94.98,142.86) 94.98,142.91 UT4.K4
TBTA_LSTX: length 28.8
  TOP w0.081: v1(84.89,144.35) 84.77,144.24 RT21.2
  GND2 w0.081: v12(84.61,144.07) v1(84.89,144.35)
  IN2 w0.058: v4(81.32,148.76) 81.32,148.15 80.59,147.42 80.59,145.34 81.2,144.73 82.68,144.73 83.34,144.07 v12(84.61,144.07)
  IN3 w0.058: v4(95.01,144.01) 94.97,143.97 94.86,143.97 94.44,144.39 94.44,144.88 90.81,148.51 85.74,148.51 85.03,149.23 81.79,149.23 v4(81.32,148.76)
  BOTTOM w0.081: RT40.1 v4(81.32,148.76) 81.39,148.76 81.85,148.3 82.42,148.3 82.71,148.02 UT1.A5 ; v4(95.01,144.01) 95.01,143.81 UT4.L4
TBTA_MRESET: length 4
  BOTTOM w0.081: UT4.E11 98.76,140.68 100.2,140.68 100.62,140.26 RT63.1 101.32,139.89 v2(100.77,139.35)
TBTA_ROSC: length 5.7
  IN4 w0.058: v4(90.4,139.79) 90.04,140.15 90.04,140.43 90.34,140.72 90.7,140.72 90.98,140.44 91.52,140.44 92.46,141.38 93.95,141.38 v7(94.19,141.62)
TBTB_I2C_INT: length 3.1
  BOTTOM w0.081: RT33.2 86.14,144.48 85.12,145.5 84.31,145.5 UT1.E2
THERM_ALERT#: length 5.8
  TOP w0.081: RG504.2 59.18,81.23 57.89,82.53 57.89,83.26 57.63,83.52 57.43,83.52 57.15,83.8 57.15,84.25 UG1.BJ3
THERMDA: length 0.5
  BOTTOM w0.081: UT1.AB23 UT1.AC23
TOBII_INT#: length 218.8
  TOP w0.081: v2(88.29,134.25) 88.78,133.76 v5(88.78,133.76)
  IN2 w0.058: v3(94.63,56.65) 93.3,57.99 93.3,68.15 92.71,68.73 92.71,79.77 92.85,79.91 92.85,82.82 91,84.67 v3(91,86.97)
  IN3 w0.058: v9(118.24,16.28) 117.98,16.54 117.45,16.54 115.87,18.11 115.87,21.4 116.4,21.92 118.21,21.92 119.35,23.07 120.73,23.07 v9(122.19,24.53) ; v3(91,86.97) 90.86,87.1 90.86,94.83 91.74,95.71 91.74,100.23 90.86,101.11 90.86,103.19 86.89,107.17 86.89,111.85 87.44,112.4 87.44,115.85 87.38,115.91 84.2,115.91 81.81,118.3 81.81,129.94 83.56,131.69 86.57,131.69 88.53,133.65 88.67,133.65 v5(88.78,133.76) 90.39,135.36 97.56,135.36 98.81,136.6 104.75,136.6 106.15,135.21 107.24,135.21 108.58,136.56 122.89,136.56 123.2,136.88 140.46,136.88 140.46,136.85 140.49,136.85 140.49,136.85 v9(140.48,136.85) ; v9(95.01,56.65) v3(94.63,56.65)
  GND4 w0.081: v9(140.48,136.85) 140.49,136.85 140.7,137.06 v4(140.72,137.06) ; v4(118.49,16) 118.24,16.26 v9(118.24,16.28) ; v9(122.19,24.53) v6(122.38,24.72) ; v6(95.31,56.65) v9(95.01,56.65)
  IN4 w0.058: 115.38,48.6 115.38,49.37 114.84,49.91 ; 114.66,50.09 108.44,56.31 95.66,56.31 v6(95.31,56.65) ; 117.24,39.63 123.04,33.84 123.04,25.48 122.38,24.82 v6(122.38,24.72)
  IN4 w0.089: 115.38,48.6 115.38,42.36 117.24,40.49 117.24,39.63 ; 114.84,49.91 114.66,50.09
  BOTTOM w0.081: JTOBII.6 141.58,138.31 RE709.1 v4(140.72,137.06) ; RE651.2 120.82,13.51 118.92,15.41 118.92,15.57 v4(118.49,16)
TOBII_PWR_EN#: length 7.1
  TOP w0.076: v1(80.48,17.8) 80.52,17.8 80.52,17.83 80.62,17.83 80.92,17.54 80.92,17.09 80.69,16.87 UE5.H12
  TOP w0.081: v1(79.68,20.72) 79.68,21.03 79.89,21.24 UE12.4 79.46,21.74 79.39,21.81 79.13,21.81 79.11,21.8 CE79.1
  GND2 w0.076: v12(80.27,18) 80.28,18 v1(80.48,17.8)
  GND2 w0.081: v1(79.68,20.72) 79.82,20.72 v12(80.03,20.51)
  IN2 w0.058: 80.26,18.44 80.19,18.51 80.19,20.35 v12(80.03,20.51)
  IN2 w0.076: v12(80.27,18) 80.27,18.43 80.26,18.44
TON_1.2V: length 2.3
  TOP w0.203: PUM1.9 147.39,45.19 148.39,44.2 PRM18.2
TP_CLK: length 16.7
  TOP w0.076: 76.58,12.92 77.03,13.36 UE5.A5
  TOP w0.081: 76.58,12.92 76.04,12.38 75.68,12.02 75.33,12.02 v8(75.01,12.35)
  IN1 w0.058: v8(75.01,12.35) 74.92,12.35 74.87,12.29 74.87,11.84 74.92,11.78 75.11,11.78 75.29,11.61 75.29,9.44 76.22,8.5 79.83,8.5 80.49,7.84 v3(80.52,7.84)
  IN3 w0.058: v9(81.84,4.54) 81.77,4.46 81.22,4.46 80.75,4.93 80.75,7.1 80.43,7.42 80.43,7.75 v3(80.52,7.84)
  GND4 w0.081: v9(81.84,4.54) v4(82.12,4.54)
TP_CLK_R: length 20.7
  TOP w0.081: v4(79.72,6.23) 79.58,6.23 79.44,6.38 79.44,6.51 79.22,6.73 77.31,6.73 76.48,5.9 76.48,5.52 76.4,5.44 76.24,5.44 76.16,5.35 JTP15.1 76.16,4.3 76.08,4.22 74.87,4.22 74.75,4.33 v13(73.85,4.33) 73.28,4.33 71.58,6.04 68.47,6.04 67.5,5.07 66.81,5.07 66.74,5.13 66.74,5.39 66.83,5.47 67.12,5.47 67.31,5.66 JTP17.8
  BOTTOM w0.081: RE654.2 80.88,4.22 80.76,4.22 79.57,5.41 79.57,6.14 79.66,6.23 v4(79.72,6.23)
TP_DATA: length 16.8
  TOP w0.076: UE5.B5 77.41,13.11 77.03,13.11 76.76,12.85 76.76,12.84 76.72,12.81 76.72,12.8 76.58,12.66
  TOP w0.081: v8(75.01,11.52) 75.32,11.84 75.76,11.84 76.58,12.66
  IN1 w0.058: v8(75.01,11.52) 75.07,11.52 75.13,11.46 75.13,9.37 76.16,8.34 79.76,8.34 80.1,8.01 80.1,7.92 80.01,7.84 v3(79.98,7.84)
  IN3 w0.058: v3(79.98,7.84) 80.01,7.81 80.06,7.81 80.27,7.6 80.27,7.36 80.59,7.04 80.59,4.86 81.15,4.3 81.72,4.3 81.84,4.18 v9(81.84,4.04)
  GND4 w0.081: v9(81.84,4.04) 81.92,4.04 82.12,3.84 v4(82.12,3.71)
TP_DATA_R: length 20.7
  TOP w0.081: JTP17.7 66.31,5.63 66.56,5.37 66.56,5.05 66.73,4.88 67.57,4.88 68.54,5.85 71.5,5.85 73.2,4.15 73.54,4.15 73.56,4.12 74.14,4.12 74.16,4.15 74.68,4.15 74.79,4.04 76.47,4.04 76.66,4.23 JTP15.2 76.66,5.82 77.39,6.55 79.14,6.55 79.26,6.44 79.26,6.31 v4(79.18,6.23)
  BOTTOM w0.081: v4(79.18,6.23) 79.28,6.23 79.38,6.14 79.38,5.34 80.69,4.03 80.88,4.03 RE655.2
TP_EN: length 22.6
  GND2 w0.076: v1(78.67,15.36) 78.67,15.52 78.82,15.67 v3(78.82,15.98)
  IN2 w0.058: v3(92.15,20.2) 92.15,19.69 93.03,18.81 93.03,18.35 v3(94.36,17.02)
  IN3 w0.058: 84.2,18.11 85.47,18.11 87.25,19.89 89.66,19.89 89.97,20.2 v3(92.15,20.2)
  IN3 w0.076: 84.2,18.11 83.85,17.76 82.47,17.76 82.09,17.38 80.04,17.38 78.82,16.16 v3(78.82,15.98)
  GND4 w0.081: v3(94.36,17.02) 94.14,16.8 v4(94.14,16.54) ; v4(92.15,20.79) v3(92.15,20.2)
  BOTTOM w0.081: v4(94.14,16.54) 94.8,16.54 95.06,16.79 95.34,16.79 QT2.2
TP_INT#: length 58.6
  TOP w0.081: v1(77.85,5.5) 77.74,5.5 77.66,5.42 JTP15.4 77.66,3.77 77.56,3.67 72.58,3.67 71.08,5.17 68.45,5.17 67.69,4.41 65.64,4.41 64.31,5.74 JTP17.5 ; v2(95.64,18.46) 95.53,18.57 v5(93.6,18.57)
  TOP w0.089: v5(101.11,25.07) 101.19,25.15 101.19,25.58 101.04,25.72 101.03,25.72 101.01,25.75 100.84,25.75 100.82,25.72 100.59,25.72 100.36,25.95 100.36,26.09 UH1.BE15
  GND2 w0.081: v12(78.03,5.78) 78.03,5.68 v1(77.85,5.5)
  IN2 w0.058: v12(78.03,5.78) 78.03,5.86 79.35,7.18 79.35,9.15 80.77,10.57
  IN2 w0.076: v3(82.67,13.86) 82.67,13.17 81.04,11.55 81.04,10.84 80.77,10.57
  IN3 w0.058: 100.33,22.69 100.33,20.35 99.05,19.07 96.05,19.07 95.54,18.57 v5(93.6,18.57) 91.77,16.74 89.67,16.74 89.34,16.41 87.95,16.41 87.19,15.65 84.75,15.65 84.2,15.1
  IN3 w0.076: 84.2,15.1 82.96,13.86 v3(82.67,13.86)
  IN3 w0.089: v5(101.11,25.07) 101.11,24.62 100.71,24.22 100.71,23.4 100.33,23.01 100.33,22.69
  BOTTOM w0.081: v5(93.6,18.57) 93.6,18.55 93.72,18.43 RE661.2
TRIP_+1VALWP: length 3.7
  TOP w0.081: v2(141.95,28.07) PRH8.2
  TOP w0.254: PUH1.2 139.36,29.64 PRH8.2
TRON_BOT_B_DRV#: length 63.4
  IN4 w0.058: v7(58.91,4.73) 59.75,4.73 60.65,3.82 64.57,3.82 65.83,5.08 76.72,5.08 77.28,5.64 81.57,5.64 82.5,6.57 84.98,6.57 92.14,13.73 98.88,13.73 99.11,13.5 108.87,13.5 109.12,13.25 110.02,13.25 v7(110.45,13.68)
  BOTTOM w0.081: JPTRON.10 v7(58.91,4.73) ; UE8.9 108.57,11.41 108.69,11.29 108.8,11.29 110.45,12.94 v2(110.45,13.1) v7(110.45,13.68)
TRON_BOT_G_DRV#: length 63.3
  TOP w0.081: v2(109.89,13.58) 110.25,13.93 v5(110.25,14.12)
  IN4 w0.058: v7(58.57,5.03) 59.67,5.03 60.72,3.98 64.5,3.98 65.77,5.24 76.65,5.24 77.21,5.8 81.5,5.8 82.43,6.73 84.91,6.73 92.07,13.89 98.94,13.89 99.17,13.66 108.94,13.66 109.19,13.41 109.81,13.41 110.08,13.68 110.08,13.96 v5(110.25,14.12)
  BOTTOM w0.081: UE8.8 109.74,12.66 110.08,13.01 110.08,13.96 v5(110.25,14.12) ; v7(58.57,5.03) 58.11,4.57 JPTRON.9
TRON_BOT_R_DRV#: length 61.8
  TOP w0.081: v2(97.37,13.52) 97.96,14.1 v5(97.96,14.25)
  IN4 w0.058: v7(58.29,5.36) 59.56,5.36 60.78,4.14 64.44,4.14 65.8,5.5 74.38,5.5 75.47,6.59 76.37,6.59 77,5.96 81.43,5.96 82.37,6.89 84.85,6.89 92.21,14.25 v5(97.96,14.25) 98.81,14.25 99.24,13.82 109.22,13.82 v7(109.37,13.66)
  BOTTOM w0.081: v7(58.29,5.36) 57.66,4.73 57.66,2.72 57.31,2.38 JPTRON.8
TRON_TOP_B_DRV#: length 65.4
  TOP w0.081: v5(74.32,6.1) 74.32,5.97 v2(73.98,5.63)
  IN4 w0.058: v7(109.37,14.16) 108.7,14.84 104.75,14.84 103.83,15.76 101.04,15.76 100.58,15.31 97.96,15.31 97.06,14.41 92.14,14.41 84.78,7.05 82.3,7.05 81.83,6.58 78.2,6.58 78.06,6.44 76.75,6.44 76.44,6.75 74.97,6.75 v5(74.32,6.1) 74.13,5.92 65.99,5.92 64.37,4.3 60.85,4.3 59.41,5.74 v7(55.83,5.74)
  BOTTOM w0.081: v7(55.83,5.74) 54.11,4.03 JPTRON.4
TRON_TOP_G_DRV#: length 66.9
  TOP w0.081: v5(74,6.57) 74.88,6.57 75.06,6.39 v2(75.23,6.39)
  IN4 w0.058: v7(109.37,14.66) 109.03,15 104.81,15 103.9,15.92 100.97,15.92 100.52,15.47 97.9,15.47 97,14.57 92.07,14.57 84.72,7.21 82.23,7.21 81.76,6.74 78.14,6.74 77.99,6.6 76.82,6.6 76.5,6.91 74.35,6.91 v5(74,6.57) 74,6.53 73.55,6.08 65.92,6.08 64.31,4.46 60.92,4.46 59.28,6.1 v7(55.52,6.1)
  BOTTOM w0.081: v7(55.52,6.1) 53.31,3.89 JPTRON.3
TRON_TOP_R_DRV#: length 67.4
  TOP w0.081: v5(73.39,6.44) 72.88,6.44 v2(72.75,6.3)
  IN4 w0.058: v7(55.14,6.43) 59.18,6.43 60.98,4.62 64.24,4.62 65.86,6.24 72.61,6.24 72.9,6.53 73.3,6.53 v5(73.39,6.44) 73.48,6.53 73.48,6.86 73.71,7.09 76.56,7.09 76.89,6.76 77.93,6.76 78.07,6.9 81.7,6.9 82.17,7.37 84.65,7.37 92.04,14.76 96.96,14.76 97.83,15.63 100.45,15.63 100.91,16.08 103.96,16.08 104.88,15.16 v7(109.37,15.16)
  BOTTOM w0.081: v7(55.14,6.43) 52.52,3.8 JPTRON.2
TSENSE_2PH: length 4.8
  TOP w0.203: PRZ21.1 138.37,123.21 PCZ5.1 139,124.92 139,125.35 139.5,125.85 PUZ1.25
TSENSE_4PH: length 3.9
  TOP w0.203: PCZ3.1 137.87,132.29 PRZ23.1 v2(139.04,131.47) 139.19,131.47 139.78,130.89 139.78,130.5 140.02,130.25 PUZ1.14
TSENSE_GPU: length 162.4
  TOP w0.203: PUV1.33 75.17,32.13 v5(76.01,32.97)
  IN2 w0.254: 53.14,42.05 52.82,42.05 52.43,42.45 49.53,42.45 49.07,41.99 48.11,41.99 47.65,42.45 46.68,42.45 46.21,41.98 v5(45.45,41.98) 45.17,41.98 44.26,42.89 41.82,42.89 40.79,41.86 40.03,41.86 39.65,42.24 39.12,42.24 38.94,42.06 37.99,42.06 ; 53.14,42.05 v5(53.14,42.04) ; 53.14,42.05 53.25,41.94 53.78,41.94 54.18,42.33 54.67,42.33 55.02,41.99 56.22,41.99 57.04,42.8 v5(60.12,42.8) 60.19,42.8 60.41,42.8 60.66,43.04 61.45,43.04 61.45,43.04 61.81,43.04 61.81,43.04 62.14,43.04 63.26,41.93 64.34,41.93 65.27,42.85 66.08,42.85 66.17,42.94 67.12,42.94 67.21,42.85 67.7,42.85 68.49,42.06 68.63,42.06 ; v5(30.42,42.24) 31.17,42.24 31.27,42.34 32.17,42.34 32.58,41.94 33.57,41.94 34.58,42.95 36.96,42.95 37.85,42.06 37.99,42.06 ; 37.99,42.06 v5(37.99,42.05) ; 68.63,42.06 69.22,42.06 69.67,42.51 69.96,42.51 70.26,42.22 70.26,39.4 69.65,38.79 69.1,38.79 68.69,38.38 59.69,38.38 58.92,37.61 58.92,36.88 58.92,36.43 58.92,36.43 58.92,36.28 58.92,34.45 58.92,34.28 60.33,32.87 60.33,31.65 61.34,30.63 62.81,30.63 63.32,31.14 68.83,31.14 71.37,33.68 75.67,33.68 76.01,33.34 v5(76.01,32.97) ; 68.63,42.06 v5(68.63,42.04) ; v5(70.1,80.55) 70.91,80.55 71.49,79.97 73.05,79.97 73.62,79.4 79.31,79.4 81.43,77.28 81.43,70.59 80.16,69.31 80.16,57.41 80.78,56.79 80.78,42.18 v4(81.15,41.81)
  IN3 w0.254: v9(22.69,43.27) 22.69,42.48 23.37,41.81 23.37,41.35 24.03,40.69 29.18,40.69 30.42,41.93 v5(30.42,42.24)
  GND4 w0.254: v9(22.69,43.27) 22.42,43.55 v4(22.42,43.64)
  IN4 w0.254: v5(30.42,42.24) 30.4,42.26 30.4,43.06 30.18,43.29 v7(30.18,43.78)
  BOTTOM w0.254: PRV223.1 v5(76.01,32.97) 76.01,34.06 76.52,34.57 80.75,34.57 81.79,35.61 v2(81.79,39.59) 81.79,41.18 v4(81.15,41.81)
UART_2_PRXD_DTXD: length 46
  TOP w0.081: JWDB.3 124.44,45.21 v4(124.44,45.21)
  TOP w0.089: UH1.BD20 102.66,27.07 102.66,26.35 102.53,26.22 102.53,25.78 102.12,25.37 102.06,25.37 102.02,25.32 102.01,25.32 101.94,25.25 101.94,25.25 101.84,25.14 101.84,24.64 101.65,24.45 101.65,24.19 101.74,24.1 v5(101.88,24.1)
  IN1 w0.058: v5(117.99,36.8) 118.1,36.92 118.1,37.32 117.6,37.82 117.27,37.82 117.26,37.81 117.24,37.81
  IN1 w0.089: v5(101.88,24.1) 101.85,24.13 101.85,25.55 102.66,26.36 102.66,28.86 104.04,30.25 104.04,30.6 103.23,31.41 103.23,32.57 104.47,33.81 104.47,34.39 104.89,34.81 107.49,34.81 108.78,36.1 109.77,37.09 115.16,37.09 115.89,37.81 117.24,37.81
  BOTTOM w0.081: v4(124.44,45.21) 120.81,45.21 117.99,42.39 v5(117.99,36.8)
UART_2_PTXD_DRXD: length 85.8
  TOP w0.081: JWDB.2 124.36,44.41 v4(124.44,44.32) ; v8(134.87,19.64) 135,19.51 v2(135,19.17) 134.79,18.95 134.79,17.68 135.01,17.46 JWDB1.3
  TOP w0.089: v5(101.24,24.04) 101.47,24.27 101.47,24.53 101.66,24.71 101.66,25.22 101.76,25.32 101.76,25.32 101.94,25.5 101.94,25.5 101.98,25.54 102.05,25.54 102.35,25.85 102.35,26.31 102.43,26.39 UH1.BE20
  IN1 w0.058: 117.24,37.99 117.26,37.99 117.27,37.98 117.67,37.98 118.4,37.25 118.4,36.99 v5(118.61,36.78) 118.94,37.11 128.19,37.11 128.75,37.67 132.42,37.67 136.02,34.07 136.27,34.07 138.62,31.71 138.62,28.67 135.95,26 135.95,19.7 135.9,19.64 v8(134.87,19.64)
  IN1 w0.089: v5(101.24,24.04) 101.24,24.3 101.67,24.73 101.67,25.63 102.48,26.44 102.48,28.93 103.87,30.32 103.87,30.53 103.05,31.34 103.05,32.64 104.29,33.88 104.29,34.46 104.82,34.98 107.41,34.98 108.95,36.53 109.69,37.26 115.09,37.26 115.81,37.99 117.24,37.99
  BOTTOM w0.081: v5(118.61,36.78) 118.4,36.99 118.4,42.01 120.71,44.32 v4(124.44,44.32)
UD1_ISL95338_1:
  vias: v5(48.01,35.83) v5(48.59,38.17) v5(48.59,37.58) v5(48.59,37) v5(48.59,36.41) v5(48.59,35.83) v5(49.17,38.17) v5(49.17,37.58) v5(49.17,37) v5(49.17,36.41) v5(49.17,35.83) v5(49.76,38.17) v5(49.76,37.58) v5(49.76,37) v5(49.76,36.41) v5(49.76,35.83) v5(50.21,29.57) v5(50.21,28.32) v5(50.21,27.08) v5(50.21,25.83) v5(52.29,37.11) v5(52.29,36.53) v5(57.2,34) v10(51.23,37.2)
UG1_ISL95338_1: length 17.6
  TOP w0.635: PQV01.1 50.51,31.35 50.53,31.33 v8(51.13,31.33) ; v5(51.77,25.5) 51.48,25.8 PQV02.1
  IN1 w0.635: v8(51.13,31.33) 51.13,30.71 52.11,29.73 52.11,25.84 v5(51.77,25.5)
  IN3 w0.635: 55.04,33.33 54.48,32.77 54.48,29.81 54.97,29.33 54.97,28.29 54.28,27.6 54.28,27.6 52.79,26.11 52.18,25.5 v5(51.77,25.5)
  vias: v4(55.31,34.25) v4(55.59,34.03) v9(55.28,33.82) v9(55.55,33.67)
UG2_ISL95338_1: length 34.2
  IN2 w0.635: v5(32.94,33.11) 33.06,33 33.06,29.5 v5(31.62,28.06)
  IN3 w0.508: 47.43,26.33 47.52,26.42 49.88,26.42 49.95,26.48 50.48,26.48 50.57,26.4
  IN3 w0.635: v5(31.62,28.06) 31.65,28.06 34.33,25.39 43.61,25.39 44.55,26.33 47.43,26.33 ; 52.51,30.66 52.51,28.35 50.57,26.4
  BOTTOM w0.203: PUV3.5 v4(53.66,31.39) v4(53.28,31.39)
  BOTTOM w0.635: PQV3.1 v5(31.62,28.06) ; v5(32.94,33.11) 32.92,33.11 32.54,33.49 PQV4.1
  vias: v9(52.58,31.22) v9(52.93,31.23)
UG_+1VALWP: length 1.9
  TOP w0.254: PUH1.9 135.47,29.64 v5(135.13,29.3)
  BOTTOM w0.081: v5(135.13,29.3) 135.52,28.91 v2(135.52,28.58)
  vias: v5(131.89,33.49)
UG_CHG:
  vias: v2(40.68,19.42)
UG_CHG_R: length 0.9
  BOTTOM w0.081: 37.73,19.43 v2(37.73,18.58)
USB2_COMP: length 5
  TOP w0.089: v2(89.71,45.87) 89.79,45.95 RH109.1
  TOP w0.381: 93.12,45.58 93.04,45.5 92.96,45.58 92.96,45.58 91.08,45.58 RH109.1
USB3_PRX_C_DTX_N8: length 3
  TOP w0.089: CI38.2 40.6,146.73 40.24,147.08 40.24,147.36 39.71,147.9 39.71,148.32 39.85,148.46 JCDRA.36
USB3_PRX_C_DTX_P8: length 2.9
  TOP w0.089: JCDRA.37 39.45,148.41 39.51,148.36 39.51,147.81 40.02,147.3 40.02,147.08 39.66,146.73 CI39.2
USB3_PRX_DTX_N5: length 55.7
  IN1 w0.076: 117.24,45.57 117.27,45.6 117.32,45.6 117.33,45.59 117.44,45.59 118.19,44.85 122.97,44.85 124.85,42.98 129.29,42.98 135.81,36.46 138.54,36.46 140.62,34.38 144.79,34.38 145.16,34.75 145.16,34.96 145.24,35.04 v4(145.34,35.04)
  IN1 w0.089: v8(98.79,44.29) 98.82,44.2 98.74,44.03 98.47,43.76 98.47,43.41 98.87,43.02 99.25,43.02 100.71,44.48 102.11,44.48 102.81,45.18 103.63,45.18 105.35,46.89 109.5,46.89 109.86,47.24 111.03,47.24 111.95,46.32 111.95,46.09 112.22,45.83 112.83,45.83 113.08,45.57 117.24,45.57
USB3_PRX_DTX_N6: length 52.7
  IN1 w0.076: 117.24,47.04 117.37,47.04 118.29,46.12 119.63,46.12 120.08,46.57 120.9,46.57 121.6,45.87 127.67,45.87 133.73,39.82 136.3,39.82 140.35,35.77 142.51,35.77 143.27,36.53 143.71,36.53 143.9,36.33 143.9,36.16 144.1,35.96 v4(144.14,35.96)
  IN1 w0.089: 117.24,47.04 116.74,47.04 115.82,46.13 113.6,46.13 112.77,46.95 112.08,46.95 111.26,47.77 108.96,47.77 108.61,47.42 103.34,47.42 101.65,45.74 99.6,45.74 99.38,45.52 99.26,45.52 v8(99.18,45.6)
USB3_PRX_DTX_N7: length 140.8
  TOP w0.089: v8(97.4,44.73) 97.52,44.73 98.06,44.19 98.06,43.64 98.67,43.03 100.4,43.03 100.63,43.26 100.63,45.04 100.75,45.11 100.87,45.08 UH1.G17
  IN1 w0.076: v4(8.86,16.26) 9,16.11 9,15.98 9.2,15.79 12.14,15.79 13.28,16.93 13.28,19.4 12.28,20.41 12.28,25.41 13.82,26.94 13.82,29.73 14.01,29.92 14.01,35.75 13.64,36.12 13.64,38.04 14.86,39.26 14.86,47.04 15.33,47.51 15.33,52.89 19.62,57.18 75.59,57.18 81.97,50.81 81.97,48.87 85.72,45.11 88.47,45.11 88.48,45.13 88.5,45.13
  IN1 w0.089: v8(97.4,44.73) 97.4,44.82 97.38,44.82 97.19,45.02 97.06,45.02 96.03,43.99 95.33,43.99 95.19,43.84 93.54,43.84 92.25,45.13 88.5,45.13
USB3_PRX_DTX_N8: length 152.5
  TOP w0.107: UH1.R21 v5(102.37,41.5)
  IN1 w0.076: v8(40.64,145.81) 40.37,145.81 40.23,145.67 40.23,145.21 40.34,145.11 55.43,145.11 56.73,143.82 57.73,143.82 60.99,140.56 60.99,138.04 62.13,136.9 62.13,126.59 67.67,121.05 69.23,121.05 v5(69.42,121.24)
  IN4 w0.076: 88.5,44.67 85.19,44.67 83.55,46.3 83.55,71.5 82.85,72.2 82.85,98.14 76.77,104.22 76.77,112.12 70.18,118.71 70.18,120.86 69.99,121.05 69.61,121.05 v5(69.42,121.24)
  IN4 w0.089: v5(102.37,41.5) 102.37,41.63 102.46,41.72 102.65,41.72 102.77,41.6 102.77,41.2 102.49,40.92 100.71,40.92 100,40.21 96.26,40.21 93.02,43.45 91.14,43.45 89.92,44.67 88.5,44.67
USB3_PRX_DTX_P5: length 55.7
  IN1 w0.076: v4(144.74,35.04) 144.88,35.04 144.96,34.96 144.96,34.84 144.7,34.58 140.7,34.58 138.62,36.67 135.89,36.67 129.38,43.18 124.93,43.18 123.06,45.05 118.27,45.05 117.53,45.79 117.24,45.79
  IN1 w0.089: v8(99.05,43.56) 99.3,43.8 99.3,43.93 99.17,44.05 99.02,44.05 98.74,43.78 98.74,43.78 98.65,43.66 98.65,43.49 98.94,43.2 99.18,43.2 100.64,44.66 102.03,44.66 102.73,45.35 103.56,45.35 105.27,47.07 109.43,47.07 109.78,47.42 111.1,47.42 112.13,46.39 112.13,46.17 112.29,46 112.9,46 113.16,45.75 117.17,45.75 117.21,45.79 117.24,45.79
USB3_PRX_DTX_P6: length 52.6
  IN1 w0.076: v4(143.54,35.96) 143.7,36.12 143.7,36.25 143.62,36.32 143.36,36.32 142.6,35.56 140.26,35.56 136.21,39.61 133.64,39.61 127.58,45.67 121.52,45.67 120.82,46.37 120.16,46.37 119.71,45.92 118.21,45.92 117.27,46.86 117.25,46.86 117.25,46.87 117.24,46.87
  IN1 w0.089: 117.24,46.87 116.81,46.87 115.9,45.95 113.53,45.95 112.7,46.78 112,46.78 111.18,47.6 109.04,47.6 108.69,47.25 103.42,47.25 101.73,45.56 99.67,45.56 99.32,45.2 99.31,45.08 99.4,44.96 99.55,44.93 v8(99.56,44.93)
USB3_PRX_DTX_P7: length 140.7
  TOP w0.089: v8(97.67,45) 97.67,44.83 98.23,44.27 98.23,43.72 98.74,43.21 100.33,43.21 100.46,43.33 100.46,45.14 100.71,45.29 100.71,45.46 UH1.F16
  IN1 w0.076: 88.5,45.3 88.48,45.3 88.47,45.32 85.81,45.32 82.17,48.96 82.17,50.89 75.68,57.38 19.54,57.38 15.13,52.97 15.13,47.6 14.66,47.13 14.66,39.34 13.44,38.12 13.44,36.03 13.8,35.66 13.8,30 13.61,29.81 13.61,27.03 12.08,25.49 12.08,20.32 13.08,19.32 13.08,17.02 12.06,15.99 9.28,15.99 9.21,16.07 9.21,16.18 9.28,16.26 v4(9.46,16.26)
  IN1 w0.089: 88.5,45.3 92.33,45.3 93.61,44.02 95.11,44.02 95.26,44.17 95.95,44.17 96.98,45.19 97.26,45.19 97.46,45 v8(97.67,45)
USB3_PRX_DTX_P8: length 152.4
  TOP w0.107: UH1.P21 v5(103.16,41.49)
  IN1 w0.076: v5(69.42,120.66) 69.23,120.85 67.58,120.85 61.93,126.51 61.93,136.81 60.78,137.95 60.78,140.48 57.65,143.61 56.64,143.61 55.35,144.91 40.25,144.91 40.03,145.13 40.03,145.67 39.89,145.81 v8(39.62,145.81)
  IN4 w0.076: 88.5,44.47 85.1,44.47 83.35,46.22 83.35,71.42 82.65,72.12 82.65,98.05 76.57,104.14 76.57,112.04 69.98,118.63 69.98,120.77 69.9,120.85 69.61,120.85 v5(69.42,120.66)
  IN4 w0.089: v5(103.16,41.49) 102.94,41.28 102.94,41.12 102.56,40.74 100.79,40.74 100.08,40.03 96.19,40.03 92.95,43.27 91.06,43.27 89.86,44.48 89.84,44.47 88.5,44.47
