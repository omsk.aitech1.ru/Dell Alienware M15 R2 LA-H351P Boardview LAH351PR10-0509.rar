# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PVCC_FBVDDQ: length 17.5
  TOP w0.081: v10(2.24,46.55) 2.59,46.19 PRW5.2
  TOP w0.254: v8(1.78,46.26) 1.78,45.52 2.03,45.26 PRW5.2 ; v8(5.92,55.87) 5.92,55.74 6.54,55.12 6.54,55.08 6.67,54.95 PUW1.17
  IN1 w0.254: v8(5.92,55.87) 5.26,55.87 5.23,55.89 4.05,55.89 2.29,54.13 2.29,46.76 v8(1.78,46.26)
VBAT_CHG: length 3.1
  BOTTOM w0.203: PRB26.1 42.85,21.57 43.17,21.25 v2(43.17,21.06) 43.36,21.06 44.31,20.11 PUB1.26
VCC1_NVVDD: length 1.8
  GND2 w0.254: v1(25.09,42.42) v3(25.09,42.87)
  GND4 w0.254: v3(25.09,42.87) 25.37,43.15 v4(25.37,43.25)
  BOTTOM w0.254: PCV66.1 25.43,43.3 v4(25.37,43.25)
VCC2_NVVDD: length 1.8
  GND2 w0.254: v1(32.65,42.42) v3(32.65,42.95)
  GND4 w0.254: v3(32.65,42.95) 32.94,43.25 v4(32.97,43.25)
  BOTTOM w0.254: PCV65.2 32.88,43.33 v4(32.97,43.25)
VCC3_NVVDD: length 1.9
  GND2 w0.254: v1(40.21,42.42) v3(40.21,42.82)
  GND4 w0.254: v3(40.21,42.82) 40.4,43.01 v4(40.4,43.32)
  BOTTOM w0.254: v4(40.4,43.32) 40.46,43.39 40.46,43.97 PCV100.2
VCC4_NVVDD: length 2.1
  GND2 w0.254: v1(47.83,42.42) 47.83,42.62 v3(48.11,42.9)
  GND4 w0.254: v4(48.11,43.33) v3(48.11,42.9)
  BOTTOM w0.254: PCV101.2 48.15,44.11 48.15,43.37 v4(48.11,43.33)
VCC5_NVVDD: length 1.8
  GND2 w0.254: v1(55.51,42.42) 55.51,42.76 v3(55.48,42.8)
  GND4 w0.254: v4(55.75,42.98) 55.73,42.98 55.55,42.8 v3(55.48,42.8)
  BOTTOM w0.254: v4(55.75,42.98) 55.75,44.05 PCV129.2
VCC6_NVVDD: length 1.8
  GND2 w0.254: v3(63.32,42.97) 63.32,42.48 v1(63.26,42.42)
  GND4 w0.254: v4(63.32,43.32) v3(63.32,42.97)
  BOTTOM w0.254: v4(63.32,43.32) 63.35,43.35 PCV130.2
VCC7_NVVDD: length 1.7
  GND2 w0.254: v1(70.81,42.42) v3(70.81,42.85)
  GND4 w0.254: v3(70.81,42.85) 71.03,43.07 v4(71.03,43.26)
  BOTTOM w0.254: PCV158.2 71.01,43.28 v4(71.03,43.26)
VCC8_NVVDD: length 3.5
  TOP w0.081: v2(71.01,77.87) v5(71.67,77.87)
  TOP w0.254: v5(71.67,77.87) 71.92,77.61 PUV11.3
  BOTTOM w0.254: PRV179.2 71.31,77.87 v5(71.67,77.87) 71.77,77.76 71.84,77.76 71.85,77.75 PCV160.2
VCC_1.0VS_VGAP: length 3.2
  BOTTOM w0.254: PU1101.13 70.7,106.57 v2(69.92,107.35) 69.74,107.53 PC1105.1
VCC_+1.8VGS: length 10.3
  TOP w0.081: v2(54.29,3.27) PR1810.1
  TOP w0.254: PR1810.1 51.52,4.71 51.19,4.71 51.16,4.75 PC1812.1 50.31,4.75 v5(49.95,5.11) 49.97,5.13 49.97,5.49 49.76,5.7 PU1802.13 ; PR1809.1 47.78,4.2 PU1802.10
  TOP w0.508: v8(48.45,3.52) PR1809.1
  IN1 w0.254: v8(48.45,3.52) 49.95,5.02 v5(49.95,5.11)
VCC_CORE_PH1: length 1.2
  BOTTOM w0.081: v5(88.58,123.6) v2(88.58,122.41)
  vias: v5(88.58,124.17)
VCC_CORE_PH2: length 0.6
  BOTTOM w0.081: v5(96.14,123.66) v10(96.76,123.66)
  vias: v5(96.14,124.23)
VCC_CORE_PH3: length 0.6
  BOTTOM w0.081: v5(103.82,123.73) v10(104.42,123.73)
  vias: v5(103.82,124.3)
VCC_CORE_PH4: length 0.9
  BOTTOM w0.081: v5(111.63,124.3) 111.75,124.3 v10(112.33,124.88)
  vias: v5(111.63,123.73)
VCC_CORE_PH5: length 0.8
  TOP w0.081: 121.21,133.86 v2(121.21,134.7)
  vias: v5(121.86,128.42) v5(121.86,127.79)
VCC_CORE_PH6: length 2.2
  BOTTOM w0.508: PRZ127.1 v2(122.86,121.76) v5(123.46,121.76)
VCC_VCCIO: length 3.4
  TOP w0.254: PUH2.13 133.32,52.89 133.14,53.07 v5(133.14,54.24)
  BOTTOM w0.081: v5(133.14,54.24) v2(133.14,54.97)
  BOTTOM w0.508: PCH18.1 133.22,54.16 v5(133.14,54.24)
VCCGT_SENSE: length 42.6
  TOP w0.081: v2(148.46,120.65) 147.8,121.31 v5(147.45,121.31)
  TOP w0.152: UC1.AH38 116.37,111.67 116.53,111.67 117.03,112.17 117.98,112.17 118.47,112.66 118.47,113.93 RH203.1 v1(117.77,115.7)
  TOP w0.254: PRZ31.1 v5(147.45,121.31)
  GND2 w0.152: v1(117.77,115.7) v12(117.77,115.98)
  IN2 w0.152: v12(117.77,115.98) 125.2,115.98 125.96,116.74 131.27,116.74 133.78,119.26 137.5,119.26 140.45,122.2 144.34,122.2 144.84,121.69 144.84,121.06 145.16,120.74 146.88,120.74 v5(147.45,121.31)
  BOTTOM w0.254: PRZ19.2 147.38,121.38 v5(147.45,121.31)
VCCIO_PGOOD: length 3.9
  TOP w0.081: PRH18.2 138.23,50.17 v2(138.35,50.04)
  TOP w0.254: PUH2.7 137.48,52.44 137.73,52.18 137.73,51.21 137.99,50.95 PRH18.2
VCCIO_SENSE: length 90.7
  TOP w0.254: v5(101.37,93.35) 101.35,93.35 101.32,93.37 101.24,93.37 UC1.H14
  IN1 w0.254: v5(101.37,93.35) 101.14,93.12 99.57,93.12 98.55,92.1 97.17,92.1 96.91,91.85 96.91,88.25 96.59,87.93 96.59,86.21 97.03,85.78 97.03,85.13 94.53,82.63 92.39,82.63 91.46,81.71 91.46,79.97 91.7,79.74 91.7,59.43 93.38,57.76 100.47,57.76 101.03,57.2 105.07,57.2 105.47,57.6 107.9,57.6 108.45,57.04 113.67,57.04 114.44,57.81 117.16,57.81 118.02,56.95 122.73,56.95 123.21,56.46 124.74,56.46 125.55,55.65 136.73,55.65 v8(136.98,55.91)
  BOTTOM w0.081: v5(101.37,93.35) v2(101.37,93.87)
VCCSA_SENSE: length 123.3
  TOP w0.254: UC1.M38 103.51,111.78 103.63,111.89 103.63,114.16 103.23,114.56 100.36,114.56 99.72,113.91 98.09,113.91 97.77,113.59 94.91,113.59 94.28,114.22 94.28,114.28 ; v5(149.63,132.29) 149.92,132.29 150.3,131.9 PRZ24.1
  TOP w0.381: 94.28,114.28 94.28,114.6 95.19,115.51 RH201.1 v5(95.8,116.11)
  IN2 w0.254: v3(145.64,135.99) 145.28,135.63 145.28,135.27 145.57,134.98 147.69,134.98 148.08,134.58 148.59,134.58 149.03,135.03 149.73,135.03 150.69,134.08 150.69,132.74 150.23,132.29 v5(149.63,132.29)
  IN3 w0.254: v3(145.64,135.99) 145.34,136.3 140.49,136.3 140.17,136.62 123.31,136.62 122.99,136.3 108.69,136.3 107.29,134.9 105.94,134.9 104.52,136.32 99.47,136.32 97.79,134.65 94.23,134.65 94.06,134.48 92.87,134.48 90.97,132.57 90.61,132.57 89.89,133.3 88.55,133.3 86.68,131.43 83.67,131.43 82.07,129.83 82.07,118.4 84.18,116.3 95.61,116.3 v5(95.8,116.11)
  BOTTOM w0.081: PRZ30.2 v2(151.59,132.63)
  BOTTOM w0.254: v5(149.63,132.29) 149.97,132.63 PRZ30.2
VCCSENSE: length 59.1
  TOP w0.152: v1(115.16,115.7) 114.22,114.76 113.7,114.76 RH197.2 113.86,114.27 113.99,114.27 114.23,114.03 114.23,112.82 114.65,112.41 114.65,112.01 114.93,111.73 114.93,111.02 115.19,110.76 UC1.AG37
  GND2 w0.152: v1(115.16,115.7) v12(115.16,115.95)
  IN2 w0.152: v4(146.75,133.94) 148.22,133.94 148.53,133.63 148.53,130.03 149.61,128.95 149.61,123.45 148.42,122.27 145.58,122.27 145.08,122.77 139.15,122.77 136.23,119.85 133.56,119.85 130.96,117.25 125.75,117.25 125.05,116.55 115.85,116.55 115.25,115.95 v12(115.16,115.95)
  BOTTOM w0.081: v2(146.67,134.39) 146.75,134.32 v4(146.75,133.94)
  BOTTOM w0.203: v4(146.75,133.94) 146.88,133.81 PRZ18.1
VDD_1.2V:
  vias: v2(149.53,44.81)
VDD_CHG: length 27.6
  TOP w0.254: PRB19.1 45.92,12.72 45.21,13.43 43.94,13.43 43.62,13.74 43.62,16.28 43.18,16.73 v2(42.68,16.73) v5(41.85,16.73) 41.16,16.73 PRB9.1 39.8,16.59 39.69,16.47 v5(39.69,14.25)
  IN2 w0.254: v5(41.85,16.73) 42.29,16.73 43.24,17.68 43.24,19.08 43.75,19.59 47.31,19.59 47.82,20.09 49.34,20.09 50.42,19.01 v5(50.86,19.01)
  BOTTOM w0.203: PCB22.2 41.35,16.79 41.78,16.79 v5(41.85,16.73) 41.91,16.79 42.42,16.79 42.7,17.07 PUB1.19
  BOTTOM w0.254: PRB35.1 v5(39.69,14.25) ; PRB31.1 v5(50.86,19.01)
VDD_ISL95338_1: length 5.9
  TOP w0.081: v2(57.99,29.72) 58.39,30.13 58.39,30.57 PCV24.2
  TOP w0.254: PCV24.2 58.56,30.76 PRV99.1 59.26,32.29 v5(59.31,32.29)
  BOTTOM w0.203: PRV98.1 60.4,33.49 60.01,33.1 60.01,32.79 59.5,32.29 v5(59.31,32.29) 59.21,32.19 PUV3.18
VDDP_1.2V: length 8.6
  TOP w0.203: v5(149.28,46.68) 149.07,46.88 PUM1.12
  TOP w0.381: PCM17.2 v5(149.77,47.7)
  BOTTOM w0.381: v5(149.78,41.19) 149.78,41.63 149.28,42.14 v5(149.28,46.68) 149.77,47.17 v5(149.77,47.7)
  vias: v10(149.31,40.49)
VDDP_ISL95338_1: length 4
  BOTTOM w0.081: PCV23.1 52.65,33.02 51.99,33.68 v2(51.89,33.68)
  BOTTOM w0.203: PUV3.8 52.67,32.59 PCV23.1
  BOTTOM w0.254: PRV91.1 PCV23.1
VIN1N: length 6.2
  TOP w0.254: RG62.2 2.73,39.84 3.24,39.33 3.24,38.95 v2(3.85,38.34) 3.99,38.2 3.99,36.71 4.36,36.34 4.36,34.75 UG37.1
VIN1P: length 6
  TOP w0.254: RG1501.1 2.62,38.75 3.61,37.76 3.61,36.5 v2(3.66,36.45) 3.66,36.22 3.98,35.91 3.98,34.93 3.92,34.87 3.92,34.37 4.17,34.11 UG37.2
VIN2N: length 3.7
  TOP w0.254: RG66.2 3.12,35.65 3.56,35.21 v2(3.56,35.16) 3.56,33.87 4.12,33.31 UG37.4
VIN2P: length 3.2
  TOP w0.254: RG64.1 2.73,34.83 3.16,34.39 3.16,33.62 v2(3.51,33.28) 3.87,32.91 UG37.5
VINMON_GPU: length 3.7
  TOP w0.203: PRV54.1 78.55,29.49 v5(78.49,29.43) 78.41,29.5 PUV1.27
  BOTTOM w0.081: v5(78.49,29.43) v2(78,29.43)
  BOTTOM w0.254: PRV82.2 79.1,29.48 78.54,29.48 v5(78.49,29.43)
VSSGT_SENSE: length 41.1
  TOP w0.081: v1(116.33,115.62) v2(116.79,115.62)
  TOP w0.152: v1(116.33,115.62) RH472.1 117.09,113.77 117.09,113.04 115.69,111.64 115.69,111.07 116,110.76 UC1.AH37
  TOP w0.203: v3(145.54,119.65) PRZ22.2
  GND2 w0.152: v1(116.33,115.62) v12(116.33,115.88)
  IN2 w0.152: v12(116.33,115.88) 117.39,115.88 117.59,115.67 117.93,115.67 117.98,115.72 125.3,115.72 126.06,116.49 131.37,116.49 133.89,119 137.61,119 140.55,121.95 144.23,121.95 144.59,121.59 144.59,120.95 145.54,120 v3(145.54,119.65)
VSSIO_SENSE: length 16.3
  TOP w0.254: UC1.J14 101.46,93.8 v5(101.98,93.8) ; PRH21.2 v2(91.01,87.16) 91.01,88.57 v5(91.21,88.78)
  IN4 w0.254: v5(101.98,93.8) 100.87,93.8 99.67,92.61 99.14,92.61 98.55,92.03 97.46,92.03 95.25,89.82 92.25,89.82 v5(91.21,88.78)
VSSSA_SENSE: length 121.3
  TOP w0.254: UC1.M37 103.58,110.76 103.92,111.11 103.92,111.68 103.97,111.73 103.97,114.49 103.56,114.9 100.22,114.9 99.58,114.26 97.94,114.26 RH469.1
  TOP w0.381: v5(96.69,116.11) RH469.1
  IN2 w0.254: v4(151.21,128.81) 151.21,134.19 149.61,135.79 147.32,135.79 146.99,135.46 v3(145.85,135.46)
  IN3 w0.254: v3(145.85,135.46) 145.47,135.46 144.98,135.94 140.34,135.94 140.02,136.26 123.46,136.26 123.14,135.94 108.84,135.94 107.44,134.55 105.79,134.55 104.37,135.97 99.61,135.97 97.94,134.29 94.38,134.29 94.21,134.12 93.02,134.12 91.12,132.22 90.47,132.22 89.74,132.95 88.7,132.95 86.82,131.07 83.81,131.07 82.43,129.68 82.43,118.55 84.26,116.72 96.24,116.72 96.69,116.27 v5(96.69,116.11)
  BOTTOM w0.081: v2(150.74,127.85) 150.74,128.34 v4(151.21,128.81)
  BOTTOM w0.254: v4(151.21,128.81) PRZ26.1
VSSSENSE: length 57.2
  TOP w0.152: UC1.AG38 115.33,112.56 114.79,113.1 114.79,113.97 115.35,114.54 RH466.1 115.44,115.37 v1(115.7,115.62)
  TOP w0.254: v5(149.91,133.87) 150.37,134.32 PRZ33.2 PRZ25.1
  GND2 w0.152: v1(115.7,115.62) v12(115.7,115.88)
  IN2 w0.152: v12(115.7,115.88) 115.7,116.04 115.95,116.3 125.15,116.3 125.85,116.99 131.06,116.99 133.67,119.6 136.33,119.6 139.26,122.52 144.97,122.52 145.48,122.01 148.53,122.01 149.86,123.34 149.86,129.06 148.78,130.14 148.78,133.5 149.14,133.87 v5(149.91,133.87)
  BOTTOM w0.081: v2(149.36,134.43) 149.91,133.88 v5(149.91,133.87)
1ST_PWR_GOOD: length 34.2
  GND2 w0.076: v1(77.16,12.86) 77.1,12.8 76.58,12.8
  GND2 w0.081: 76.58,12.8 v3(76.45,12.8)
  IN3 w0.058: v9(76.19,12.58) 76.21,12.58 76.21,12.59 76.24,12.59 v3(76.45,12.8)
  GND4 w0.081: v6(75.97,12.79) 76.18,12.58 v9(76.19,12.58)
  IN4 w0.058: v7(61.42,30.25) 61.61,30.25 61.85,30.5 62.51,30.5 63.27,31.26 63.27,31.28 63.33,31.33 65.05,31.33 66.62,29.76 66.62,23.21 67.67,22.16 67.67,21.26 69.56,19.37 69.77,19.37 69.83,19.32 74.35,19.32 v7(74.84,18.82) ; 76.58,14.69 76.32,14.42 76.32,13.95 75.97,13.61 v6(75.97,12.79) ; v7(77.53,18.82) 77.53,18.52 77.52,18.51 77.52,18.44
  IN4 w0.076: 76.58,14.69 76.75,14.86 76.75,17.6 77.52,18.37 77.52,18.38 77.52,18.44
  BOTTOM w0.081: v7(77.53,18.82) v2(76.29,18.82) v7(74.84,18.82)
81215_ALERT: length 1.5
  TOP w0.203: PUZ1.41 146.91,125.85 147.45,125.31 PRZ17.2
81215_SCLK: length 1.3
  TOP w0.203: PUZ1.42 147.27,126.25 147.45,126.08 PRZ10.1
81215_SDIO: length 1.8
  TOP w0.203: PUZ1.40 146.8,125.45 147,125.25 147,125 147.45,124.55 PRZ5.1
81215_VR_HOT: length 2.5
  TOP w0.203: PRZ28.1 147.43,123.73 146.8,124.36 145.92,124.36 145.72,124.56 PUZ1.39
+EC_VCCA: length 8.2
  TOP w0.076: 76.58,17.12 77.27,17.12 77.42,16.97 77.42,16.53 77.58,16.36 UE5.B11
  TOP w0.081: 76.58,17.12 75.75,17.12 75.56,17.3 74.87,17.3 74.43,17.74 CE172.1 74.28,18.07 74.1,18.25 74.1,20.28 v2(74.18,20.36) 74.36,20.54 LE1.2
+FBA_VREFC: length 65.5
  TOP w0.127: v2(62.34,122.89) 61.95,122.89 RG111.2
  TOP w0.254: UG11.K1 29.1,131.7 v3(29.1,130.46)
  TOP w0.406: RG111.2 RG112.1 v8(59.63,122.13)
  IN1 w0.406: v8(59.63,122.13) 58.86,122.13 58.13,122.86 58.13,123.43 59.16,124.46 59.16,133.14 v5(58.86,133.43) 58.41,133.43 58.1,133.12 v8(57.12,133.12)
  GND4 w0.254: v4(28.65,130.46) v3(29.1,130.46)
  IN4 w0.406: v4(28.65,130.46) 29.29,131.1 29.29,138.89 30.07,139.68 32.91,139.68 34.34,141.11 55.76,141.11 57.59,139.28 57.59,137.15 58.86,135.88 v5(58.86,133.43)
+FBB_VREFC: length 55.2
  TOP w0.254: v1(9.98,106.92) 9.81,107.09 UG13.K1
  IN1 w0.254: v3(9.91,105.44) 9.91,106.85 v1(9.98,106.92)
  GND2 w0.254: v1(8.88,133.91) v12(8.88,134.27)
  IN2 w0.254: v12(8.88,134.27) 8.52,134.27 7.89,134.9 2.03,134.9 1.46,134.33 1.46,121.1 2.84,119.73 3.43,119.73 4.7,118.46 v3(4.7,118.2) 4.7,118.01 4.41,117.73 2.13,117.73 1.91,117.5 1.91,105.82 2.29,105.44 v3(9.91,105.44)
  GND4 w0.508: v4(5.32,118.2) v3(4.7,118.2)
  BOTTOM w0.127: v4(5.32,118.2) v2(4.36,118.2)
  BOTTOM w0.508: v4(5.32,118.2) RG123.1 CG571.1 RG122.2
+FBC_VREFC: length 59.4
  IN2 w0.254: v3(8.88,99.75) 7.95,100.68 2.1,100.68 1.84,100.42 1.84,88.36 2.22,87.98 6.03,87.98 6.58,87.43 v4(6.58,83.51) 5.48,83.51 5.33,83.66 2.38,83.66 1.78,83.06 1.78,71.09 2.15,70.72 v3(9.59,70.72)
  IN3 w0.152: v3(9.59,70.72) 9.62,70.76 v3(9.62,72.93)
  BOTTOM w0.127: RG133.2 v2(9.15,82.56)
  BOTTOM w0.508: v4(6.58,83.51) RG134.1 CG148.1 RG133.2
+FBD_VREFC: length 58.7
  IN2 w0.254: v3(56.46,61.27) 56.08,60.89 v4(41.91,60.89) 41.63,60.61 v3(28.07,60.61)
  IN3 w0.254: v4(29.43,68.78) 28.13,67.48 28.13,60.67 v3(28.07,60.61) ; v3(56.46,61.27) 56.71,61.51 56.71,68.54 55.73,69.52 v3(55.32,69.52)
  BOTTOM w0.406: v4(41.91,60.89) 41.78,60.89 41.35,61.32 v2(41.35,66.46) 41.35,67.74 RG156.2
  BOTTOM w0.508: RG156.2 CG256.1 RG154.1 RG155.2
+FBX_PLLAVDD: length 67.5
  TOP w0.203: v1(30.56,103.06) 30.67,103.17 30.67,108.63 v1(30.57,108.73) ; 30.25,94.35 30.8,93.81 30.8,90.9 31.11,90.58 35.2,90.58 v1(35.27,90.52) ; v1(30.57,94.67) 30.67,94.77 30.67,102.33 UG1.L29
  TOP w0.254: UG1.AN42 v1(45.33,111.53) ; UG1.L29 v1(30.56,103.06) ; v1(30.57,94.67) 30.25,94.35 UG1.L17 ; UG1.V11 35.27,90.27 v1(35.27,90.52) ; UG1.L38 v1(30.57,108.73) ; UG1.AF42 v1(40.41,111.51)
  GND2 w0.254: v1(30.57,94.67) 30.78,94.87 v3(30.78,95.03) ; v1(45.33,111.53) 45.5,111.36 v3(46.1,111.36) ; v1(30.56,103.06) v3(30.88,103.38)
  GND2 w0.381: v1(35.27,90.52) 35.28,90.52 v4(35.53,90.26) ; v1(30.57,108.73) v3(30.96,108.73) ; v3(40.83,111.6) 40.74,111.51 v1(40.41,111.51)
  GND4 w0.203: v4(30.31,103.98) v4(30.31,103.34) 30.84,103.34 v3(30.88,103.38)
  GND4 w0.254: v3(46.1,111.36) 46.02,111.29 v4(45.56,111.29) ; v6(40.58,111.85) v3(40.83,111.6)
  GND4 w0.381: v4(30.63,109.06) 30.96,108.73 v3(30.96,108.73) ; v4(30.73,94.43) 30.73,94.99 v3(30.78,95.03)
  IN4 w0.508: v4(30.73,94.43) 30.42,94.74 30.42,101.37 29.78,102.01 29.78,111.83 30.29,112.33 40.09,112.33 v6(40.58,111.85) 41.13,112.41 45.05,112.41 45.56,111.9 v4(45.56,111.29)
  BOTTOM w0.127: v2(50.66,112.51) 50.53,112.38 LG6.1
+HDMI_5V_OUT:
  vias: v10(132.66,149.74)
+IFPCD_PLLVDD: length 0.8
  GND2 w0.254: v1(53.35,95.05) 53.35,95.4 v3(53.28,95.47)
  GND4 w0.508: v4(53.59,95.62) 53.44,95.62 53.29,95.47 v3(53.28,95.47)
  vias: v2(54.71,97.3)
+IFPE_PLLVDD: length 0.5
  GND2 w0.254: v4(53.59,93.31) 53.35,93.06 v1(53.35,92.95)
  vias: v2(54.93,93.65)
+INV_PWR_LCD: length 5.6
  TOP w0.081: v10(28.31,145.25) 28.31,145.05 29.26,144.1 FV4.2 ; v10(27.38,142.99) 27.2,142.99 25.55,141.34 v10(25.55,141.16)
  vias: v5(30.51,144.07) v5(30.51,143.5) v5(31.08,144.07) v5(31.08,143.5) v5(31.66,144.07) v5(31.66,143.5) v5(32.23,144.07) v5(32.23,143.5) v5(35.73,152.92) v5(35.73,152.29) v5(36.32,152.94) v5(36.32,152.3) v5(36.96,152.94) v5(36.96,152.3)
+INV_PWR_SRC: length 3.8
  TOP w0.081: v2(43.98,140.6) 41.1,140.6 CV14.1
+LCDVDD: length 30.2
  TOP w0.081: v10(18.95,137.44) 19.36,137.85 v5(20.36,137.85) ; v5(21.51,137.85) 21.51,138.16 22.16,138.81 v10(22.89,138.81)
  IN2 w1.524: 37.72,151.28 36.58,150.14 34.04,150.14 29.08,145.19 29.08,144.55
  BOTTOM w0.254: v5(38.35,152.94) 37.47,153.82 32.89,153.82 31.37,152.3 31.37,147.91 30.76,147.3 30.02,147.3 29.53,146.8 29.53,146.69 RV684.1
  vias: v5(20.94,137.85) v5(27.57,140.92) v5(27.99,140.3) v5(27.99,139.66) v5(38.35,152.3) v5(38.99,152.94) v5(38.99,152.3) v10(20.78,138.66)
+NVHS_CVDD1: length 24.9
  TOP w0.254: v8(65.49,81.88) RG1527.1
  IN1 w0.178: 64.52,81.56 65.18,81.56 v8(65.49,81.88)
  IN1 w0.254: v8(47.05,89.45) 47.02,89.41 47.02,85.98 51.9,81.09 64.05,81.09 64.52,81.56
+NVHS_CVDD2: length 24.1
  TOP w0.254: RG1528.1 v8(65.49,83.15)
  IN1 w0.254: v8(47.75,90.15) 48.41,89.49 48.41,86.13 52.38,82.16 62.19,82.16 63.18,83.15 v8(65.49,83.15)
+NVHS_DVDD1: length 23.8
  TOP w0.254: RG1523.1 v8(64.29,81.88) CG7148.1
  IN1 w0.254: v8(47.75,89.45) 47.37,89.07 47.37,86.13 52.05,81.45 63.86,81.45 v8(64.29,81.88)
+NVHS_DVDD2: length 21.8
  TOP w0.254: v8(63.67,82.51) CG7147.1 RG1586.1
  IN1 w0.254: v8(63.67,82.51) 63.56,82.51 62.85,81.8 52.23,81.8 47.75,86.29 v8(47.75,88.75)
+NVHS_DVDD3: length 22.3
  TOP w0.254: v8(64.87,84.42) RG1525.1 CG7146.1
  IN1 w0.254: v8(64.87,84.42) 64.38,83.92 64.06,83.92 63.83,84.15 62.92,84.15 61.65,82.89 52.7,82.89 49.15,86.43 v8(49.15,89.45)
+NVHS_DVDD4: length 22.3
  TOP w0.254: CG7145.1 v8(63.67,83.78) RG1588.1
  IN1 w0.254: v8(49.15,90.15) 48.77,89.77 48.77,86.27 52.53,82.51 61.91,82.51 63.18,83.78 v8(63.67,83.78)
+NVHS_HVDD1: length 28.6
  TOP w0.254: CG7153.1 RG1529.1 v8(64.87,78.07)
  IN1 w0.254: v8(64.87,78.07) 64.2,78.74 61.37,78.74 60.86,79.25 58.7,79.25 58.2,78.74 51.74,78.74 44.94,85.54 44.94,89.44 v8(44.95,89.45)
+NVHS_HVDD2: length 28.7
  TOP w0.254: RG1590.1 RG1530.1 v8(63.67,78.07)
  IN1 w0.254: v8(44.95,90.15) 44.58,89.78 44.58,85.4 51.59,78.39 58.34,78.39 58.85,78.89 60.66,78.89 61.26,78.29 63.45,78.29 v8(63.67,78.07)
+NVHS_HVDD3: length 26.6
  TOP w0.254: RG1591.1 CG7151.1 v8(63.67,79.34)
  IN1 w0.254: v8(63.67,79.34) 63.14,79.34 62.88,79.61 58.56,79.61 58.05,79.1 51.89,79.1 45.29,85.69 45.29,89.09 v8(45.65,89.45)
+NVHS_HVDD4: length 27.5
  TOP w0.254: v8(64.87,80.61) CG7150.1 RG1532.1
  IN1 w0.254: v8(64.87,80.61) 64.43,80.16 63.5,80.16 63.31,80.36 58.3,80.36 57.75,79.81 52.18,79.81 46.3,85.69 46.3,89.5 v8(45.65,90.15)
+NVHS_HVDD5: length 25.4
  TOP w0.254: RG1593.1 CG7149.1 v8(63.67,80.61)
  IN1 w0.254: v8(47.05,90.15) 46.66,89.76 46.66,85.83 52.33,80.16 57.61,80.16 58.18,80.74 63.54,80.74 v8(63.67,80.61)
+NVHS_PLL_HVDD: length 26.5
  TOP w0.254: v8(64.87,79.34) CG7157.1 RG1534.1
  IN1 w0.254: v8(45.65,88.75) 45.65,85.84 52.03,79.45 57.9,79.45 58.45,80 63.04,80 63.35,79.7 64.52,79.7 v8(64.87,79.34)
+NVVDD: length 180.2
  IN1 w0.254: v4(80.02,37.18) 80.02,52.09 76.89,55.22 74.45,55.22 73.67,54.45 v5(73.28,54.45)
  GND2 w0.203: v1(58.25,114.65) v3(57.9,114.65) ; v1(58.25,117.45) 57.9,117.45 57.9,117.45 57.55,117.45 v1(57.55,117.45) ; v1(35.15,110.45) 35.15,110.61 v3(34.99,110.77) ; v1(34.45,94.35) v3(34.45,94.68) v1(34.45,95.05) ; v1(44.95,98.55) v3(44.95,98.9) v1(44.95,99.25) ; v3(41.45,107.3) v1(41.45,106.95) ; v1(47.75,93.65) v3(47.75,93.31) v1(47.75,92.95) ; v1(37.25,92.95) v3(37.25,93.31) v1(37.25,93.65) ; v1(51.25,112.55) v3(51.6,112.55) ; v1(35.85,109.05) v3(35.85,108.69) v1(35.85,108.35) ; v1(31.65,100.65) v3(31.65,100.99) v1(31.65,101.35) ; v1(46.35,96.45) v3(46.35,96.1) v1(46.35,95.75) ; v1(44.25,110.45) v3(44.55,110.75) ; v3(47.9,91.88) 47.75,92.03 v1(47.75,92.25) ; v1(40.05,109.75) v3(40.05,110.1) ; v1(42.15,94.35) v3(42.15,94.71) v1(42.15,95.05) ; v1(40.75,110.45) v3(41.08,110.45) v1(41.45,110.45) ; v1(40.75,95.05) v3(40.75,94.68) v1(40.75,94.35) ; v1(47.05,110.45) v3(47.05,110.89) ; v1(34.45,100.65) v3(34.45,100.29) v1(34.45,99.95) ; v1(33.05,95.75) v3(33.05,96.08) v1(33.05,96.45) ; v1(34.45,93.65) v3(34.45,93.31) v1(34.45,92.95) ; v1(40.05,96.45) v3(40.05,96.1) v1(40.05,95.75) ; v1(38.65,96.45) v3(38.65,96.08) v1(38.65,95.75) ; v1(56.85,118.85) 56.85,118.85 56.15,118.85 v1(56.15,118.85) ; v1(41.45,102.05) v3(41.45,102.39) v1(41.45,102.75) ; v1(42.15,102.05) v3(42.15,101.69) v1(42.15,101.35) ; v1(44.95,101.35) v3(44.95,101.69) v1(44.95,102.05) ; v3(38.65,98.2) v1(38.65,98.55) ; v1(56.85,114.65) 56.57,114.65 v3(56.52,114.71) ; v3(37.79,110.77) 37.95,110.61 v1(37.95,110.45) ; v1(47.75,106.25) 47.75,105.88 v3(47.75,105.88) 47.75,105.88 v1(47.75,105.55) ; v1(43.55,102.75) v3(43.55,102.39) v1(43.55,102.05) ; v1(49.15,109.05) v3(49.15,108.69) v1(49.15,108.35) ; v1(37.95,91.55) 37.95,91.29 v3(38.01,91.22) ; v1(42.15,104.15) v3(42.15,104.49) v1(42.15,104.85) ; v1(35.85,106.95) v3(35.85,107.29) v1(35.85,107.65) ; v1(51.95,114.65) v1(52.65,114.65) ; v3(59.3,116.05) v1(58.95,116.05) ; v1(44.95,92.95) v3(44.95,93.31) v1(44.95,93.65) ; v1(47.75,100.65) v3(47.75,100.29) v1(47.75,99.95) ; v1(42.15,97.15) v3(42.15,97.52) v1(42.15,97.85) ; v1(35.85,94.35) v3(35.85,94.68) v1(35.85,95.05) ; v1(56.85,115.35) v1(57.55,115.35) ; v1(53.35,115.35) v1(52.65,115.35) ; v3(53.7,112.55) v1(54.05,112.55) ; v1(38.65,107.65) v3(38.65,107.29) v1(38.65,106.95) ; v1(33.05,95.05) v3(33.05,94.72) v1(33.05,94.35) ; v1(40.75,93.65) v3(40.75,93.31) v1(40.75,92.95) ; v1(51.95,109.75) v3(51.6,109.75) ; v1(46.35,94.35) v3(46.35,94.71) v1(46.35,95.05) ; v1(40.05,93.65) v3(40.05,93.31) v1(40.05,92.95) ; v1(38.65,109.05) v3(38.65,108.69) v1(38.65,108.35) ; v1(47.75,111.85) v3(48.07,112.17) ; v1(42.15,92.95) v3(42.15,93.31) v1(42.15,93.65) ; v1(54.75,117.45) 54.75,117.45 55.1,117.45 55.1,117.45 v1(55.45,117.45) ; v1(43.55,92.95) v3(43.55,93.31) v1(43.55,93.65) ; v1(37.25,106.25) v3(37.25,105.88) v1(37.25,105.55) ; v1(38.65,101.35) v3(38.65,100.99) v1(38.65,100.65) ; v1(54.75,115.35) v1(54.05,115.35) ; v1(34.45,103.45) v3(34.45,103.09) v1(34.45,102.75) ; v1(37.25,94.35) v3(37.25,94.68) v1(37.25,95.05) ; v1(42.15,96.45) v3(42.15,96.12) v1(42.15,95.75) ; v1(35.85,102.05) v3(35.85,102.39) v1(35.85,102.75) ; v1(37.25,104.15) v3(37.25,104.49) v1(37.25,104.85) ; v3(50.55,104.5) v1(50.55,104.15) ; v1(37.25,109.05) v3(37.25,108.69) v1(37.25,108.35) ; v1(33.05,107.65) v3(33.05,107.29) v1(33.05,106.95) ; v1(43.55,95.05) v3(43.55,94.71) v1(43.55,94.35) ; v1(43.55,99.95) v3(43.55,99.6) v1(43.55,99.25) ; v1(46.35,109.75) v3(46.35,110.1) ; v1(34.45,109.05) v3(34.45,108.69) v1(34.45,108.35) ; v1(40.75,99.25) v3(40.75,99.6) v1(40.75,99.95) ; v1(44.95,100.65) v3(44.95,100.29) v1(44.95,99.95) ; v1(40.05,97.15) v3(40.05,97.52) v1(40.05,97.85) ; v3(50.55,98.2) v1(50.55,97.85) ; v1(38.65,95.05) v3(38.65,94.72) v1(38.65,94.35) ; v1(37.25,106.95) v3(37.25,107.29) v1(37.25,107.65) ; v1(37.25,99.95) v3(37.25,100.29) v1(37.25,100.65) ; v1(38.65,99.95) v3(38.65,99.6) v1(38.65,99.25) ; v3(40.75,104.5) v1(40.75,104.85) ; v1(34.45,102.05) v3(34.45,101.69) v1(34.45,101.35) ; v1(33.05,109.75) v3(33.05,110.1) ; v1(56.15,113.25) v1(56.85,113.25) ; v1(47.75,99.25) v3(47.75,98.9) v1(47.75,98.55) ; v1(40.05,109.05) v3(40.05,108.69) v1(40.05,108.35) ; v3(57.12,114.22) v1(56.85,113.95) ; v1(42.15,109.05) v3(42.15,108.69) v1(42.15,108.35) ; v1(47.75,97.15) v3(47.75,97.5) v1(47.75,97.85) ; v1(40.05,101.35) v3(40.05,101.69) v1(40.05,102.05) ; v1(40.05,99.95) v3(40.05,100.29) v1(40.05,100.65) ; v1(40.05,102.75) v3(40.05,103.09) v1(40.05,103.45) ; v1(43.55,106.25) v3(43.55,105.88) v1(43.55,105.55) ; v1(37.25,102.05) v3(37.25,101.69) v1(37.25,101.35) ; v1(41.45,109.05) v3(41.45,109.39) v1(41.45,109.75) ; v1(53.35,109.75) v1(52.65,109.75) ; v1(44.95,108.35) v3(44.95,108.69) v1(44.95,109.05) ; v1(34.45,97.15) v3(34.45,97.52) v1(34.45,97.85) ; v1(42.15,99.95) v3(42.15,100.31) v1(42.15,100.65) ; v1(34.45,98.55) v3(34.45,98.9) v1(34.45,99.25) ; v1(40.05,98.55) v3(40.05,98.92) v1(40.05,99.25) ; v3(46.35,97.5) v1(46.35,97.15) ; v1(37.25,97.85) v3(37.25,97.52) v1(37.25,97.15) ; v1(46.35,99.25) v3(46.35,99.6) v1(46.35,99.95) ; v1(51.25,113.25) v3(50.9,113.25) ; v1(56.85,116.75) v1(57.55,116.75) ; v1(34.45,104.15) v3(34.45,104.49) v1(34.45,104.85) ; v1(49.15,101.35) v3(49.15,100.99) v1(49.15,100.65) ; v3(38.65,97.5) v1(38.65,97.15) ; v1(49.15,96.45) v3(49.15,96.1) v1(49.15,95.75) ; v1(55.45,118.15) v1(56.15,118.15) ; v3(31.65,104.5) v1(31.65,104.15) ; v1(38.65,102.05) v3(38.65,102.39) v1(38.65,102.75) ; v1(56.15,116.05) v1(56.85,116.05) ; v1(49.85,91.55) v3(50.22,91.92) v1(50.55,92.25) ; v1(34.45,106.95) v3(34.45,107.29) v1(34.45,107.65) ; v1(44.95,104.85) v3(44.95,104.49) v1(44.95,104.15) ; v1(42.15,109.75) v3(42.15,110.1) ; v1(56.15,117.45) 56.15,117.45 56.5,117.45 56.5,117.45 v1(56.85,117.45) ; v1(40.05,104.85) v3(40.05,104.49) v1(40.05,104.15) ; v1(37.25,95.75) v3(37.25,96.08) v1(37.25,96.45) ; v1(54.05,116.75) v1(54.75,116.75) ; v1(44.95,92.25) 44.95,92 v3(45.03,91.92) ; v3(31.65,98.2) v1(31.65,97.85) ; v1(46.35,106.95) v3(46.35,107.29) v1(46.35,107.65) ; v3(53.73,110.83) v1(54.05,111.15) ; v1(46.35,106.25) v3(46.35,105.88) v1(46.35,105.55) ; v1(35.85,92.25) v3(35.85,91.9) ; v3(50.55,107.3) v1(50.55,106.95) ; v1(47.75,104.15) v3(47.75,104.49) v1(47.75,104.85) ; v1(43.55,96.45) v3(43.55,96.12) v1(43.55,95.75) ; v3(40.51,91.92) 40.75,92.16 v1(40.75,92.25) ; v1(50.55,112.55) v1(49.85,112.55) ; v3(48.96,92.58) 48.98,92.57 48.98,92.42 v1(49.15,92.25) ; v1(32.35,110.45) v3(32.02,110.12) v1(31.65,109.75) ; v1(46.35,109.05) v3(46.35,108.69) v1(46.35,108.35) ; v1(47.75,95.75) v3(47.75,96.1) v1(47.75,96.45) ; v1(42.15,105.55) v3(42.15,105.88) v1(42.15,106.25) ; v1(33.05,105.55) v3(33.05,105.88) v1(33.05,106.25) ; v1(34.45,95.75) v3(34.45,96.08) v1(34.45,96.45) ; v1(40.05,95.05) v3(40.05,94.72) v1(40.05,94.35) ; v1(47.75,106.95) 47.75,107.29 v3(47.75,107.29) 47.75,107.36 47.75,107.36 v1(47.75,107.65) ; v1(55.45,116.75) v1(56.15,116.75) ; v1(34.45,92.25) v3(34.45,91.9) ; v3(35.85,104.5) v1(35.85,104.85) ; v1(33.05,100.65) v3(33.05,100.99) v1(33.05,101.35) ; v1(49.15,102.05) v3(49.15,102.39) v1(49.15,102.75) ; v3(46.35,98.2) v1(46.35,98.55) ; v1(54.75,116.05) v1(55.45,116.05) ; v1(49.85,113.95) v1(50.55,113.95) ; v1(49.15,113.25) v1(49.85,113.25) ; v1(47.75,102.05) v3(47.75,101.69) v1(47.75,101.35) ; v1(35.85,101.35) v3(35.85,100.99) v1(35.85,100.65) ; v1(40.05,106.25) v3(40.05,105.88) v1(40.05,105.55) ; v1(46.35,92.95) v3(46.35,93.31) v1(46.35,93.65) ; v1(42.15,106.95) v3(42.15,107.29) v1(42.15,107.65) ; v1(46.35,102.05) v3(46.35,102.39) v1(46.35,102.75) ; v1(37.25,98.55) v3(37.25,98.9) v1(37.25,99.25) ; v1(35.85,109.75) v3(35.85,110.1) ; v1(54.05,111.85) v1(54.75,111.85) ; v1(43.55,106.95) v3(43.55,107.29) v1(43.55,107.65) ; v1(40.75,91.55) v3(41.08,91.55) v1(41.45,91.55) ; v3(39.86,91.91) 40.05,92.1 v1(40.05,92.25) ; v1(48.45,112.55) v1(49.15,112.55) ; v1(41.45,95.75) v3(41.45,96.08) v1(41.45,96.45) ; v1(56.15,113.95) v1(55.45,113.95) ; v1(44.95,97.15) v3(44.95,97.52) v1(44.95,97.85) ; v1(43.55,92.25) v3(43.55,91.9) ; v1(43.55,109.05) v3(43.55,108.69) v1(43.55,108.35) ; v3(54.4,113.95) v1(54.75,113.95) ; v1(47.75,109.05) v3(47.75,108.69) v1(47.75,108.35) ; v1(57.55,118.15) v1(56.85,118.15) ; v1(38.65,105.55) v3(38.65,105.88) v1(38.65,106.25) ; v1(44.95,109.75) v3(44.95,110.1) ; v1(42.15,99.25) v3(42.15,98.92) v1(42.15,98.55) ; v3(46.35,104.5) v1(46.35,104.85) ; v1(42.15,102.75) v3(42.15,103.09) v1(42.15,103.45) ; v1(58.95,117.45) v3(59.3,117.45) ; v1(49.15,93.65) v3(49.15,93.31) v1(49.15,92.95) ; v1(33.05,99.95) v3(33.05,99.6) v1(33.05,99.25) ; v3(43.55,97.5) v1(43.55,97.15) ; v1(32.35,91.55) v3(31.96,91.94) v1(31.65,92.25) ; v1(49.15,105.55) v3(49.15,105.88) v1(49.15,106.25) ; v3(41.45,97.5) v1(41.45,97.15) ; v1(53.35,116.05) v1(54.05,116.05) ; v3(35.85,98.2) v1(35.85,98.55) ; v1(47.75,95.05) v3(47.75,94.71) v1(47.75,94.35) ; v3(38.65,104.5) v1(38.65,104.85) ; v1(49.15,107.65) v3(49.15,107.29) v1(49.15,106.95) ; v1(35.85,99.95) v3(35.85,99.6) v1(35.85,99.25) ; v1(37.25,102.75) v3(37.25,103.09) v1(37.25,103.45) ; v1(46.35,101.35) v3(46.35,100.99) v1(46.35,100.65) ; v1(33.05,93.65) v3(33.05,93.31) v1(33.05,92.95) ; v3(35.85,97.5) v1(35.85,97.15) ; v1(49.15,99.95) v3(49.15,99.6) v1(49.15,99.25) ; v1(35.85,96.45) v3(35.85,96.12) v1(35.85,95.75) ; v1(37.25,109.75) v3(37.25,110.1) ; v3(43.55,103.8) v1(43.55,103.45) ; v1(50.55,101.35) v3(50.55,100.99) v1(50.55,100.65) ; v1(52.65,109.05) 52.3,109.05 v1(51.95,109.05) ; v1(33.05,92.25) v3(33.05,91.9) ; v1(54.75,113.25) v1(55.45,113.25) ; v1(57.55,116.05) v1(58.25,116.05) ; v1(35.15,91.55) v3(34.88,91.28) ; v1(46.35,92.25) v3(46.35,91.9) ; v1(35.85,106.25) v3(35.85,105.88) v1(35.85,105.55) ; v1(40.75,106.25) v3(40.75,105.88) v1(40.75,105.55) ; v1(49.15,111.85) v1(49.85,111.85) ; v1(44.95,106.95) v3(44.95,107.29) v1(44.95,107.65) ; v1(49.15,109.75) v3(49.15,110.1) ; v3(49.15,97.5) v1(49.15,97.15) ; v1(33.05,109.05) v3(33.05,108.69) v1(33.05,108.35) ; v1(34.45,106.25) v3(34.45,105.88) v1(34.45,105.55) ; v1(58.95,116.75) v1(58.25,116.75) ; v1(44.95,95.75) v3(44.95,96.12) v1(44.95,96.45) ; v1(43.55,109.75) v3(43.55,110.1) ; v1(58.25,115.35) v1(58.95,115.35) ; v1(51.25,115.35) v1(51.95,115.35) ; v1(38.65,93.65) v3(38.65,93.31) v1(38.65,92.95) ; v1(54.05,114.65) 53.7,114.65 53.7,114.65 v1(53.35,114.65) ; v1(44.95,95.05) v3(44.95,94.71) v1(44.95,94.35) ; v1(44.95,106.25) v3(44.95,105.88) v1(44.95,105.55) ; v1(47.05,91.55) v3(47.05,91.17) ; v1(49.15,95.05) v3(49.15,94.71) v1(49.15,94.35) ; v1(35.85,93.65) v3(35.85,93.31) v1(35.85,92.95) ; v3(35.85,103.8) v1(35.85,103.45) ; v1(33.05,102.05) v3(33.05,102.39) v1(33.05,102.75) ; v3(49.15,98.2) v1(49.15,98.55) ; v1(42.15,92.25) v3(42.15,91.9) ; v3(31.65,107.3) v1(31.65,106.95) ; v1(40.05,107.65) v3(40.05,107.29) v1(40.05,106.95) ; v1(57.55,118.85) 57.9,118.85 57.9,118.85 58.25,118.85 v1(58.25,118.85) ; v1(47.75,103.45) v3(47.75,103.09) v1(47.75,102.75) ; v1(44.95,103.45) v3(44.95,103.09) v1(44.95,102.75) ; v1(58.95,118.15) v1(58.25,118.15) ; v3(53,113.95) v1(52.65,113.95) ; v3(49.15,103.8) v1(49.15,103.45) ; v3(38.65,103.8) v1(38.65,103.45) ; v3(33.05,98.2) v1(33.05,98.55) ; v3(31.65,95.4) v1(31.65,95.05) ; v1(34.45,109.75) v3(34.45,110.1) ; v1(40.75,100.65) v3(41.09,100.99) v1(41.45,101.35) ; v1(47.75,109.75) v3(47.75,110.1) ; v1(53.35,111.15) v1(52.65,111.15) ; v3(55.73,112.83) v1(55.45,112.55) ; v3(43.55,104.5) v1(43.55,104.85) ; v3(49.15,104.5) v1(49.15,104.85) ; v3(43.55,98.2) v1(43.55,98.55) ; v3(33.05,104.5) v1(33.05,104.85) ; v3(33.05,103.8) v1(33.05,103.45) ; v3(52.2,110.45) v1(52.65,110.45) ; v1(41.45,98.55) v3(41.45,98.21) ; v3(33.05,97.5) v1(33.05,97.15) ; v1(43.55,100.65) v3(43.55,100.99) v1(43.55,101.35) ; v1(51.25,113.95) v1(51.95,113.95) ; v3(50.55,95.4) v1(50.55,95.05) ; v1(55.45,115.35) v1(56.15,115.35) ; v3(46.35,103.79) v1(46.35,103.45) ; v1(37.25,92.25) v3(37.25,91.9) ; v3(40.75,103.8) v1(40.75,103.45) ; v3(38.65,91.9) v1(38.65,92.25) ; v1(44.25,91.55) v3(44.25,91.15) ; v1(38.65,109.75) v3(38.65,110.1)
  GND2 w0.254: v3(41.45,108) v1(41.45,108.35)
  vias: v1(33.05,104.15) v1(33.05,97.85) v1(35.85,104.15) v1(35.85,97.85) v1(38.65,104.15) v1(38.65,97.85) v1(40.75,104.15) v1(41.45,97.85) v1(41.45,107.65) v1(43.55,104.15) v1(43.55,97.85) v1(46.35,104.15) v1(46.35,97.85) v1(49.15,104.15) v1(49.15,97.85) v1(49.85,110.45) v1(50.55,109.75) v1(51.25,114.65) v1(51.95,116.05) v1(52.65,116.75) v1(53.35,118.15) v1(53.35,117.45) v1(53.35,116.75) v1(54.05,118.85) v1(54.05,118.15) v1(54.05,117.45) v1(54.75,118.15) v1(55.45,118.85) v1(55.45,114.65) v2(25.63,59.65) v5(23.5,56.67) v5(23.5,56.1) v5(23.5,55.53) v5(23.5,54.96) v5(24.07,56.67) v5(24.07,56.1) v5(24.07,55.53) v5(24.07,54.96) v5(24.43,53.99) v5(24.43,53.41) v5(24.43,52.82) v5(24.64,56.67) v5(24.64,56.1) v5(24.64,55.53) v5(24.64,54.96) v5(25.21,56.67) v5(25.21,56.1) v5(25.21,55.53) v5(25.21,54.96) v5(25.32,53.99) v5(25.32,53.41) v5(25.32,52.82) v5(26.21,53.99) v5(26.21,53.41) v5(26.21,52.82) v5(27.1,53.99) v5(27.1,53.41) v5(27.1,52.82) v5(28.6,53.93) v5(28.6,53.34) v5(28.6,52.76) v5(29.49,53.93) v5(29.49,53.34) v5(29.49,52.76) v5(30.38,53.93) v5(30.38,53.34) v5(30.38,52.76) v5(31.27,53.93) v5(31.27,53.34) v5(31.27,52.76) v5(32.16,53.93) v5(32.16,53.34) v5(32.16,52.76) v5(33.05,53.93) v5(33.05,53.34) v5(33.05,52.76) v5(33.93,54.51) v5(33.93,53.93) v5(33.93,53.34) v5(33.93,52.76) v5(34.62,54.55) v5(34.62,53.96) v5(34.62,53.38) v5(34.62,52.8) v5(36.28,54.03) v5(36.28,53.44) v5(36.28,52.86) v5(37.17,54.03) v5(37.17,53.44) v5(37.17,52.86) v5(38.06,54.03) v5(38.06,53.44) v5(38.06,52.86) v5(38.95,54.03) v5(38.95,53.44) v5(38.95,52.86) v5(39.84,54.03) v5(39.84,53.44) v5(39.84,52.86) v5(40.73,54.03) v5(40.73,53.44) v5(40.73,52.86) v5(41.62,54.03) v5(41.62,53.44) v5(41.62,52.86) v5(43.75,54.19) v5(43.75,53.62) v5(43.75,53.05) v5(44.32,54.19) v5(44.32,53.62) v5(44.32,53.05) v5(44.92,56.7) v5(44.92,56.06) v5(44.92,55.49) v5(44.92,54.92) v5(44.89,54.19) v5(44.89,53.62) v5(44.89,53.05) v5(45.5,56.7) v5(45.5,56.06) v5(45.5,55.49) v5(45.5,54.92) v5(45.47,54.19) v5(45.47,53.62) v5(45.47,53.05) v5(46.08,54.17) v5(46.08,53.6) v5(46.08,53.03) v5(46.65,54.17) v5(46.65,53.6) v5(46.65,53.03) v5(47.22,54.17) v5(47.22,53.6) v5(47.22,53.03) v5(47.79,54.17) v5(47.79,53.6) v5(47.79,53.03) v5(48.62,54.16) v5(48.62,53.57) v5(48.62,52.99) v5(49.5,54.16) v5(49.5,53.57) v5(49.5,52.99) v5(51.42,54.05) v5(51.42,53.47) v5(51.42,52.89) v5(52.31,54.05) v5(52.31,53.47) v5(52.31,52.89) v5(53.2,54.05) v5(53.2,53.47) v5(53.2,52.89) v5(53.91,56.54) v5(53.91,55.97) v5(53.91,55.4) v5(53.91,54.83) v5(53.91,54.26) v5(53.91,53.69) v5(54.13,53) v5(54.48,56.54) v5(54.48,55.97) v5(54.48,55.4) v5(54.48,54.83) v5(54.48,54.26) v5(54.48,53.69) v5(54.7,53) v5(55.05,56.54) v5(55.05,55.97) v5(55.05,55.4) v5(55.05,54.83) v5(55.05,54.26) v5(55.05,53.69) v5(55.27,53) v5(55.63,56.54) v5(55.63,55.97) v5(55.63,55.4) v5(55.63,54.83) v5(55.63,54.26) v5(55.63,53.69) v5(56.26,54.08) v5(56.26,53.49) v5(56.26,52.91) v5(57.15,54.08) v5(57.15,53.49) v5(57.15,52.91) v5(58.97,54.17) v5(58.97,53.58) v5(58.97,53) v5(59.86,54.17) v5(59.86,53.58) v5(59.86,53) v5(63.06,56.16) v5(63.06,55.59) v5(63.06,55.02) v5(63.06,54.45) v5(63.06,53.88) v5(63.06,53.3) v5(63.63,56.16) v5(63.63,55.59) v5(63.63,55.02) v5(63.63,54.45) v5(63.63,53.88) v5(63.63,53.3) v5(64.2,54.45) v5(64.2,53.88) v5(64.2,53.3) v5(64.77,54.45) v5(64.77,53.88) v5(64.77,53.3) v5(71.63,86.01) v5(71.63,85.37) v5(71.63,84.74) v5(71.63,84.1) v5(71.63,83.47) v5(71.63,82.83) v5(71.63,82.2) v5(71.56,54.45) v5(71.56,53.88) v5(71.56,53.3) v5(72.14,54.45) v5(72.14,53.88) v5(72.14,53.3) v5(72.16,86.64) v5(72.71,54.45) v5(72.71,53.88) v5(72.71,53.3) v5(72.9,86.13) v5(73.28,53.88) v5(73.28,53.3) v5(73.53,86.13)
+PEX_PLL_HVDD: length 1.6
  GND2 w0.254: v1(51.95,103.45) 51.76,103.64 v3(51.76,103.83)
  GND4 w0.203: v4(51.65,104.58) 51.65,103.94 v3(51.76,103.83) 51.92,103.67 v4(51.92,103.53)
+PEX_VDD: length 55.6
  TOP w0.203: v4(64.87,83.78) RG1586.2 ; v8(66.08,82.51) 66.47,82.51 66.67,82.72 66.67,83.59 66.48,83.78 v8(66.08,83.78) ; RG1607.1 70.46,66.8 v5(70.74,67.08) ; v1(64.87,81.24) v8(64.87,81.88)
  IN1 w0.203: v1(64.87,78.7) 64.87,78.67 65.53,78.01 65.04,77.51 64.49,77.51 64.29,77.72 v4(64.29,78.07) ; v1(64.87,78.7) 64.96,78.7 65.53,79.28 64.87,79.94 v1(64.87,79.97) 66.08,81.18 v8(66.08,82.51) 65.51,82.51 v8(64.87,81.88) ; v1(64.87,78.7) 64.29,79.29 v1(64.29,79.34) ; v1(64.29,80.61) 64.87,81.19 v1(64.87,81.24) ; v4(64.87,83.78) v8(66.08,83.78)
  GND2 w0.203: v1(51.95,97.15) v1(52.65,97.15) v3(52.94,96.86) ; v1(52.65,107.65) v3(52.91,107.91) ; v1(53.35,105.55) 53.09,105.81 v3(52.91,105.81) v1(52.65,105.55) ; v1(51.95,98.55) 51.95,98.55 v3(52.25,98.26) 52.54,98.55 v1(52.65,98.55) v3(52.94,98.26) ; v1(51.95,96.45) 52.4,96.45 v3(52.45,96.4) ; v1(51.95,106.95) v1(52.65,106.95) 52.96,107.26 v3(52.96,107.28) ; v1(53.35,107.65) v3(53.61,107.91) ; v1(51.95,105.55) v3(52.21,105.81) ; v4(64.87,83.78) 64.29,84.37 v1(64.29,84.42) ; v3(52.21,107.91) v1(51.95,107.65) ; v1(52.65,94.35) 52.54,94.35 v3(52.25,94.06) 51.95,94.35 v1(51.95,94.35)
  GND4 w0.381: v4(52.55,97.12) 52.68,97.12 v3(52.94,96.86) 52.48,96.4 v3(52.45,96.4)
  BOTTOM w0.203: 56.64,90.83 56.64,85.63 57.78,84.48 59.23,84.48 59.69,84.94 61.14,84.94 62.29,83.78 v4(64.87,83.78) ; v4(64.29,78.07) 64.47,77.89 64.47,75.15 66.67,72.94 68.31,72.94 70.74,70.51 v5(70.74,67.08)
  vias: v4(52.58,93.28) v4(52.62,92.7) v4(52.62,91.56) v4(52.62,90.99) v4(53.24,109.79) v4(53.24,109.19) v4(53.72,108.42) v10(58,91.4)
+RTC_CELL: length 150
  TOP w0.254: PD4.1 v5(18.39,7.43)
  TOP w0.508: 117.67,26.95 118.24,26.38 118.24,24.98 119.18,24.04 CH226.1
  GND2 w0.254: v3(118.49,27.33) v1(118.11,27.33)
  IN3 w0.254: v9(88.57,22.73) 87.94,22.73 84.79,19.58 80.48,19.58 80.36,19.45 77.49,19.45 77.37,19.58 76.8,19.58 76.55,19.32 76.55,13.52 75.51,12.49 75.51,11.92 76.05,11.38 76.05,9.12 74.67,7.74 70.87,7.74 70.42,7.29 69.92,7.29 68.85,6.23 58.88,6.23 58.78,6.33 55.26,6.33 51.29,10.3 39.44,10.3 39.16,10.02 28.08,10.02 27.01,8.95 21.38,8.95 19.86,7.43 v5(18.39,7.43) ; v3(118.49,27.33) 118.19,27.03 116.66,27.03 112.34,22.71 112.34,20.88 110.75,19.29 105.54,19.29 101.97,15.72 97.55,15.72 97.12,15.29 94.7,15.29 91.46,12.05 90.07,12.05 89.15,11.13 88.45,11.13 v9(87.53,12.05)
  GND4 w0.254: v4(88.91,22.87) 88.91,22.83 88.81,22.73 v9(88.57,22.73) ; v4(118.49,27.66) v3(118.49,27.33) ; v6(86.85,12.05) v9(87.53,12.05)
  IN4 w0.254: v4(88.91,22.87) 88.91,22.52 88.89,22.49 88.89,22.45 88.27,21.83 88.27,20.42 87.91,20.07 87.91,18.77 88.42,18.27 88.42,17.81 87.82,17.21 87.82,14.72 87.67,14.57 87.67,14.35 86.92,14.35 86.55,13.99 86.55,12.35 v6(86.85,12.05)
  BOTTOM w0.081: CH173.1 120.88,28.65 v2(121.26,29.03)
  BOTTOM w0.508: v4(118.49,27.66) RH83.1 RH84.1 120.14,28.53 CH173.1 CH80.1
+TBTA_VBUS: length 11.1
  TOP w0.081: v10(99.21,144.59) 99.36,144.74 v5(100.22,144.74) ; v5(101.35,144.74) 101.35,143.92 v10(101.88,143.39)
  TOP w0.254: JUSBC.A4 98.08,150.05 JUSBC.B9 ; JUSBC.A9 95.58,150.05 JUSBC.B4
  TOP w0.508: v1(93.04,147.86) 93.04,147.25 CT97.1 CT95.2
  IN1 w0.381: v1(93.04,147.86) 93.5,148.31 94.23,148.31 95.63,149.71 JUSBC.B4
  BOTTOM w0.254: v4(98.2,139.12) v4(98.2,138.62)
  vias: v1(100.14,147.6) v1(100.65,147.14) v3(99.95,148.05) v3(100.46,148.05) v5(100.77,144.74) v5(106.25,147.98) v5(106.81,147.98) v5(107.38,147.98) v5(108.01,147.98) v10(101.07,145.29) v18(98.7,142.62) v18(98.7,142.12)
AC_PRESENT: length 7.7
  TOP w0.081: 111.77,22.69 111.32,22.23 RH533.1 110.87,21.57 110.87,20.78 DH1.2
  TOP w0.089: 111.77,22.69 111.77,22.95 112.77,23.95 112.77,24.15 v5(112.84,24.22)
  TOP w0.122: UH1.BG42 113.09,25.36 113.32,25.13 113.32,24.78 112.84,24.3 v5(112.84,24.22)
  BOTTOM w0.089: v5(112.84,24.22) v2(112.84,23.64)
ACIN#: length 10.4
  BOTTOM w0.081: QE3.3 128.13,13.92 RE17.2 127.65,15.59 125.48,17.76 122.61,17.76 122.44,17.59 UE1.18
ACIN_CHG: length 4.2
  TOP w0.254: PRB42.1 48.7,19.9 v5(48.32,19.52)
  BOTTOM w0.203: PRB39.2 PRB42.1 48.7,19.9 v5(48.32,19.52) 47.87,19.07 PUB1.1
ACIN_ISL95338_1: length 2.4
  BOTTOM w0.203: PRV96.2 60.39,32.72 59.46,31.79 PUV3.19
ACIN_R_1: length 6.2
  BOTTOM w0.081: v2(65.3,32.98) 65.16,32.98 PRV226.2
  BOTTOM w0.203: PDV01.2 62.67,32.72 PRV103.1 61.84,33.17 61.52,33.49 PRV98.2 61.39,32.73 PRV96.1
  BOTTOM w0.254: PDV01.2 63.63,32.2 PRV226.2
ACLIM_CHG: length 5.2
  BOTTOM w0.081: PRB36.1 v2(42.14,13.43)
  BOTTOM w0.203: PRB36.1 PRB35.2 42.93,14.25 43.91,15.23 PUB1.16
AD0_2: length 1.5
  BOTTOM w0.081: RE164.1 108.54,17.63 108.07,17.16 UE8.31
AD1_2: length 2.7
  BOTTOM w0.081: v2(110.49,18.27) RE163.1 109.42,18.08 108.57,17.22 UE8.32
AD2_2: length 2.9
  BOTTOM w0.081: UE8.1 110.46,16.16 RE165.2 110.68,16.74 111.38,17.44 v2(111.52,17.44)
AD3_2: length 2.4
  BOTTOM w0.081: v2(110.68,14.47) RE162.1 110.51,15.66 UE8.2
AD_BID: length 4.9
  TOP w0.081: UE5.A12 75.21,16.87 RE64.1 75.06,16.86 74.61,17.3 73.65,17.3 CE28.1 RE66.2
ADC_IN_N: length 111.7
  TOP w0.081: UG1.BJ11 56.85,90.09 57.18,89.77 59.16,89.77 59.77,89.16 59.77,86.59 60.17,86.18 60.17,85.35 60.76,84.76 60.76,83.9 61.44,83.21 61.44,79.61 v1(61.9,79.15)
  TOP w0.254: v1(10.73,30.88) 10.48,31.13 10.19,31.13 9.82,31.5 9.82,31.88 9.8,31.89 v2(9.8,31.9) 9.79,31.92 9.79,31.93 9.75,31.97 9.75,32.06 9.3,32.51 UG37.19
  GND2 w0.081: v12(61.85,78.64) 61.85,79.1 v1(61.9,79.15) ; v1(10.73,30.88) 10.77,30.88 10.92,31.03 v12(10.92,31.14)
  IN2 w0.058: v12(61.85,78.64) 61.4,78.64 61.34,78.58 61.34,60.65 58.68,57.99 33.96,57.99 33.53,58.42 29.67,58.42 29.24,57.99 19.53,57.99 17.17,55.63 15.16,55.63 12.26,52.72 12.26,41.13 10.59,39.46 10.59,32.36 10.92,32.03 v12(10.92,31.14)
ADC_IN_N_RC: length 2
  TOP w0.081: v2(9.82,30.36) 10.21,29.96 RG1561.1
  TOP w0.254: CG7119.2 RG1561.1
ADC_IN_P: length 109.2
  TOP w0.081: UG1.BJ9 56.85,88.86 57.12,89.13 59.18,89.13 59.46,88.85 59.46,86.44 59.89,86.01 59.89,85.19 60.5,84.58 60.5,83.77 61.16,83.11 61.16,79.48 v1(61.47,79.17)
  TOP w0.254: UG37.20 9.5,32.91 10.71,31.7 v1(10.73,31.7)
  GND2 w0.081: v1(10.73,31.7) 10.41,32.02 v12(10.41,32.03) ; v12(61.11,78.82) v1(61.47,79.17)
  IN2 w0.058: v12(10.41,32.03) 10.34,32.11 10.34,39.49 12.01,41.17 12.01,52.91 15.14,56.03 17.2,56.03 19.41,58.24 29.16,58.24 29.54,58.63 33.78,58.63 34.16,58.24 58.57,58.24 61.11,60.78 v12(61.11,78.82)
ADC_IN_P_RC: length 0.9
  TOP w0.254: CG7118.2 RG1560.1
ADC_MUX_SEL: length 4.8
  TOP w0.254: UG37.29 6.47,36.21 7.18,36.92 7.18,37.94 6.35,38.76 RG1537.1
ADDR/FSW_GPU: length 3.4
  TOP w0.203: v5(78.55,28.79) 78.51,28.79 78.2,29.1 v2(78.02,29.1) PUV1.26
  TOP w0.254: PRV4.1 79.04,28.79 v5(78.55,28.79)
  BOTTOM w0.254: v5(78.55,28.79) 78.8,28.54 PRV3.1
ADP_I: length 42.5
  TOP w0.254: v5(51.61,12.31) 51.57,12.27 PR23.2
  GND2 w0.076: v1(77.66,16.87) 78.03,16.87 78.03,16.87 v3(78.03,16.87)
  GND4 w0.076: v6(78.36,16.87) 78.03,16.87 78.03,16.87 v3(78.03,16.87)
  IN4 w0.058: v5(51.61,12.31) 54.29,12.31 56.04,10.56 68.04,10.56 68.7,11.22 76.58,11.22
  IN4 w0.076: 76.58,11.22 77.51,11.22 77.71,11.02 78.25,11.02 78.99,11.76 78.99,13.21 77.8,14.4 77.8,16.69 77.97,16.87 v6(78.36,16.87)
  BOTTOM w0.203: PRB27.1 50.29,16.65 PCB6.1 51.52,16.65 51.79,16.39 51.79,13.9 52.22,13.46 52.22,12.88 v2(52.2,12.85) 51.65,12.31 v5(51.61,12.31)
ADPS_ISL95338_1: length 7
  IN4 w0.254: v6(57.06,37.07) 57.06,35.71 57.98,34.79 v7(57.98,33.94) 57.47,33.43 57.02,33.43 56.52,33.94 v7(56.52,34)
  BOTTOM w0.203: v7(56.52,34) 56.6,33.92 PUV3.13 ; v7(57.98,33.94) 57.8,33.76 PUV3.16
  vias: v2(57.67,36.32)
ALIEN_LED_B_DRV#: length 188
  IN2 w0.058: v4(97.82,13.28) 97.82,13.6 96.59,14.84 95.97,14.84 92.86,17.95 92.86,18.75 91.99,19.62 91.99,19.82 89.36,22.45 88.64,22.45 87.45,23.63 87.45,29.03 87.78,29.36 87.78,32.13 87.19,32.72 87.19,43.56 85.07,45.68 85.07,50.93 87.48,53.33 87.48,56.38 85.37,58.49 85.37,81.21 85.98,81.82 85.98,84.28 v3(85.75,84.51)
  IN3 w0.058: v3(85.75,84.51) 84.81,85.45 84.81,87.15 84.93,87.27 84.93,96.25 77.5,103.68 77.5,114.13 71.73,119.91 71.73,121.1 68.89,123.93 67.95,123.93 65.28,126.6 65.28,140.65 63.96,141.97 62.5,141.97 58.01,146.46 47.81,146.46 46.77,147.5 42.59,147.5 41.22,148.87 v5(41.22,152.58)
  BOTTOM w0.081: v4(97.82,13.28) 97.82,11.37 v2(98.7,10.5) 98.95,10.25 103,10.25 104.27,11.53 UE8.17 ; v5(41.22,152.58) 41.25,152.55 JEDP.30
ALIEN_LED_G_DRV#: length 187.3
  IN2 w0.058: v4(97.32,13.26) 97.32,13.54 96.92,13.93 96.6,13.93 92.71,17.83 92.71,17.87 92.7,17.88 92.7,18.64 91.59,19.76 91.59,19.95 89.27,22.26 88.6,22.26 87.29,23.57 87.29,29.1 87.62,29.43 87.62,32.02 87.03,32.61 87.03,43.5 84.91,45.62 84.91,50.99 87.32,53.4 87.32,56.23 85.75,57.79 85.75,57.88 85.21,58.42 85.21,81.27 85.75,81.81 85.75,84.04 85.42,84.37 85.42,84.65 85.75,84.98 v3(85.75,85.02)
  IN3 w0.058: v3(85.75,85.02) 85.09,85.68 85.09,87.05 85.09,87.05 85.09,96.32 77.66,103.75 77.66,114.2 71.89,119.97 71.89,121.16 68.96,124.09 68.01,124.09 65.44,126.67 65.44,140.72 64.02,142.13 62.56,142.13 58.07,146.62 47.88,146.62 46.83,147.66 46.7,147.66 43.03,147.66 41.72,148.97 v5(41.72,152.24)
  BOTTOM w0.081: v4(97.32,13.26) 97.32,11.51 v2(97.51,11.32) 97.51,10.94 98.37,10.07 103.45,10.07 105.07,11.69 UE8.16 ; JEDP.29 41.75,152.21 v5(41.72,152.24)
ALIEN_LED_R_DRV#: length 188.3
  IN2 w0.058: v4(96.78,13.27) 96.78,13.36 91.43,18.72 91.43,19.88 89.2,22.1 88.53,22.1 87.13,23.5 87.13,29.17 87.46,29.5 87.46,31.95 86.87,32.54 86.87,43.43 84.75,45.55 84.75,51.06 87.16,53.46 87.16,56.16 85.59,57.73 85.59,57.81 85.05,58.35 85.05,81.34 85.59,81.88 85.59,83.97 85.26,84.3 85.26,84.99 85.65,85.39 85.65,85.42 v3(85.75,85.52)
  IN3 w0.058: v5(42.22,152.58) 42.22,149.21 43.61,147.82 46.64,147.82 46.9,147.82 47.94,146.78 58.14,146.78 62.63,142.29 64.09,142.29 65.6,140.79 65.6,126.84 68.18,124.25 69.03,124.25 72.05,121.23 72.05,120.04 77.82,114.26 77.82,103.81 85.25,96.38 85.25,86.02 v3(85.75,85.52)
  BOTTOM w0.081: UE8.15 105.57,11.49 103.96,9.89 98.3,9.89 96.95,11.24 v2(96.95,12.5) 96.78,12.66 v4(96.78,13.27) ; v5(42.22,152.58) 42.22,152.06 42.25,152.04 JEDP.28
AMON_CHG: length 2.1
  BOTTOM w0.203: PUB1.6 47.92,17.07 48.45,16.54 PRB27.2
ASGATE_CHG: length 3
  BOTTOM w0.203: PUB1.30 45.91,21.05 v2(45.77,21.19) 45.66,21.19 PRB40.2
BA:
  vias: v10(24.27,6.38)
BA_PWR: length 25.3
  TOP w0.081: v5(22.42,11.53) 22.42,11.64 v10(21.88,12.18)
  TOP w0.254: v5(43.55,12.92) 43.73,12.92 43.87,12.78 PDB1.2 ; v5(22.42,11.53) 22.48,11.47 PRB12.2
  IN3 w0.254: v5(22.42,11.53) 22.3,11.65 22.3,12.36 22.57,12.63 22.58,12.63 23.19,13.24 38.93,13.24 39.24,12.92 v5(43.55,12.92)
BATGONE_CHG: length 2.2
  BOTTOM w0.203: PRB28.1 44.51,13.75 45.11,14.34 v2(45.11,14.53) PUB1.13
BATLOW#: length 5
  BOTTOM w0.081: RT14.1 RT31.2 86.31,142.57 85.77,143.11 85.77,144.26 85.02,145.02 84.33,145.02 UT1.F2
BATT_CHG_LED: length 12.2
  IN4 w0.058: v7(131.82,14.81) 131.6,14.81 131.47,14.94 122.45,14.94 v7(121.93,14.43)
  BOTTOM w0.081: UE1.19 121.94,14.43 v7(121.93,14.43)
BATT_CHG_LED#: length 42.9
  IN4 w0.058: v7(91.44,16.6) 91.44,16.28 92.44,15.28 97.01,15.28 97.67,15.95 100.32,15.95 100.83,16.46 109.29,16.46 110.73,15.02 115.88,15.02 116.98,13.92 122.2,13.92 122.64,14.36 129.27,14.36 v7(129.41,14.51)
  BOTTOM w0.081: v7(129.41,14.51) 129.41,15.22 129.65,15.46 QE1.2 ; v7(91.44,16.6) 91.31,16.6 91.29,16.62 UE10.2
BATT_LOW_LED: length 3.5
  BOTTOM w0.081: QE3.6 126.89,14.43 RE21.2 126,14.62 124.94,15.68 UE1.13
BATT_LOW_LED#: length 42.5
  IN4 w0.058: v7(129.54,14.09) 129.43,14.2 122.71,14.2 122.27,13.76 116.91,13.76 115.81,14.86 110.67,14.86 109.25,16.28 100.88,16.28 100.39,15.79 97.73,15.79 97.07,15.12 v7(91.31,15.12)
  BOTTOM w0.081: v7(129.54,14.09) 129.29,13.84 QE3.2 ; v2(91.45,14.48) 91.45,14.98 v7(91.31,15.12) UE10.5
BATT_PRS: length 10
  TOP w0.081: v5(27.47,4.64) 27.47,4.55 27.39,4.47 27.39,3.58 27.92,3.06 27.92,2.35 v2(27.85,2.28)
  TOP w0.254: v5(27.47,4.64) 27.03,4.64 PR22.1
  BOTTOM w0.254: PBATT1.5 29.57,6.11 28.4,4.93 27.76,4.93 v5(27.47,4.64)
BBS_BIT0: length 3
  TOP w0.122: UH1.BA26 105.52,28.69 105.88,28.32 v5(106.08,28.32)
  BOTTOM w0.089: v5(106.08,28.32) 105.62,27.86 105.62,26.92 RH130.2
BEEP#: length 85.1
  TOP w0.081: v2(10.72,6.76) 10.72,6.69 v5(11.19,6.22)
  IN1 w0.058: 78.87,18.44 78.79,18.53 73.68,18.53 71.45,16.3 71.45,15.99 70.24,14.78 70.24,12.62 66.9,9.27 15.94,9.27 15.49,8.82 14.72,8.05 13.55,8.05 11.79,6.29 11.26,6.29 v5(11.19,6.22)
  IN1 w0.076: v8(82.67,14.86) 82.67,14.9 82.42,15.15 82.42,16.51 81.24,17.68 81.18,17.68 80.48,18.38 78.95,18.38 78.89,18.44 78.87,18.44
  IN3 w0.058: v5(11.19,6.22) 11.19,6.34 11.02,6.5 9.4,6.5 v9(9.02,6.89)
  GND4 w0.081: v9(9.02,6.89) 9.02,7.04 v4(8.86,7.19)
  BOTTOM w0.081: JIO1.B5 8.26,6.59 v4(8.86,7.19)
BG_REF_OUT: length 4.9
  TOP w0.081: v2(12.56,35.65) 12.04,35.13 CG7123.1
  TOP w0.254: CG7123.1 RG1566.2 RG1568.2 10.51,34.11 UG37.23
BGATE_CHG: length 3.9
  BOTTOM w0.203: PRB15.1 v2(41.85,21.17) 42.54,20.47 43.5,20.47 43.91,20.07 PUB1.25
BIA_PWM_PCH: length 189.3
  TOP w0.081: v8(24.07,136.68) 24.07,136.43 RV681.1
  TOP w0.089: v1(116.27,30.83) 116.12,30.67 UH1.AU48
  IN1 w0.058: v8(24.07,136.68) 24.07,138.87 26.85,141.66 33.43,141.66 34.34,140.74 52.87,140.74 53.53,140.08 56.84,140.08 57.61,139.3 57.61,135.41 59.65,133.38 59.65,131.69 60.16,131.18 60.16,131.05 60.15,131.05 60.15,124.76 60.93,123.98 60.93,121.54 64.53,117.95 v3(65.02,117.95)
  GND2 w0.089: v3(115.89,31.08) 116.14,30.83 v1(116.27,30.83)
  GND4 w0.081: v3(65.02,117.95) v4(65.41,117.95)
  GND4 w0.089: v3(115.89,31.08) v6(115.89,30.63)
  IN4 w0.058: 90.09,48.37 89.19,49.27 89.19,51.09 86.48,53.8 86.48,54.55 85.96,55.07 85.96,69.83 v7(86.39,70.26)
  IN4 w0.089: v6(115.89,30.63) 115.89,30.84 115.57,31.16 114.35,31.16 113.92,31.59 113.92,32.6 112.78,33.74 112.78,34.17 113.17,34.56 113.17,35.79 113.27,35.9 113.27,36.29 112.13,37.44 112.13,38.33 111.78,38.67 111.21,38.67 108.32,41.56 108.32,41.89 107.69,42.52 106.28,42.52 103.93,44.87 102.79,44.87 102.11,45.55 100.93,45.55 99.25,47.23 97.77,47.23 97.5,47.5 96.01,47.5 95.44,48.07 94.68,48.07 93.97,47.35 91.86,47.35 91.55,47.67 90.79,47.67 90.09,48.37
  BOTTOM w0.081: v4(65.41,117.95) 71.09,117.95 71.93,118.79 73.81,118.79 v2(75.53,117.06) 86.6,105.99 86.6,99.34 86.17,98.9 86.17,97.99 86.17,73.07 85.85,72.75 85.85,72.6 85.85,70.8 v7(86.39,70.26)
BKOFF: length 179.6
  TOP w0.076: v5(82.5,18.2) 82.41,18.12 82.41,17.1 82.18,16.87 UE5.L12
  TOP w0.081: v5(25.13,138.09) 24.94,137.9 24.94,136.65 24.93,136.63 DV1.2
  IN3 w0.058: v9(81.76,38.86) 81.76,39.14 81.97,39.35 81.97,43.87 80.89,44.95 80.89,56.86 80.5,57.25 80.44,57.31 80.44,59.43 80.77,59.76 80.77,65.98 83.51,68.73 83.51,89.51 81.13,91.89 81.13,97.5 75.7,102.93 75.7,113.36 63.44,125.61 63.44,138.44 58.72,143.17 56.83,143.17 56.19,143.81 38.06,143.81 37.49,143.23 33.15,143.23 31.43,141.52 27.23,141.52 25.13,139.42 v5(25.13,138.09)
  GND4 w0.081: v6(81.82,38.51) 81.82,38.8 v9(81.76,38.86)
  IN4 w0.058: 82.33,18.44 81.86,18.91 81.86,24.56 82.63,25.33 82.63,28.77 82.33,29.06 82.33,36.51 82.35,36.53 82.35,37.8 81.82,38.32 v6(81.82,38.51)
  IN4 w0.076: 82.33,18.44 82.5,18.27 v5(82.5,18.2)
  BOTTOM w0.076: v5(82.5,18.2) 82.5,18.29 82.65,18.44
  BOTTOM w0.081: 82.65,18.44 v2(83.03,18.82)
BMON_CHG: length 2.3
  BOTTOM w0.203: PUB1.7 47.81,16.67 48.77,15.71 PRB22.2
BOARD_ID: length 3.6
  TOP w0.089: UH1.BA20 102.35,28.64 102.01,28.31 v5(101.94,28.31)
  BOTTOM w0.089: v5(101.94,28.31) 101.94,28.13 v2(101.42,27.61) 101.13,27.32 101.13,27.06 100.55,26.49 100.55,26.49 ; 100.55,26.49 RH1601.1 ; 100.55,26.49 RH21.1
BS2_1.0VS_VGAP: length 1.2
  TOP w0.081: PC1109.1 71.77,109.95 v2(71.77,110.85)
