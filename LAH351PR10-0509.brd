# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EN6_NVVDD: length 0.9
  GND2 w0.254: v1(61.63,43.05) v3(61.63,42.61)
  GND4 w0.254: v3(61.63,42.61) 61.58,42.66 v4(61.58,43.04)
EN7_NVVDD: length 2.3
  TOP w0.081: v2(67.94,42.47) 68.52,43.05 v1(69.19,43.05)
  GND2 w0.254: v3(68.94,42.74) 69.19,42.99 v1(69.19,43.05)
  GND4 w0.254: v3(68.94,42.74) 68.97,42.78 v4(69.37,42.78)
EN8_NVVDD: length 4.3
  TOP w0.081: v5(72.92,80.6) 72.1,80.6 v2(71.77,80.27)
  TOP w0.254: v5(72.92,80.6) 72.92,80.62 72.93,80.62 PUV11.17
  BOTTOM w0.254: PRV183.2 71.96,79.64 v5(72.92,80.6)
EN_0.6VSP: length 7.4
  TOP w0.081: v2(147.79,39.96) 147.79,40.08 PRM6.1
  TOP w0.203: PRM6.1 146.93,41.3 146.93,41.8 PCM19.1 146.72,41.98 146.02,41.98 PRM7.1 146.15,42.31 146.15,44.78 146.59,45.22 PUM1.7
EN_1.2V: length 3
  TOP w0.203: PUM1.8 146.99,45.14 146.52,44.67 146.52,44.11 146.67,43.96 PCM18.1
  TOP w0.254: PRM5.2 PCM18.1
EN_3V: length 32.7
  TOP w0.081: v2(44.85,8.07) 44.73,8.19 v5(44.36,8.19)
  TOP w0.254: PU301.9 61.95,26.02 v5(61.79,26.19)
  IN1 w0.254: v5(61.79,26.19) 60.58,26.19 59.05,24.67 v11(59.05,22.76)
  GND2 w0.254: v12(59.05,22.38) v11(59.05,22.76)
  IN2 w0.254: v5(44.36,8.19) 44.36,8.56 45.12,9.32 48.39,9.32 50.16,11.1 50.16,15.27 52.58,17.69 52.58,20.25 53.57,21.24 55.45,21.24 56.59,22.38 v12(59.05,22.38)
  BOTTOM w0.254: PR505.1 44.36,8.75 v5(44.36,8.19)
EN_5V: length 23.2
  TOP w0.254: v5(52.75,24.2) 52.82,24.2 52.86,24.16 PU501.6
  IN2 w0.254: v5(43.79,8.19) 43.79,8.54 44.93,9.68 48.24,9.68 49.81,11.25 49.81,15.42 52.22,17.83 52.22,23.87 52.55,24.2 v5(52.75,24.2)
  BOTTOM w0.254: v5(43.79,8.19) 43.79,8.54 PR503.1
EN_+1VALWP: length 3.1
  TOP w0.254: PUH1.3 v2(139.98,30.14) 140.26,30.14 PRH5.2 140.89,29.92 PCH9.1
EN_FBVDDQ: length 37.2
  TOP w0.254: v5(3.75,53.24) 3.92,53.07 PUW1.2 ; v8(7.7,24.82) PRW28.1 7.1,24.06 7.05,24.1 PQW1.3
  IN1 w0.254: v5(3.75,53.24) 3.25,52.75 3.25,46.21 2.21,45.16 2.21,43.61 2.84,42.98 3.51,42.98 5.38,41.1 5.38,40.74 4.86,40.22 4.86,36.73 5.38,36.21 7.38,36.21 8.89,34.7 8.89,31.03 8.33,30.47 8.33,25.45 v8(7.7,24.82)
EN_INVPWR: length 170.5
  TOP w0.076: UE5.G13 80.17,17.96 80.45,18.25 81.09,18.25 v5(81.12,18.28)
  TOP w0.081: v3(33.25,142.78) 33.25,145.93 QV2.2
  IN3 w0.058: v9(81.19,37.36) 81.25,37.42 81.25,37.82 81.13,37.95 81.13,38.4 81.01,38.52 80.82,38.71 80.82,39.22 80.54,39.51 80.54,41.01 80.56,41.03 80.75,41.22 80.75,42.9 80.75,43.03 80.75,43.29 80.52,43.52 80.52,44.09 80.52,44.09 80.52,44.19 80.25,44.45 80.25,56.59 79.8,57.05 79.8,59.7 80.13,60.03 80.13,66.25 82.87,68.99 82.87,89.24 80.49,91.63 80.49,97.21 75.06,102.64 75.06,112.11 74.64,112.53 74.64,113.5 68.72,119.43 67.74,119.43 66.34,120.83 66.34,121.8 62.8,125.34 62.8,138.18 58.58,142.4 55.97,142.4 55.09,143.28 52.98,143.28 51.49,141.79 44.15,141.79 42.52,143.41 38.46,143.41 37.82,142.78 v3(33.25,142.78)
  GND4 w0.081: v6(81.01,37.18) v9(81.19,37.36)
  IN4 w0.058: 81.12,18.44 81.22,18.54 81.22,30.55 81.69,31.02 81.69,35.84 81.01,36.52 v6(81.01,37.18)
  IN4 w0.076: 81.12,18.44 v5(81.12,18.28)
EN_VCCIO: length 4.5
  TOP w0.254: PRH13.1 PRH19.1 PCH27.1 138.23,53.53 137.81,53.95 136.62,53.95 136.18,53.51 PUH2.9
EN_WOL#: length 93.5
  IN3 w0.058: v9(90.37,11.3) 89.34,10.28 87.97,10.28 84.23,6.53 84.23,4.42 83.58,3.78 81.34,3.78 81.1,4.02 79.64,4.02 78.75,3.12 77.97,3.12 77.44,3.66 70.04,3.66 69.94,3.56 65.18,3.56 64.59,2.97 49.95,2.97 48.5,4.42 46.37,4.42 45.06,5.74 44.54,6.08 44.38,6.19 43.61,6.51 42.81,6.66 40.21,6.66 38.74,5.19 31.46,5.19 31.28,5.37 27.42,5.37 26.66,4.62 22.19,4.62 20.44,2.86 15.94,2.86 15.36,3.45 15.36,3.81 14.73,4.43 12.76,4.43 11.33,5.86 10.56,5.86 v9(10.29,6.13)
  GND4 w0.081: v9(10.29,6.13) v4(10.06,6.36) ; v9(90.37,11.3) v4(90.68,11.62)
  BOTTOM w0.081: UE10.7 89.53,13.44 v2(90.41,12.56) 90.68,12.29 v4(90.68,11.62)
ENBKL_PCH: length 56
  TOP w0.076: v3(79.73,14.93) 79.67,15 UE5.F9
  GND2 w0.089: v1(114.9,30.13) v3(114.9,29.77)
  IN3 w0.058: 111.25,22.69 110.97,22.42 110.97,21.95 110.57,21.55 109.61,21.55 108.47,20.41 104.48,20.41 102.73,18.67 102.73,17.09 101.79,16.14 97.38,16.14 96.95,15.7 94.44,15.7 91.63,12.9 87.43,12.9 84.84,10.31 84.3,10.31 83,9.01 80.48,9.01 79.97,8.5 79.51,8.5 79.45,8.56 79.45,10.57
  IN3 w0.076: v3(79.73,14.93) 79.74,14.93 79.74,13.27 80.04,12.98 80.04,12.21 79.69,11.86 79.69,10.98 79.45,10.74 79.45,10.57
  IN3 w0.089: 111.25,22.69 112.41,23.86 112.41,25.51 113.35,26.44 113.35,27.9 113.65,28.2 113.65,28.53 113.37,28.81 113.37,29.4 113.61,29.64 114.64,29.64 114.77,29.77 v3(114.9,29.77)
ENLDO_3V5V: length 16.9
  TOP w0.254: PU301.8 63.54,26.91 63.25,27.21 v8(62.87,27.21) ; PU501.5 53.14,24.61 52.88,24.86 v5(52.88,24.93) 52.88,26.66 PR306.1
  IN1 w0.254: v8(62.87,27.21) 62.87,27.84 62.17,28.54 59.37,28.54 56.6,25.77 54.91,25.77 53.84,24.69 53.07,24.69 52.88,24.88 v5(52.88,24.93)
  BOTTOM w0.254: PR308.1 53,25.05 v5(52.88,24.93)
ENVDD_PCH: length 199.1
  GND2 w0.089: v1(114.1,29.71) 114.1,30.08 v3(114.05,30.13)
  IN3 w0.058: v9(26.53,142.12) 26.53,142.27 28.36,144.1 28.36,145.83 33.06,150.53 33.06,153.42 34.46,154.83 57.61,154.83 59.55,152.89 59.55,147.01 63.08,143.48 64.53,143.48 67.44,140.57 67.44,137.15 74.41,130.18 74.41,119.1 78.87,114.64 78.87,114.03 80.64,112.26 v9(81.39,112.26)
  GND4 w0.081: v4(26.53,141.73) v9(26.53,142.12) ; v4(81.62,112.47) 81.41,112.26 v9(81.39,112.26)
  GND4 w0.089: v3(114.05,30.13) 114.05,30.51 v6(113.98,30.57)
  IN4 w0.058: v7(86.39,70.67) 85.8,70.08 85.8,54.26 89.03,51.02 89.03,49.17 89.97,48.24
  IN4 w0.089: 89.97,48.24 90.72,47.49 91.47,47.49 91.79,47.18 94.04,47.18 94.76,47.89 95.37,47.89 95.93,47.32 97.43,47.32 97.7,47.06 99.17,47.06 101.54,44.69 103.85,44.69 106.2,42.34 107.62,42.34 108.14,41.82 108.14,41.49 111.13,38.5 111.71,38.5 111.95,38.25 111.95,37.37 113.1,36.22 113.1,35.97 112.99,35.87 112.99,34.64 112.6,34.24 112.6,33.67 113.73,32.54 113.73,31.53 113.98,31.27 v6(113.98,30.57)
  BOTTOM w0.081: v7(86.39,70.67) 86.03,71.02 86.03,72.67 86.35,72.99 86.35,98.06 86.35,98.82 86.79,99.26 86.79,106.09 81.62,111.25 v2(81.62,111.7) v4(81.62,112.47)
EQA0: length 4.2
  TOP w0.081: UM8.20 69.35,145.57 69.79,146.01 v2(69.96,146.01) 71.74,146.01 RM81.2 RM84.2
EQA1: length 3.6
  TOP w0.081: RM76.2 RM70.2 70.98,145.51 70.17,145.51 69.85,145.19 UM8.19
EQB0: length 2.3
  TOP w0.081: UM8.46 65.85,134.64 RM82.2 RM85.2
EQB1: length 1.9
  TOP w0.081: UM8.47 66.35,134.19 66.07,133.91 RM26.2 RM23.2
ESPI_FRAME#: length 49.6
  TOP w0.076: 84.2,11 83.94,11 83.32,11.61 82.56,11.61 82.42,11.76 82.42,11.91 82.41,11.91 82.41,11.97 81.67,12.72 UE5.K4
  TOP w0.081: v8(112.37,19.23) 112.37,16.36 v8(112.14,16.13) ; v8(85.48,11.7) 85.48,11.36 85.48,11.36 TC22.1 85.46,11 84.2,11
  TOP w0.122: UH1.BE38 111.1,26.38 111.45,26.03 111.45,25.63 111.82,25.26 111.82,24.31 v8(111.8,24.29)
  IN1 w0.058: v8(112.37,19.23) 110.95,19.23 110.57,19.61 109.5,19.61 109.4,19.71 109.4,21.47 110.62,22.69 ; v8(85.48,11.7) 85.49,11.7 85.9,12.12 86.81,12.12 88.27,13.58 88.61,13.58 91.42,16.4 102.26,16.4 102.66,16 104.28,16 105.04,15.24 105.61,15.24 106.2,15.83 107.45,15.83 108.02,16.39 111.88,16.39 v8(112.14,16.13)
  IN1 w0.089: v8(111.8,24.29) 111.8,23.87 110.62,22.69
ESPI_IO0: length 38.9
  TOP w0.076: 84.2,12.86 UE5.N4
  TOP w0.081: v1(85.29,12.64) 85,12.64 84.93,12.71 84.93,12.72 84.79,12.86 84.2,12.86
  TOP w0.089: v5(112.14,27.71) 111.85,28 UH1.BB39
  GND2 w0.081: v3(85.47,12.27) 85.34,12.4 85.34,12.43 85.33,12.44 85.33,12.58 85.29,12.61 v1(85.29,12.64)
  IN3 w0.058: v3(85.47,12.27) 85.88,12.27 87.15,13.54 91.37,13.54 94.2,16.37 96.71,16.37 97.11,16.78 101.52,16.78 102.09,17.35 102.09,18.94 104.26,21.1 108.25,21.1 109.66,22.51 109.66,22.53 109.82,22.69
  IN3 w0.089: 109.82,22.69 110.1,22.97 110.1,23.51 110.48,23.89 110.48,24.98 112.16,26.66 112.16,27.69 v5(112.14,27.71)
ESPI_IO1: length 43
  TOP w0.076: v5(83.88,11.62) 83.78,11.62 83.28,12.11 82.5,12.11 82.11,12.5 82.11,12.92 81.67,13.36 UE5.K5
  TOP w0.122: v5(111.43,29.49) 111.26,29.31 UH1.AW37
  IN3 w0.058: 109.2,22.69 109.2,22.59 108.07,21.45 104.16,21.45 101.38,18.67 100.4,18.67 99.79,18.06 97.55,18.06 97.09,17.6 94.42,17.6 93.59,16.77 93.59,16.21 91.26,13.88 86.59,13.88 86.57,13.9 86.26,13.9 85.79,13.43 85.79,13.3 84.77,12.28 84.77,11.86 84.49,11.58 84.2,11.58
  IN3 w0.076: v5(83.88,11.62) 83.93,11.56 84.04,11.56 84.06,11.58 84.2,11.58
  IN3 w0.089: 109.2,22.69 109.2,24.2 111.6,26.6 111.6,29.32 v5(111.43,29.49)
  BOTTOM w0.076: v5(83.88,11.62) 83.88,11.56 83.8,11.48 TC24.1
ESPI_IO2: length 41.6
  TOP w0.076: UE5.M4 82.81,12.86 83.06,13.11 83.06,13.11 83.99,13.11 84.14,13.27 84.14,13.29 84.2,13.35
  TOP w0.081: v1(84.35,13.5) 84.2,13.35
  TOP w0.122: UH1.AV37 110.98,29.87 v5(111.01,29.87)
  GND2 w0.081: v3(84.72,12.93) 84.47,13.18 84.47,13.24 84.43,13.27 84.43,13.4 84.35,13.48 v1(84.35,13.5)
  IN3 w0.058: v3(84.72,12.93) 84.72,12.93 84.78,12.99 84.78,13.81 85.35,14.39 86.53,14.39 86.72,14.2 91.11,14.2 93.27,16.36 93.27,16.93 93.97,17.63 94.26,17.92 96.96,17.92 97.42,18.38 99.66,18.38 100.27,18.99 101.25,18.99 104.06,21.81 107.97,21.81 108.85,22.69 108.85,22.69
  IN3 w0.089: v5(111.01,29.87) 110.23,29.87 109.79,29.43 109.79,28.2 110.68,27.31 110.68,26.19 108.85,24.35 108.85,22.69
ESPI_IO3: length 40
  TOP w0.076: 84.2,11.83 83.9,12.13 83.6,12.13 83.37,12.36 UE5.N3
  TOP w0.081: v3(84.43,12.16) 84.39,12.12 84.39,11.78 TC26.1 84.28,11.75 84.2,11.83
  TOP w0.122: UH1.BA38 110.96,28.99 110.54,28.99 110.42,29.11 v5(110.24,29.11)
  IN3 w0.058: v3(84.43,12.16) 84.43,12.16 85.6,13.33 85.6,13.47 86.19,14.06 86.64,14.06 86.65,14.04 91.2,14.04 93.43,16.28 93.43,16.86 94.33,17.76 97.03,17.76 97.49,18.22 99.73,18.22 100.34,18.83 101.31,18.83 104.11,21.63 108.02,21.63 109.03,22.64 109.03,22.69
  IN3 w0.089: v5(110.24,29.11) 110.24,28.69 110.41,28.52 110.41,27.83 110.87,27.37 110.87,26.12 109.03,24.28 109.03,22.69
ESPI_KB_RST#: length 40.5
  TOP w0.122: UH1.BE39 111.56,26.55 111.66,26.45 111.66,26.09 112.08,25.67 112.08,24.55 112.18,24.45 112.18,24.13 111.96,23.91 111.82,23.91 v2(111.31,23.4) 110.44,22.53 v3(110.44,22.01)
  GND2 w0.081: v3(82.8,9.35) 82.8,9 v1(82.68,8.88)
  IN3 w0.058: v3(110.44,22.01) 109.85,22.01 108.41,20.57 104.41,20.57 102.57,18.74 102.57,17.15 101.72,16.3 97.31,16.3 96.88,15.86 94.37,15.86 91.57,13.06 87.36,13.06 84.81,10.51 83.26,10.51 82.8,10.05 v3(82.8,9.35)
ESPI_RST#: length 42.1
  TOP w0.089: v5(111.44,25.05) 111.4,25.05 111.32,25.14 111.32,25.43 111.07,25.68 UH1.BF38
  IN1 w0.058: v11(84.78,11.2) 84.71,11.27 84.71,13.89 84.33,14.28 84.33,14.7 84.2,14.82
  IN1 w0.076: 84.2,14.82 83.66,15.36 v8(83.17,15.36)
  GND2 w0.081: v3(84.71,10.88) 84.78,10.95 v11(84.78,11.2)
  IN3 w0.058: 110.73,22.69 110.55,22.51 110.12,22.51 108.36,20.75 104.36,20.75 102.41,18.8 102.41,17.22 101.65,16.46 97.25,16.46 96.81,16.02 94.31,16.02 91.5,13.22 87.28,13.22 84.96,10.89 84.72,10.89 v3(84.71,10.88)
  IN3 w0.089: v5(111.44,25.05) 111.05,25.05 110.83,24.83 110.83,24.19 111.19,23.84 111.19,23.14 110.73,22.69
  BOTTOM w0.089: v5(111.44,25.05) v2(110.91,25.05)
ESPI_SERIRQ: length 39.4
  TOP w0.076: v5(83.8,12.51) 83.72,12.51 83.62,12.61 82.91,12.61 UE5.M3
  TOP w0.089: v5(106.8,27.65) 106.93,27.65 107.03,27.55 107.78,27.55 107.82,27.5 108.29,27.5 108.43,27.64 108.43,27.93 109.69,29.19 UH1.AW35
  IN3 w0.058: 84.2,14.06 84.85,14.71 86.67,14.71 86.85,14.52 90.95,14.52 92.95,16.52 92.95,16.8 92.95,17.06 93.65,17.76 94.14,18.25 95.68,18.25 96.18,18.75 99.18,18.75 102.44,22.01 103.21,22.01 103.81,22.61 104.25,22.61 104.34,22.69
  IN3 w0.076: v5(83.8,12.51) 83.85,12.57 83.85,13.71 84.2,14.06
  IN3 w0.089: 104.34,22.69 105.09,23.44 105.15,23.44 106.04,24.33 106.04,26.18 106.8,26.95 v5(106.8,27.65)
  BOTTOM w0.076: 84.2,12.56 84.15,12.51 v5(83.8,12.51)
  BOTTOM w0.081: 84.2,12.56 TC21.1
  BOTTOM w0.089: v5(106.8,27.65) 107.17,27.65 107.74,27.08 RH111.1
FB_1.0VS_VGAP: length 3.6
  BOTTOM w0.254: PR1110.2 67.53,104.88 PR1107.2 68.34,104.89 PR1111.1 68.77,105.69 69.43,105.03 PU1101.11
FB_1.2V: length 4.3
  TOP w0.203: PUM1.6 146.19,45.25 145.67,44.73 PRM15.1 PRM16.1 PRM17.1 PRM14.1
FB_2PH: length 9.3
  TOP w0.203: PUZ1.34 143.72,123.55 v5(143.7,123.54) 143.7,123.41 143.96,123.15 v5(143.96,121.31) 143.96,121.06 PCZ22.2
  BOTTOM w0.081: PCZ18.1 142.61,121.94 142.18,121.5 v2(142.06,121.5)
  BOTTOM w0.254: PRZ36.1 143.96,121.43 v5(143.96,121.31) 144.09,121.18 PRZ71.1 ; PCZ18.1 143.59,121.94 143.8,122.15 143.8,123.43 v5(143.7,123.54)
FB_4PH: length 6.4
  TOP w0.203: PRZ38.1 v5(144.97,134.27) PRZ8.1 ; v5(144.27,131.92) 144.12,131.77 PUZ1.5
  BOTTOM w0.081: v2(145.25,134.75) 144.97,134.47 v5(144.97,134.27)
  BOTTOM w0.203: PCZ34.2 PCZ17.2 145.35,132.62 144.65,131.92 v5(144.27,131.92)
  BOTTOM w0.254: v5(144.97,134.27) 144.97,134.03 PCZ34.2
FB_+1.8VGS: length 4.9
  TOP w0.081: PR1814.1 49.97,1.74 v2(50.25,1.46)
  TOP w0.254: PU1802.11 48.23,4.63 48.7,4.16 48.87,4.16 49.06,3.96 49.06,3.66 PR1812.2 PR1816.2 49.26,1.83 PR1814.1
FB_+1VALWP: length 5.4
  TOP w0.081: PRH3.1 v2(141.86,33.07)
  TOP w0.254: 139.89,33.07 140.08,32.88 140.08,31.08 139.64,30.64 PUH1.4 ; 139.89,33.07 PRH7.1 ; 139.89,33.07 PRH3.1
FB_A_CLK0: length 26.9
  IN2 w0.084: v3(36.52,133.12) 36.58,133.07 37.19,133.07 38.4,134.28 41.31,134.28 42.53,133.07 42.53,128.61 42.52,128.61 42.52,121.4 42.81,121.11 42.81,115.11 41.83,114.12 41.62,114.12 v3(41.45,113.95)
FB_A_CLK1: length 26.6
  IN2 w0.084: v3(50.38,132.38) 50.49,132.49 50.73,132.49 51.26,133.01 51.26,133.45 50.9,133.81 50.09,133.81 49.73,133.45 47.61,133.45 45.54,131.39 45.54,125.24 45.54,125.23 45.54,123.26 43.41,121.13 43.41,120.62 43.4,120.62 43.4,118.32 43.97,117.75 43.97,114.85 43.76,114.65 v3(43.55,114.65)
FB_A_CLK#0: length 26.9
  IN2 w0.084: v3(36.52,132.38) 36.52,132.65 36.74,132.87 37.27,132.87 38.48,134.08 41.23,134.08 42.32,132.98 42.32,124.24 42.32,124.24 42.32,121.31 42.61,121.02 42.61,115.19 41.74,114.33 41.45,114.33 41.37,114.41 41.37,114.57 v3(41.45,114.65)
FB_A_CLK#1: length 26.6
  IN2 w0.084: v3(43.55,113.95) 43.55,114.15 44.17,114.77 44.17,117.84 43.61,118.4 43.61,120.62 43.61,120.62 43.61,121.04 45.74,123.18 45.74,125.15 45.74,125.15 45.74,131.3 47.69,133.25 49.82,133.25 50.17,133.61 50.82,133.61 51.05,133.37 51.05,133.1 50.65,132.69 50.49,132.69 50.28,132.91 50.28,133.03 v3(50.38,133.12)
FB_A_CMD0: length 22.9
  TOP w0.089: 32.38,121.16 33.14,120.4 34.64,120.4 36.18,118.86 36.18,118.53 UG1.Y51
  TOP w0.099: UG11.H3 30.88,134.27 29.4,134.27 28.48,133.34 28.48,124.81 31.85,121.44 v2(32.09,121.44) 32.38,121.16
FB_A_CMD1: length 22.1
  TOP w0.081: UG11.K3 30.93,132.72 30.93,132.78 UG11.J3
  TOP w0.089: 33,121.16 33.51,120.65 34.75,120.65 UG1.Y52
  TOP w0.099: 30.93,132.78 30.88,132.83 30.88,133.31 30.66,133.53 29.67,133.53 28.8,132.65 28.8,124.94 30.6,123.13 31.03,123.13 v2(31.09,123.07) 33,121.16
FB_A_CMD2: length 19.7
  TOP w0.089: 34.25,121.16 v2(34.38,121.02) 34.44,120.96 34.86,120.96 36.88,118.95 36.88,117.16 36.55,116.83 UG1.Y49
  TOP w0.099: 34.25,121.16 RG1482.2 30.14,125.27 30.14,132.76 UG11.J1
FB_A_CMD3: length 18.1
  TOP w0.081: UG11.K4 32.03,132.37 32.03,132.5 31.74,132.79 31.74,132.84 UG11.J4
  TOP w0.089: 34.94,121.16 37.25,118.85 UG1.AA52
  TOP w0.099: 31.74,132.79 31.67,132.71 31.67,132.2 31.44,131.98 31.09,131.98 30.89,131.78 30.89,125.35 33.49,122.75 v2(33.49,122.61) 34.94,121.16
FB_A_CMD4: length 16.2
  TOP w0.089: 35.37,121.16 37.61,118.91 37.61,118.71 37.25,118.35 UG1.AA51
  TOP w0.099: 35.37,121.16 35.24,121.28 35.18,121.35 35.18,121.57 31.62,125.12 31.62,131.28 UG11.L3
FB_A_CMD5: length 16.4
  TOP w0.089: UG1.AA50 37.6,117.8 37.6,118.26 37.81,118.47 37.81,119.16 35.82,121.16
  TOP w0.099: 35.82,121.16 35.56,121.42 35.56,121.63 33.21,123.98 v2(33.21,124.32) 33.21,130.21 32.9,130.52 32.38,130.52 UG11.M4
FB_A_CMD6: length 18.8
  TOP w0.081: UG11.J5 33.1,132.8 v8(33.1,132.74) 33.1,132.7 UG11.K5
  TOP w0.089: UG1.AC50 38.28,117.82 38.28,118.42 38.08,118.62 38.08,119.35 36.27,121.16
  TOP w0.099: v8(33.05,131.28) 33.32,131.28 33.53,131.07 33.53,124.6 33.74,124.39 33.74,124.12 v2(35.22,122.64) 35.94,121.92 35.94,121.49 36.27,121.16
  IN1 w0.071: v8(33.05,131.28) 33.05,131.54 33.1,131.6 v8(33.1,132.74)
FB_A_CMD7: length 19.8
  TOP w0.081: UG11.L5 33.51,132.36 33.51,133.14 UG11.H5
  TOP w0.089: 36.73,121.16 38.31,119.57 38.31,118.71 38.65,118.37 UG1.AC51
  TOP w0.099: 33.51,132.86 33.73,132.86 33.89,132.7 33.89,124.79 36.27,122.4 36.27,121.65 36.37,121.55 v2(36.4,121.55) 36.4,121.48 36.73,121.16
FB_A_CMD8: length 19
  TOP w0.089: UG1.AC52 38.65,119.69 37.18,121.16
  TOP w0.099: 37.18,121.16 37.18,121.27 36.58,121.87 36.58,122.95 v2(35.11,124.41) 34.21,125.32 34.21,133.26 33.19,134.27 32.38,134.27 UG11.G4
FB_A_CMD9: length 21.6
  TOP w0.089: 37.63,121.16 38.97,119.81 38.97,117.35 38.65,117.02 UG1.AC49
  TOP w0.099: 37.63,121.16 37.63,121.33 36.9,122.06 v2(36.9,123.12) 36.9,124.23 35.22,125.91 35.22,134.08 36.11,134.97 36.93,134.97 UG11.G11
FB_A_CMD10: length 19
  TOP w0.081: UG11.G10 36.92,134.23 v8(36.92,132.74) 36.92,131.27 UG11.M10
  TOP w0.089: 38.08,121.16 39.35,119.89 UG1.AD52
  TOP w0.099: 38.08,121.16 v2(38.08,121.21) 38.08,121.42 37.33,122.18 v8(37.33,124.29)
  IN1 w0.071: v8(37.33,124.29) 37.33,125.96 36.92,126.36 v8(36.92,132.74)
FB_A_CMD11: length 19.9
  TOP w0.081: UG11.H10 36.17,133.52 36.17,131.98 UG11.L10
  TOP w0.089: UG1.AD51 39.35,118.15 39.35,118.36 39.72,118.73 39.72,119.98 39.36,120.34 39.36,121.16
  TOP w0.099: 39.36,121.16 38.96,121.55 v2(38.96,122.7) 38.96,124.39 38.03,125.32 36.81,125.32 35.86,126.27 35.86,132.66 35.98,132.78 36.17,132.78
FB_A_CMD12: length 15.1
  TOP w0.089: 39.8,121.16 39.8,120.35 39.95,120.2 39.95,118.51 39.68,118.24 39.68,117.78 UG1.AD50
  TOP w0.099: UG11.M11 37.69,130.46 38.19,130.46 38.4,130.26 38.4,125.52 v2(39.62,124.3) 39.8,124.12 39.8,121.16
FB_A_CMD13: length 16.6
  TOP w0.089: UG1.AF50 40.4,117.8 40.4,118.39 40.23,118.57 40.23,120.46 40.13,120.55 40.13,121.16
  TOP w0.099: UG11.L12 38.43,131.22 39.67,131.22 40.83,130.06 40.83,122.33 v2(40.63,122.13) 40.13,121.63 40.13,121.16
FB_A_CMD14: length 18.8
  TOP w0.081: UG11.J11 37.59,132.81 ; UG11.K11 37.27,132.49 37.59,132.81
  TOP w0.089: 40.44,121.16 40.44,118.66 40.69,118.41 40.69,118.21 UG1.AF51
  TOP w0.099: 40.44,121.16 40.44,121.36 41.28,122.2 v2(41.28,123.79) 41.28,130.14 40.07,131.35 40.07,131.66 39.74,131.99 37.83,131.99 37.63,132.19 37.63,132.76 37.59,132.81 37.59,132.81
FB_A_CMD15: length 21
  TOP w0.081: UG11.K12 38.25,132.6 38.25,132.6 38.4,132.75 38.25,132.9 38.25,132.9 UG11.J12
  TOP w0.089: 40.77,121.16 40.75,121.14 UG1.AF52
  TOP w0.099: 38.4,132.75 38.4,133.3 38.61,133.51 42.02,133.51 42.67,132.85 v2(42.67,125.01) 42.67,123.06 40.77,121.16
FB_A_CMD16: length 30.3
  TOP w0.089: UG1.AN50 45.65,117.62 46.04,118.01 46.04,118.33 46.89,119.18 52.41,119.18 52.88,119.65
  TOP w0.099: 52.88,119.65 53.02,119.79 54.42,119.79 60.55,125.92 v2(60.55,131.13) 60.55,131.15 57.47,134.23 55.98,134.23 UG12.L3
FB_A_CMD17: length 29
  TOP w0.081: UG12.J3 55.99,132.74 ; UG12.K3 55.99,132.76
  TOP w0.089: UG1.AN51 45.65,118.39 46.67,119.41 52.18,119.41 52.88,120.11
  TOP w0.099: 55.99,132.76 55.99,132.74 ; 55.99,132.74 55.99,132.74 ; 55.99,132.74 58.51,132.74 59.92,131.33 v2(59.92,129.22) 60.24,128.9 60.24,126.04 54.31,120.11 52.88,120.11
FB_A_CMD18: length 25
  TOP w0.089: UG1.AN52 46.44,119.64 51.93,119.64 52.74,120.44 52.88,120.44
  TOP w0.099: UG12.J1 57.99,132.38 59.21,131.16 59.21,127.16 59.66,126.7 ; 59.66,126.7 RG1481.2 ; 59.66,126.7 59.3,126.34 59.3,125.57 v2(55.23,121.5) 55.21,121.5 54.15,120.44 52.88,120.44
FB_A_CMD19: length 29.7
  TOP w0.081: UG12.J4 54.87,132.69 54.96,132.77 55.16,132.77 55.16,132.84 UG12.K4
  TOP w0.089: 52.88,120.78 52.74,120.78 51.82,119.87 46.13,119.87 45.29,119.03 45.29,117.09 UG1.AM49
  TOP w0.099: 52.88,120.78 53.86,120.78 v2(57.34,124.26) 57.51,124.26 58.61,125.36 58.61,131.19 57.81,131.99 55.5,131.99 55.27,132.22 55.27,132.66 55.16,132.77
FB_A_CMD20: length 24.2
  TOP w0.089: 52.87,121.11 52.56,121.11 51.55,120.09 46.04,120.09 44.95,119 UG1.AM52
  TOP w0.099: 52.87,121.11 53.67,121.11 v2(55.89,123.33) 57.21,124.65 57.44,124.65 58.17,125.38 58.17,130.56 57.5,131.23 56.02,131.23 UG12.H3
FB_A_CMD21: length 20.8
  TOP w0.089: 52.22,121.16 51.41,120.35 45.83,120.35 44.62,119.13 44.62,118.75 44.95,118.42 UG1.AM51
  TOP w0.099: 52.22,121.16 52.59,121.53 52.7,121.53 53.75,122.57 v2(53.75,124.39) 53.75,130.36 53.9,130.52 54.52,130.52 UG12.G4
FB_A_CMD22: length 24.3
  TOP w0.081: UG12.K5 54.52,132.73 ; 54.52,132.72 54.17,132.38 UG12.J5
  TOP w0.089: UG1.AM50 44.63,117.77 44.63,118.33 44.39,118.56 44.39,119.23 45.74,120.58 51.21,120.58 51.79,121.16
  TOP w0.099: 54.52,132.73 54.52,131.43 54.33,131.24 53.88,131.24 53.36,130.72 v2(53.36,122.65) 53.28,122.57 53.2,122.57 51.79,121.16
FB_A_CMD23: length 25.6
  TOP w0.081: UG12.H5 53.62,132.13 53.62,133.37 UG12.L5
  TOP w0.089: UG1.AK50 43.9,117.8 43.9,118.27 44.16,118.54 44.16,119.32 45.67,120.83 51.04,120.83 51.36,121.16
  TOP w0.099: 51.36,121.16 53.04,122.84 53.04,132.66 53.14,132.75 53.62,132.75
FB_A_CMD24: length 24.8
  TOP w0.089: 45.53,121.08 43.86,119.42 43.86,118.62 43.55,118.3 UG1.AK51
  TOP w0.099: 45.53,121.08 50.76,121.08 v2(51.9,122.22) 51.98,122.3 52.08,122.3 52.72,122.95 52.72,133.29 53.68,134.25 54.5,134.25 UG12.M4
FB_A_CMD25: length 24.8
  TOP w0.089: UG1.AK52 43.55,119.52
  TOP w0.099: 43.55,119.52 45.39,121.36 50.23,121.36 v2(50.47,121.61) 51.6,122.74 52.09,122.74 52.39,123.04 52.39,124.87 52.09,125.16 52.09,133.49 50.61,134.97 49.97,134.97 UG12.M11
FB_A_CMD26: length 28.8
  TOP w0.081: UG12.M10 50,134.24 v8(50,132.76) 50,131.26 UG12.G10
  TOP w0.089: 43.23,119.67 43.23,117.41 42.85,117.03 UG1.AJ49 ; 44.26,120.7 44.27,120.72
  TOP w0.099: v8(51.56,133.34) 51.56,133.06 51.65,132.97 51.65,124.55 RG1480.2 51.9,124.28 49.26,121.64 45.2,121.64 v2(45.07,121.52) 44.27,120.72 ; 43.23,119.67 44.26,120.7
  IN1 w0.071: v8(51.56,133.34) 50.98,132.76 v8(50,132.76)
FB_A_CMD27: length 23.3
  TOP w0.081: UG12.L10 50.81,133.87 50.89,133.79 50.89,131.81 50.7,131.63 UG12.H10
  TOP w0.089: UG1.AJ52 42.85,119.15 42.91,119.21 42.91,119.89 ; 44.17,121.15 44.17,121.16
  TOP w0.099: 44.17,121.16 44.93,121.92 48.99,121.92 v2(50.75,123.68) 51.06,123.99 51.06,129.72 51.27,129.92 51.27,132.72 51.18,132.81 50.89,132.81 ; 42.91,119.89 44.17,121.15
FB_A_CMD28: length 18.5
  TOP w0.089: UG1.AJ51 42.85,118.36 42.53,118.68 42.53,119.98
  TOP w0.099: 42.53,119.98 44.73,122.18 48.74,122.18 v2(49.09,122.53) 50,123.43 50,130.5 UG12.G11
FB_A_CMD29: length 19.7
  TOP w0.089: UG1.AJ50 42.5,117.8 42.5,118.33 42.28,118.55 42.28,120.15
  TOP w0.099: 42.28,120.15 44.55,122.43 48.49,122.43 49.11,123.05 v2(49.11,124.28) 49.23,124.41 49.23,131.27 UG12.H12
FB_A_CMD30: length 21.7
  TOP w0.081: UG12.K12 48.74,132.99 48.74,132.75 48.88,132.61 UG12.J12
  TOP w0.089: 42.02,120.41 42.02,118.55 41.83,118.36 41.83,117.79 41.49,117.45 UG1.AG50
  TOP w0.099: 48.74,132.75 48.56,132.56 48.56,132.51 48.55,132.51 48.55,132.19 48.51,132.15 48.51,125.14 48.65,125.01 48.65,123.02 48.3,122.67 44.33,122.67 v2(44.3,122.65) 44.26,122.65 42.02,120.41
FB_A_CMD31: length 23.9
  TOP w0.081: UG12.K11 49.63,133.09 49.33,132.79 49.33,132.67 UG12.J11
  TOP w0.089: 41.71,120.54 41.71,119.05 41.77,118.99 41.77,118.63 41.45,118.32 UG1.AG51
  TOP w0.099: 41.71,120.54 44.17,123 v2(45.89,123) 48.23,123 48.34,123.11 48.34,124.66 47.75,125.25 47.75,133.33 47.93,133.5 49.02,133.5 49.24,133.29 49.24,132.89 49.33,132.79
FB_A_CMD32: length 23
  TOP w0.089: UG1.AF49 40.75,117.03 41.13,117.41 41.13,120.98 41.26,121.1 41.26,121.1 41.28,121.12
  TOP w0.099: 41.28,121.12 43.12,122.96 v2(43.12,126.9) 43.12,132.92 42.09,133.95 40.39,133.95 40.06,134.27 38.42,134.27 UG11.H12
FB_A_CMD33: length 19.7
  TOP w0.089: 41.88,121.16 41.45,120.73 UG1.AG52
  TOP w0.099: UG12.L12 48.48,134.27 47.17,134.27 45.93,133.03 45.93,125.21 v2(45.17,124.44) 41.88,121.16
FB_A_D0: length 18.2
  IN1 w0.086: v8(30.53,134.62) 30.93,134.22 30.93,125.31 34.53,121.71 34.53,119.71 34.45,119.63 v8(34.45,118.15)
FB_A_D1: length 22
  IN1 w0.086: v8(30.53,136.12) 30.53,135.9 30.13,135.5 30.13,125.66 34.19,121.6 34.19,116.31 v8(34.45,116.05)
FB_A_D2: length 20.1
  IN1 w0.086: v8(34.45,117.45) 34.45,117.78 34.71,118.04 34.71,119.26 34.85,119.39 34.85,121.84 31.67,125.01 31.67,134.68 31.37,134.99 30.92,134.99 v8(30.53,135.37)
FB_A_D3: length 21.6
  IN1 w0.086: v8(31.28,136.12) 31.59,135.81 32.05,135.81 32.36,135.49 32.36,124.77 35.16,121.97 35.16,119.25 34.89,118.98 34.89,117.97 34.71,117.79 34.71,117.32 34.45,117.06 v8(34.45,116.75)
FB_A_D4: length 25.3
  IN1 w0.086: v8(32.03,138.37) 31.56,137.91 29.39,137.91 28.2,136.71 28.2,125.91 33.13,120.97 33.13,119.32 33.31,119.14 33.31,118.41 v8(33.05,118.15)
FB_A_D5: length 25.6
  IN1 w0.086: v8(31.28,138.37) 30.98,138.08 29.32,138.08 29.31,138.08 29.05,138.08 27.88,136.9 27.88,125.78 32.69,120.97 32.69,117.81 v8(33.05,117.45)
FB_A_D6: length 28.1
  IN1 w0.086: v8(33.05,115.35) 32.74,115.66 32.74,116.96 32.6,117.1 32.09,117.1 31.99,117.2 31.99,121.22 27.56,125.65 27.56,137.13 29.09,138.66 30.24,138.66 v8(30.53,138.37)
FB_A_D7: length 31.9
  IN1 w0.086: v8(31.28,139.12) 30.93,139.47 29.4,139.47 27.25,137.32 27.25,125.51 31.38,121.38 31.38,116.48 31.94,115.92 31.94,115.22 32.16,115 34.1,115 v8(34.45,114.65)
FB_A_D8: length 31.7
  IN1 w0.086: v8(38.77,138.37) 39.12,138.03 39.87,138.03 41.53,136.36 41.53,124.73 39.17,122.38 39.17,117.76 38.65,117.23 38.65,115.9 39.01,115.54 39.01,115.17 38.83,115 38.52,115 37.62,114.1 37.62,113.72 37.49,113.59 36.36,113.59 36.13,113.82 36.13,114.45 35.94,114.65 v8(35.15,114.65)
FB_A_D9: length 26.7
  IN1 w0.086: v8(36.55,113.95) 36.9,114.3 37.38,114.3 38.04,114.95 38.04,115.52 38.33,115.81 38.33,117.32 38.86,117.85 38.86,122.51 41.21,124.86 41.21,135.58 40.84,135.94 40.26,135.94 40.07,135.76 39.38,135.76 39.03,136.11
  IN1 w0.089: v8(38.77,136.12) 39.02,136.12 39.03,136.11
FB_A_D10: length 25.4
  IN1 w0.086: v8(36.55,115.35) 36.85,115.65 36.85,116.19 37.14,116.48 37.36,116.48 37.56,116.68 37.56,117.38 38.22,118.04 38.22,122.77 40.64,125.19 40.64,132.68 40.55,132.77 39.28,132.77 39.19,132.86 39.19,133.03 39.28,133.12 40.55,133.12 40.64,133.2 40.64,133.37 40.55,133.46 39.99,133.46 39.9,133.55 39.9,134.1 39.82,134.19 38.95,134.19 38.77,134.37 v8(38.77,134.62)
FB_A_D11: length 25.3
  IN1 w0.086: v8(38.77,135.37) 39.06,135.09 40.02,135.09 40.11,135.01 40.11,134.59 40.19,134.5 40.81,134.5 40.89,134.41 40.89,134.22 40.81,134.13 40.55,134.13 40.46,134.05 40.46,133.88 40.55,133.79 40.81,133.79 40.89,133.7 40.89,125 38.54,122.64 38.54,117.95 37.91,117.31 37.91,116.55 37.59,116.23 37.59,115.15 37.44,115 36.9,115 v8(36.55,114.65)
FB_A_D12: length 24.2
  IN1 w0.086: v8(35.15,117.45) 35.58,117.45 36.63,118.49 36.63,122.53 35.22,123.94 35.22,136.21 36.25,137.24 37.45,137.24 37.7,137.48 37.7,137.77 38.02,138.1 v8(38.02,138.37)
FB_A_D13: length 23.9
  IN1 w0.086: 37.58,135.91 37.4,135.73 36.7,135.73 35.65,134.68 35.65,123.95 36.94,122.66 36.94,118.23 35.5,116.78 35.5,116.71 35.21,116.42 35.08,116.42 34.82,116.16 34.82,115.68 v8(35.15,115.35)
  IN1 w0.089: v8(38.02,136.12) 37.8,136.12 37.58,135.91
FB_A_D14: length 23.1
  TOP w0.089: UG1.U52 34.77,118.53 35.57,118.53 v1(35.85,118.8)
  IN1 w0.086: v8(37.27,138.37) 36.72,137.82 36.34,137.82 34.9,136.39 34.9,123.81 36.24,122.47 36.24,119.2 v1(35.85,118.8)
FB_A_D15: length 24.1
  IN1 w0.086: v8(38.02,139.12) 37.74,138.84 36.32,138.84 34.59,137.1 34.59,123.68 35.93,122.34 35.93,119.39 35.43,118.9 35.43,118.43 v8(35.15,118.15)
FB_A_D16: length 20.8
  IN4 w0.086: v4(38.77,130.13) 39.11,130.46 40.32,130.46 42.61,128.17 42.61,123.47 41.63,122.49 41.63,116.71 41.84,116.49 41.84,114.26 v3(42.85,113.25)
FB_A_D17: length 16
  IN4 w0.086: v4(38.77,129.38) 39.16,129.76 40.46,129.76 41.34,128.88 41.34,119.55 41.45,119.44 v6(41.45,116.05)
FB_A_D18: length 20.8
  IN4 w0.086: v4(38.77,130.88) 39.12,131.22 40.26,131.22 42.93,128.55 42.93,123.38 41.91,122.37 41.91,116.84 42.02,116.74 42.02,114.78 42.85,113.95 v3(42.85,113.95)
FB_A_D19: length 14.9
  TOP w0.089: UG1.AG49 v3(41.15,117.05)
  IN4 w0.086: v3(41.15,117.05) 41.12,117.09 41.12,119.22 41.05,119.29 41.05,127.76 39.81,129 38.4,129 v4(38.02,129.38)
FB_A_D20: length 14.4
  TOP w0.089: UG1.AF46 v3(40.42,114.99)
  IN4 w0.086: v4(37.27,127.13) 37.59,126.81 37.59,126.01 38.67,124.93 38.67,118.26 39.38,117.55 39.38,115.27 39.66,114.99 v3(40.42,114.99)
FB_A_D21: length 12.9
  TOP w0.089: UG1.AF47 v3(40.42,115.69)
  IN4 w0.086: v3(40.42,115.69) 39.94,116.16 39.94,117.81 39.25,118.51 39.25,125.24 38.42,126.08 38.42,126.73 v4(38.02,127.13)
FB_A_D22: length 11.9
  TOP w0.089: UG1.AF48 v3(40.41,116.39)
  IN4 w0.086: v4(38.77,127.13) 39.03,126.87 39.03,125.9 39.54,125.4 39.54,118.63 40.16,118.01 40.16,116.64 v3(40.41,116.39)
FB_A_D23: length 11.9
  TOP w0.089: UG1.AD47 v3(39.75,115.7)
  IN4 w0.086: v3(39.75,115.7) 39.67,115.77 39.67,117.67 39.45,117.9 38.96,118.39 38.96,125.09 38.02,126.02 v4(38.02,126.38)
FB_A_D24: length 19.2
  TOP w0.089: v3(39.03,116.99) 39.27,116.75 UG1.AD49
  IN4 w0.086: v6(30.53,130.88) 30.79,130.62 31.43,130.62 31.53,130.72 32.88,130.72 35.31,128.3 35.31,126.39 37.85,123.85 37.85,118.64 38.93,117.57 38.93,117.1 v3(39.03,116.99)
FB_A_D25: length 19.5
  TOP w0.089: v3(38.98,116.36) 39.3,116.05 UG1.AD48
  IN4 w0.086: v3(38.98,116.36) 38.55,116.79 38.55,117.43 37.56,118.42 37.56,123.54 35.03,126.07 35.03,128.12 32.68,130.47 31.76,130.47 31.68,130.38 30.79,130.38 v6(30.53,130.13)
FB_A_D26: length 19.5
  IN4 w0.086: v6(30.53,129.38) 30.88,129.02 33.18,129.02 34.4,127.81 34.4,125.88 36.98,123.3 36.98,118.18 37.97,117.19 37.97,116.55 38.35,116.17 38.35,115.64 38.23,115.52 38.23,115.07 v3(38.65,114.65)
FB_A_D27: length 18.7
  IN4 w0.086: v3(38.65,115.35) 38.64,115.36 38.64,116.29 38.26,116.67 38.26,117.31 37.27,118.3 37.27,123.42 34.71,125.98 34.71,128.07 33.01,129.77 31.67,129.77 v6(31.28,129.38)
FB_A_D28: length 14.3
  IN4 w0.086: v6(32.03,127.13) 32.38,126.77 33.02,126.77 33.4,126.39 33.4,125.5 36.11,122.79 36.11,116.49 v3(37.25,115.35)
FB_A_D29: length 15.2
  IN4 w0.086: v3(37.25,114.65) 35.82,116.08 35.82,122.64 32.38,126.08 32.38,126.39 32.13,126.64 31.77,126.64 v6(31.28,127.13)
FB_A_D30: length 14.9
  IN4 w0.086: v6(31.28,126.38) 31.28,126.03 35.53,121.77 35.53,115.88 36.6,114.81 36.6,114.6 v3(37.25,113.95)
FB_A_D31: length 16.4
  IN4 w0.086: v3(36.55,113.25) 36.55,113.54 36.14,113.95 36.14,114.66 35.24,115.56 35.24,121.65 30.8,126.1 30.8,126.85 v6(30.53,127.13)
FB_A_D32: length 11.1
  IN1 w0.086: v8(54.87,127.13) 54.55,126.8 54.55,124.72 50.21,120.39 50.21,118.51 v1(49.85,118.15)
FB_A_D33: length 10.4
  IN1 w0.086: v8(56.37,127.13) 56.07,126.82 56.07,124.98 51.23,120.14 51.23,118.87 v8(51.25,118.85)
FB_A_D34: length 12.2
  IN1 w0.086: v8(49.85,117.45) 50.23,117.83 50.23,118.2 50.53,118.5 50.53,120.3 55.18,124.95 55.18,126.84 55.47,127.13 v8(55.62,127.13)
FB_A_D35: length 10.4
  IN1 w0.086: v8(55.62,126.38) 55.62,124.94 50.87,120.18 50.87,118.53 v8(51.25,118.15)
FB_A_D36: length 16.5
  IN1 w0.086: v8(55.62,129.38) 56.07,128.93 57.21,128.93 57.78,128.36 57.78,125.38 52.64,120.23 52.64,118.53 52.32,118.21 52.32,117.95 52.13,117.76 51.56,117.76 v8(51.25,117.45)
FB_A_D37: length 16.6
  IN1 w0.086: v8(51.95,117.45) 52.36,117.45 53.05,118.14 53.05,120.2 58.12,125.27 58.12,128.98 57.35,129.76 56.76,129.76 v8(56.37,129.38)
FB_A_D38: length 18.9
  IN1 w0.086: v8(56.37,130.13) 56.77,130.52 57.28,130.52 58.37,129.43 58.37,125.07 53.66,120.36 53.66,118.01 53.46,117.82 53.22,117.82 52.48,117.08 51.83,117.08 51.5,116.75 v8(51.25,116.75)
FB_A_D39: length 22.5
  IN1 w0.086: v8(49.85,116.75) 50.2,116.39 52.74,116.39 52.96,116.62 52.96,116.91 53.17,117.12 53.46,117.12 53.65,117.31 53.65,117.55 53.87,117.77 54.11,117.77 54.36,118.01 54.36,120.61 58.66,124.91 58.66,130.34 57.78,131.22 56.72,131.22 v8(56.37,130.88)
FB_A_D40: length 16.5
  IN1 w0.086: v8(48.88,129.38) 48.96,129.38 49.4,129.82 50.55,129.82 50.8,129.57 50.8,122.77 49.53,121.5 49.53,117.95 49.59,117.89 49.59,117.12 49.49,117.03 49.49,116.39 v8(49.15,116.05)
FB_A_D41: length 11.5
  IN1 w0.086: v8(47.75,116.75) 47.75,117 47.18,117.57 46.93,117.57 46.75,117.74 46.75,124.5 47.87,125.62 47.87,126.87 v8(48.13,127.13)
FB_A_D42: length 17.6
  IN1 w0.086: v8(47.75,115.35) 47.41,115.69 46.84,115.69 46.67,115.85 46.67,116.83 45.76,117.74 45.76,128.85 46.74,129.82 47.82,129.82 v8(48.13,130.13)
FB_A_D43: length 15.6
  IN1 w0.086: v8(47.75,116.05) 47.43,116.36 47.43,116.9 47.12,117.22 46.79,117.22 46.08,117.93 46.08,128.08 46.93,128.93 47.88,128.93 48.13,129.18 v8(48.13,129.38)
FB_A_D44: length 19.2
  IN1 w0.086: v8(48.13,130.88) 47.77,130.52 46.74,130.52 45.44,129.23 45.44,117.55 46.06,116.93 46.06,116.06 46.62,115.49 46.62,115.2 46.82,115 47.4,115 v8(47.75,114.65)
FB_A_D45: length 9.6
  IN1 w0.086: v8(49.15,118.15) 49.15,118.24 48.77,118.63 48.77,121.69 49.34,122.27 49.34,126.66 v8(48.88,127.13)
FB_A_D46: length 8.9
  IN1 w0.086: v8(49.15,118.85) 49.15,121.63 49.98,122.46 49.98,126.96 49.81,127.13 v8(49.63,127.13)
FB_A_D47: length 10.6
  IN1 w0.086: v8(48.88,126.38) 48.91,126.35 48.91,122.4 48.31,121.81 48.31,118.67 48.83,118.15 48.83,117.97 48.98,117.82 49.23,117.82 49.41,117.63 49.41,117.32 49.15,117.06 v8(49.15,116.75)
FB_A_D48: length 26.4
  TOP w0.089: UG1.AJ48 42.85,116.11 v3(43.18,116.44)
  IN4 w0.086: v6(48.13,138.37) 47.87,138.63 46.15,138.63 45.42,137.9 45.42,124.03 42.78,121.4 42.78,116.83 v3(43.18,116.44)
FB_A_D49: length 32
  IN4 w0.086: v6(49.63,138.37) 49.28,138.72 49.28,139.47 48.55,140.2 46.32,140.2 44.38,138.26 44.38,124.42 42.2,122.25 42.2,115.29 42.85,114.65 v3(42.85,114.65)
FB_A_D50: length 29
  TOP w0.089: UG1.AJ47 42.87,115.35 v3(43.18,115.66)
  IN4 w0.086: v6(48.88,139.12) 48.53,139.47 47.28,139.47 47.24,139.44 47.02,139.44 46.7,139.12 45.63,139.12 44.67,138.15 44.67,124.3 42.49,122.13 42.49,116.35 v3(43.18,115.66)
FB_A_D51: length 24.9
  TOP w0.089: UG1.AK49 v3(43.25,117.05)
  IN4 w0.086: v3(43.25,117.05) 43.49,117.28 43.49,121.69 45.7,123.91 45.7,136.66 47.05,138.01 48.52,138.01 v6(48.88,138.37)
FB_A_D52: length 22.9
  TOP w0.089: UG1.AM47 v3(44.62,115.68)
  IN4 w0.086: v3(44.62,115.68) 44.95,116 44.95,117.13 44.6,117.48 44.6,121.58 46.57,123.55 46.57,135.06 47.18,135.66 47.67,135.66 v6(48.13,136.12)
FB_A_D53: length 24.8
  TOP w0.089: v3(44.56,114.32) 44.93,114.57 UG1.AM46
  IN4 w0.086: v3(44.56,114.32) 44.59,114.35 44.67,114.35 45.96,115.65 45.96,117.07 45.47,117.56 45.47,121.22 49.14,124.89 49.14,135.61 48.88,135.87 v6(48.88,136.12)
FB_A_D54: length 21.1
  TOP w0.089: UG1.AN48 v3(45.31,115.69)
  IN4 w0.086: v6(48.13,134.62) 48.13,134.39 47.75,134.01 47.75,123.91 45.18,121.34 45.18,117.54 45.79,116.93 45.79,116.17 v3(45.31,115.69)
FB_A_D55: length 21.2
  TOP w0.089: UG1.AN49 v3(45.3,116.45)
  IN4 w0.086: v3(45.3,116.45) 45.3,117.16 44.89,117.58 44.89,121.46 46.86,123.43 46.86,134.58 47.24,134.97 47.72,134.97 v6(48.13,135.37)
FB_A_D56: length 31
  IN4 w0.086: v6(56.37,135.37) 56.72,135.03 57.15,135.03 57.59,134.58 57.59,125 48.73,116.13 48.73,113.16 48.09,112.52 46.04,112.52 45.31,113.25 v3(44.95,113.25)
FB_A_D57: length 29
  IN4 w0.086: v3(44.95,113.95) 45.12,113.95 46.24,112.83 47.88,112.83 48.41,113.36 48.41,116.23 56.63,124.45 56.63,130.19 56.77,130.33 56.77,134.23 v6(56.37,134.62)
FB_A_D58: length 27.4
  IN4 w0.086: v3(45.65,113.95) 45.98,114.28 47.27,114.28 48.15,115.15 48.15,116.37 55.94,124.17 55.94,135.69 v6(56.37,136.12)
FB_A_D59: length 31.3
  TOP w0.089: UG1.AN46 45.6,114.65 v3(45.36,114.4)
  IN4 w0.086: v6(55.62,139.12) 55.21,139.54 53.85,139.54 52.24,137.93 52.24,128.47 51.4,127.63 51.4,124.98 45.78,119.37 45.78,117.69 46.14,117.34 46.14,115.57 45.49,114.93 45.49,114.53 v3(45.36,114.4)
FB_A_D60: length 27.6
  IN4 w0.086: v6(56.37,138.37) 55.95,137.95 55.44,137.95 55.31,137.82 55.31,137.51 55.05,137.25 53.63,137.25 53.16,136.78 53.16,127.78 52.53,127.14 52.53,124.88 46.67,119.03 46.67,116.42 46.86,116.23 46.87,116.23 v3(47.05,116.05)
FB_A_D61: length 30.1
  TOP w0.089: UG1.AN47 45.97,115.02 v3(45.97,114.94)
  IN4 w0.086: v3(45.97,114.94) 46.03,114.94 46.31,115.22 46.31,117.48 46.04,117.76 46.04,119.21 51.71,124.89 51.71,127.5 52.51,128.3 52.51,137.82 53.47,138.78 55.22,138.78 v6(55.62,138.37)
FB_A_D62: length 27.4
  IN4 w0.086: v6(54.87,138.37) 54.51,138.01 53.53,138.01 52.86,137.34 52.86,128.01 52.1,127.24 52.1,124.86 46.35,119.12 46.35,117.76 46.49,117.62 46.49,115.91 v6(47.05,115.35)
FB_A_D63: length 25
  IN4 w0.086: v3(47.05,114.65) 47.51,115.11 47.51,116.14 55.31,123.94 55.31,135.81 v6(55.62,136.12)
FB_A_DBI0: length 24.9
  IN1 w0.086: v8(30.53,136.87) 30.23,136.87 29.9,136.55 29.59,136.55 28.83,135.8 28.83,126.51 33.83,121.51 33.83,118.57 34.01,118.39 34.01,118.19 34.01,118.19 34.01,116.24 34.01,115.79 v8(34.45,115.35)
FB_A_DBI1: length 24.1
  IN1 w0.086: v8(36.55,116.05) 36.55,116.99 37.64,118.08 37.64,122.76 40.39,125.5 40.39,131.88 39.81,132.45 38.8,132.45 38.23,133.02 38.23,134.02 38.5,134.29 38.5,136.24 38.77,136.51 v8(38.77,136.87)
FB_A_DBI2: length 14.9
  IN4 w0.086: v6(38.77,128.63) 39.03,128.37 39.93,128.37 40.68,127.62 40.68,116.9 41.05,116.53 41.05,115.75 v6(41.45,115.35)
FB_A_DBI3: length 17.9
  TOP w0.089: UG1.AC48 37.98,116.05 v3(37.97,116.04)
  IN4 w0.086: v3(37.97,116.04) 36.69,117.33 36.69,123.18 34.08,125.79 34.08,127.8 33.62,128.26 30.89,128.26 v6(30.53,128.63)
FB_A_DBI4: length 13.6
  IN1 w0.086: v8(56.37,128.63) 56.7,128.63 57.02,128.3 57.32,128.3 57.47,128.15 57.47,125.5 52.35,120.39 52.35,118.65 51.95,118.24 v8(51.95,118.15)
FB_A_DBI5: length 12.3
  IN1 w0.086: v8(49.15,117.45) 48.73,117.45 48.02,118.16 48.02,121.93 48.62,122.52 48.62,128.14 v8(48.13,128.63)
FB_A_DBI6: length 23.3
  TOP w0.089: v3(44.57,116.29) 44.57,116.27 UG1.AM48
  IN4 w0.086: v3(44.57,116.29) 44.07,116.79 44.07,121.46 46.28,123.67 46.28,135.59 47.18,136.49 47.74,136.49 v6(48.13,136.87)
FB_A_DBI7: length 24.6
  IN4 w0.086: v3(47.05,116.75) 54.48,124.18 54.48,136.1 54.92,136.53 56.03,136.53 v6(56.37,136.87)
FB_A_DEBUG0: length 10.9
  TOP w0.081: 31.59,121.16 30.56,122.19 v2(29.76,122.19) RG1478.1
  TOP w0.089: 31.59,121.16 34.3,118.45 34.57,118.45 34.75,118.27 34.75,118.13 35.03,117.85 36.15,117.85 UG1.Y50
FB_A_DEBUG1: length 14.1
  TOP w0.081: 52.88,119.16 53.17,119.44 54.82,119.44 57.5,122.13 v10(57.51,122.13) RG1476.1
  TOP w0.089: 52.88,119.16 52.32,118.6 52.32,117.96 52.17,117.81 47.5,117.81 47.14,117.45 UG1.AR50
FB_A_EDC0: length 25
  IN1 w0.086: v8(33.05,116.05) 33.21,116.05 33.49,116.33 33.49,121.4 28.52,126.37 28.52,136.14 29.66,137.28 30.19,137.28 v8(30.53,137.62)
FB_A_EDC1: length 24.5
  IN1 w0.086: v8(35.15,116.05) 35.58,116.05 36.2,116.66 36.2,117.04 37.26,118.11 37.26,122.78 36.47,123.58 35.97,124.08 35.97,133.41 37.69,135.13 37.69,135.55 37.78,135.64 37.97,135.64 38.3,135.97 38.3,136.59 38.4,136.69 38.4,137.25 v8(38.77,137.62)
FB_A_EDC2: length 16
  IN4 w0.086: v3(40.75,113.25) 40.79,113.29 40.79,116.53 40.39,116.93 40.39,127.15 40.07,127.47 39.18,127.47 v6(38.77,127.88)
FB_A_EDC3: length 16
  IN4 w0.086: v6(30.53,127.88) 30.87,127.53 33.28,127.53 33.78,127.03 33.78,125.53 36.4,122.91 36.4,116.9 v3(37.25,116.05)
FB_A_EDC4: length 11.1
  IN1 w0.086: v8(56.37,127.88) 56.7,127.55 56.7,125.2 51.95,120.45 v8(51.95,118.85)
FB_A_EDC5: length 11
  IN1 w0.086: v8(48.13,127.88) 48.39,127.61 48.39,124.31 47.48,123.39 47.48,117.98 47.75,117.71 v8(47.75,117.45)
FB_A_EDC6: length 23.7
  IN4 w0.086: v3(43.55,116.05) 43.55,116.79 43.78,117.02 43.78,121.57 45.99,123.79 45.99,135.65 46.8,136.46 46.8,136.68 47.38,137.26 47.77,137.26 v6(48.13,137.62)
FB_A_EDC7: length 24.9
  IN4 w0.086: v3(47.05,118.15) 47.7,118.15 53.48,123.93 53.48,136.75 53.81,137.08 55.32,137.08 55.37,137.13 55.88,137.13 v6(56.37,137.62)
FB_A_WCK01: length 30.7
  IN2 w0.084: v3(34.45,113.95) 34.45,113.71 34.53,113.63 34.71,113.63 34.86,113.78 34.86,115.01 34.58,115.3 34.58,118.2 34.58,118.2 34.58,118.21 34.58,118.77 27.86,125.48 27.86,135.1 27.86,135.27 28.51,135.92 30.35,135.92 30.76,136.32 32.16,136.32 32.32,136.48 32.32,136.69 32.14,136.87 v3(32.03,136.87)
FB_A_WCK23: length 17.9
  TOP w0.089: 38.72,113.85 UG1.AC45
  TOP w0.099: 38.72,113.85 38.93,113.59 v3(39.07,113.58)
  IN2 w0.084: v3(37.27,128.63) 37,128.63 36.58,128.21 36.35,128.21 36.1,127.96 36.1,125.98 36.35,125.73 36.35,125.03 36.35,125.03 36.35,122.17 38.56,119.97 38.56,115.74 38.32,115.5 38.32,114.51 38.94,113.89 38.94,113.7 v3(39.07,113.58)
FB_A_WCK45: length 20.5
  IN2 w0.084: v3(54.87,128.63) 54.87,128.45 54.79,128.36 54.55,128.36 54.47,128.45 54.47,128.87 54.79,129.19 55.63,129.19 55.99,128.82 55.99,127.27 55.31,126.58 55.31,121.14 51.88,117.7 51.88,116.66 50.19,114.98 49.3,114.98 49.15,115.13 v3(49.15,115.35)
FB_A_WCK67: length 33
  TOP w0.089: UG1.AR45 47.05,113.9 47.09,113.85
  TOP w0.099: 47.09,113.85 v3(47.35,113.6) ; UG12.R11 v3(49.91,136.55)
  IN2 w0.084: v3(47.35,113.6) 47.21,113.74 47.21,113.99 46.67,114.52 46.67,117.06 45.92,117.81 45.92,121.45 46.67,122.2 46.67,130.77 47.12,131.22 47.56,131.22 47.75,131.03 48.4,131.03 48.84,131.47 51.22,131.47 52.02,132.27 52.02,136.92 51.31,137.63 50.26,137.63 49.99,137.36 49.99,136.63 v3(49.91,136.55)
FB_A_WCK#01: length 30.7
  IN2 w0.084: v3(32.78,136.87) 32.52,136.62 32.52,136.4 32.25,136.12 30.84,136.12 30.44,135.71 28.6,135.71 28.07,135.18 28.07,125.57 34.78,118.85 34.78,118.21 34.78,118.2 34.78,115.38 35.06,115.1 35.06,113.69 34.8,113.43 34.63,113.43 v3(34.45,113.25)
FB_A_WCK#23: length 17.9
  TOP w0.099: UG1.AC44 38.74,113.34 38.74,113.48 38.64,113.58 v3(38.38,113.58)
  IN2 w0.084: v3(38.38,113.58) 38.38,113.56 38.47,113.47 38.59,113.47 38.74,113.62 38.74,113.8 38.11,114.43 38.11,115.58 38.35,115.82 38.35,119.88 36.15,122.09 36.15,125.11 36.15,125.11 36.15,125.64 35.89,125.9 35.89,128.04 36.26,128.41 36.45,128.41 36.53,128.5 36.53,128.62 v3(36.52,128.63)
FB_A_WCK#45: length 20.5
  IN2 w0.084: v3(49.15,114.65) 49.27,114.77 49.28,114.77 50.27,114.77 52.08,116.58 52.08,117.62 55.51,121.05 55.51,126.5 56.2,127.18 56.2,128.9 55.71,129.39 54.7,129.39 54.27,128.95 54.27,128.77 v3(54.12,128.63)
FB_A_WCK#67: length 33
  TOP w0.099: UG12.R10 50.61,136.61 50.61,136.61 v3(50.65,136.55) ; v3(46.67,113.6) 46.94,113.6 47.05,113.49 UG1.AR44
  IN2 w0.084: v3(50.65,136.55) 50.48,136.55 50.19,136.85 50.19,137.27 50.34,137.42 51.23,137.42 51.81,136.84 51.81,132.35 51.13,131.67 48.75,131.67 48.32,131.23 47.84,131.23 47.65,131.42 47.03,131.42 46.47,130.86 46.47,122.29 45.72,121.54 45.72,117.72 46.47,116.97 46.47,114.43 47,113.9 47,113.69 46.92,113.6 v3(46.67,113.6)
FB_A_WCKB01: length 40.1
  TOP w0.089: UG1.V45 v3(35.53,114.23)
  IN2 w0.084: v3(37.27,136.87) 37.05,137.1 37.05,137.32 36.72,137.65 34.91,137.65 31.55,134.29 29.1,134.29 28.56,133.75 28.56,126.68 29.95,125.28 29.96,125.28 31.11,124.13 31.4,124.13 31.96,124.69 32.08,124.69 32.25,124.51 32.25,124.39 31.7,123.83 31.7,123.55 31.99,123.25 32.28,123.25 32.84,123.81 32.96,123.81 33.14,123.63 33.14,123.51 32.58,122.95 32.58,122.66 32.87,122.37 33.16,122.37 33.72,122.93 33.84,122.93 34.02,122.75 34.02,122.63 33.46,122.07 33.46,121.78 36.14,119.1 36.14,114.33 35.85,114.03 35.73,114.03 v3(35.53,114.23)
FB_A_WCKB23: length 30
  TOP w0.089: v3(39.71,114.42) 39.48,114.65 UG1.AD46
  IN2 w0.084: v3(39.71,114.42) 39.56,114.26 39.28,114.26 39.19,114.35 39.19,115.66 39.88,116.35 39.88,120.42 41.36,121.9 41.36,130.98 40.09,132.24 38.46,132.24 35.23,129.01 32.68,129.01 32.29,128.63 v3(32.03,128.63)
FB_A_WCKB45: length 15.4
  IN2 w0.084: v3(49.85,116.05) 49.92,115.98 50.33,115.98 50.84,116.49 50.84,117.78 52.18,119.13 52.18,126.75 50.7,128.23 50.24,128.23 49.85,128.63 v3(49.63,128.63)
FB_A_WCKB67: length 30
  TOP w0.099: UG12.R4 54.5,136.56 54.44,136.57 v3(54.43,136.57)
  IN2 w0.084: v3(47.75,113.95) 47.79,113.91 48.19,113.91 48.27,113.99 48.27,124.88 49.05,125.66 49.05,126.43 48.25,127.23 48.25,129.68 49.49,130.92 51.57,130.92 52.97,132.33 52.97,137.05 53.17,137.25 54.09,137.25 54.34,137 54.34,136.66 v3(54.43,136.57)
FB_A_WCKB#01: length 40
  TOP w0.099: UG1.V44 v3(35.53,113.53)
  IN2 w0.084: v3(35.53,113.53) 35.53,113.73 35.62,113.82 35.92,113.82 36.35,114.25 36.35,119.18 33.66,121.87 33.66,121.99 34.22,122.54 34.22,122.83 33.92,123.13 33.63,123.13 33.08,122.57 32.96,122.57 32.78,122.75 32.78,122.87 33.34,123.43 33.34,123.71 33.04,124.01 32.75,124.01 32.2,123.45 32.08,123.45 31.9,123.63 31.9,123.75 32.46,124.31 32.46,124.59 32.16,124.89 31.87,124.89 31.31,124.33 31.2,124.33 30.04,125.49 30.04,125.49 28.77,126.76 28.77,133.66 29.19,134.08 31.63,134.08 34.99,137.45 36.63,137.45 36.84,137.24 36.84,137.01 36.71,136.87 v3(36.52,136.87)
FB_A_WCKB#23: length 30
  TOP w0.089: 39.71,113.85 39.71,113.86 39.62,113.95 UG1.AD45
  TOP w0.099: 39.71,113.85 v3(39.71,113.68)
  IN2 w0.084: v3(39.71,113.68) 39.85,113.68 39.93,113.76 39.93,113.96 39.83,114.06 39.19,114.06 38.99,114.26 38.99,115.75 39.67,116.43 39.67,120.51 41.15,121.99 41.15,130.9 40.01,132.04 38.54,132.04 35.31,128.81 32.86,128.81 32.78,128.72 v3(32.78,128.63)
FB_A_WCKB#45: length 15.4
  IN2 w0.084: v3(49.85,115.35) 50.28,115.78 50.41,115.78 51.04,116.4 51.04,117.7 52.39,119.04 52.39,126.84 50.79,128.44 50.52,128.44 50.38,128.58 v3(50.38,128.63)
FB_A_WCKB#67: length 30.1
  TOP w0.099: UG12.R5 53.86,136.57 53.85,136.57 v3(53.85,136.57)
  IN2 w0.084: v3(47.75,113.25) 47.7,113.3 47.7,113.51 47.78,113.6 47.89,113.6 48,113.71 48.27,113.71 48.47,113.91 48.47,124.79 49.25,125.57 49.25,126.52 48.45,127.32 48.45,129.6 49.57,130.72 51.65,130.72 53.17,132.24 53.17,136.96 53.26,137.05 54,137.05 54.14,136.91 54.14,136.73 53.98,136.57 v3(53.85,136.57)
FB_B_CLK0: length 23.3
  TOP w0.099: v3(28.47,112.16) 28.46,112.16 UG1.H42
  IN2 w0.084: v3(8.88,113.83) 8.98,113.94 8.98,113.95 8.98,114.92 9.8,115.74 10.71,115.74 10.96,115.99 14.82,115.99 15.07,115.74 21.25,115.74 21.42,115.74 24.28,112.88 28.11,112.88 28.37,112.61 28.37,112.25 28.46,112.16 v3(28.47,112.16)
FB_B_CLK1: length 26.8
  IN2 w0.084: v3(9.62,127.17) 9.48,127.17 9.31,127.33 9.31,127.55 9.44,127.68 9.87,127.68 10.07,127.47 10.07,126.97 9.66,126.57 9.66,125.62 ; 9.66,124.89 9.66,123.84 11.24,122.27 16.95,122.27 24.78,114.44 26.08,114.44 26.54,114.9 26.54,115.14 v3(26.75,115.35)
  IN2 w0.089: 9.66,124.89 9.66,125.62
FB_B_CLK#0: length 23.2
  TOP w0.089: UG1.G42 27.75,112.15 v3(27.75,112.17)
  IN2 w0.084: v3(9.62,113.83) 9.56,113.77 9.41,113.77 9.18,114 9.18,114.84 9.88,115.53 10.79,115.53 11.05,115.79 14.73,115.79 14.99,115.53 21.34,115.53 24.19,112.68 28.02,112.68 28.17,112.53 28.17,112.37 27.96,112.17 27.75,112.17 v3(27.75,112.17)
FB_B_CLK#1: length 26.8
  IN2 w0.084: 9.87,125.62 9.87,126.48 10.27,126.89 10.27,127.56 9.95,127.88 9.35,127.88 9.11,127.63 9.11,127.4 v3(8.88,127.17) ; v3(26.05,115.35) 26.19,115.35 26.34,115.21 26.34,114.99 26,114.65 24.86,114.65 17.03,122.47 11.32,122.47 9.87,123.93 9.87,124.89
  IN2 w0.089: 9.87,125.62 9.87,124.89
FB_B_CMD0: length 18.7
  TOP w0.089: 21.13,105.89 23.16,105.89 23.95,106.68 UG1.B35
  TOP w0.099: 21.13,105.89 v2(18.48,105.89) 18.39,105.8 9.03,105.8 8.51,106.33 8.51,108.2 UG13.H3
FB_B_CMD1: length 18
  TOP w0.081: UG13.K3 9.31,108.27 9.19,108.27 UG13.J3
  TOP w0.089: 21.13,106.58 22.88,106.58 UG1.A35
  TOP w0.099: 9.23,108.27 9.23,106.94 9.54,106.63 15.73,106.63 16.35,107.25 17.34,108.24 18.65,108.24 v2(19.15,107.74) 20.31,106.58 21.13,106.58
FB_B_CMD2: length 19
  TOP w0.089: UG1.D35 25.05,107.25 23.82,107.25 23.55,106.98 23.55,106.76 23.07,106.28 21.13,106.28
  TOP w0.099: 21.13,106.28 v2(20.18,106.28) 19.7,106.28 18.16,107.81 RG1485.2 16.13,106.25 9.34,106.25 8.88,106.71 UG13.J1
FB_B_CMD3: length 16.7
  TOP w0.081: UG13.J4 9.1,109.11 9.21,109.11 9.25,109.07 9.52,109.34 UG13.K4
  TOP w0.089: 21.13,106.91 21.15,106.9 22.5,106.9 UG1.A36
  TOP w0.099: 21.13,106.91 20.46,106.91 18.83,108.54 16.12,108.54 15.81,108.23 10.15,108.23 10.01,108.37 10.01,108.76 9.83,108.94 9.38,108.94 9.25,109.07
FB_B_CMD4: length 14.9
  TOP w0.089: UG1.B36 23.77,107.65 23.42,108.01 23.17,108.01 22.38,107.22 21.27,107.22 21.13,107.36
  TOP w0.099: 21.13,107.36 20.57,107.36 19,108.93 v2(17.86,108.93) 10.72,108.93 UG13.L3
FB_B_CMD5: length 15.1
  TOP w0.089: 21.13,107.84 21.16,107.84 21.44,107.56 22.34,107.56 23.05,108.27 23.53,108.27 23.85,107.95 24.35,107.95 UG1.C36
  TOP w0.099: UG13.M4 11.5,109.71 18.65,109.71 20.52,107.84 21.13,107.84
FB_B_CMD6: length 18.7
  TOP w0.081: UG13.J5 9.17,109.79 ; 9.21,109.79 9.5,110.09 UG13.K5
  TOP w0.089: UG1.C38 24.28,108.68 23.86,108.68 23.69,108.51 22.96,108.51 22.31,107.86 21.53,107.86 21.13,108.26
  TOP w0.099: 9.17,109.79 9.21,109.79 9.3,109.7 10.6,109.7 10.73,109.83 10.73,110.26 11.02,110.56 16.46,110.56 17,110.01 18.77,110.01 20.52,108.26 v2(20.94,108.26) 21.13,108.26
FB_B_CMD7: length 19.1
  TOP w0.081: UG13.L5 9.96,110.5 8.54,110.5 UG13.H5
  TOP w0.089: UG1.B38 23.79,109.05 23.48,108.74 22.89,108.74 22.38,108.23 21.59,108.23 21.13,108.69
  TOP w0.099: 9.12,110.5 9.12,110.65 9.35,110.88 17.46,110.88 v2(17.67,110.67) 17.75,110.58 18.63,110.58 20.52,108.69 21.13,108.69
FB_B_CMD8: length 19
  TOP w0.089: UG1.A38 22.83,109.05 22.36,108.58 21.67,108.58 21.13,109.12
  TOP w0.099: 21.13,109.12 20.59,109.12 v2(19.46,110.25) 18.51,111.2 7.99,111.2 6.99,110.19 6.99,109.73 UG13.G4
FB_B_CMD9: length 21.8
  TOP w0.089: UG1.D38 25.05,109.35 22.76,109.35 22.37,108.97 21.71,108.97 21.13,109.55
  TOP w0.099: 21.13,109.55 20.63,109.55 18.67,111.5 8.91,111.5 7.01,113.4 7.01,114.22 UG13.G11
FB_B_CMD10: length 20.6
  TOP w0.081: UG13.M10 10.72,114.23 9.72,114.23 9.68,114.2 v8(9.27,114.2) 9.13,114.2 9.09,114.23 7.78,114.23 UG13.G10
  TOP w0.089: 21.13,109.97 21.64,109.46 22.5,109.46 22.79,109.75 UG1.A39
  TOP w0.099: v8(9.94,112.84) 16.85,112.84 RG1483.2 v2(18.68,111.97) 18.9,111.97 20.89,109.97 21.13,109.97
  IN1 w0.071: v8(9.27,114.2) 9.27,113.5 v8(9.94,112.84)
FB_B_CMD11: length 19.6
  TOP w0.081: UG13.L10 10.02,113.48 8.48,113.48 UG13.H10
  TOP w0.089: UG1.B39 23.74,109.75 23.44,110.05 22.72,110.05 22.46,109.78 21.75,109.78 21.19,110.34 21.13,110.34
  TOP w0.099: 21.13,110.34 v2(21.06,110.34) 20.99,110.34 17.61,113.72 16.73,113.72 16.14,113.12 9.45,113.12 9.22,113.35 9.22,113.48
FB_B_CMD12: length 16.6
  TOP w0.089: 21.13,110.83 21.86,110.1 22.42,110.1 22.62,110.3 23.61,110.3 23.81,110.1 24.3,110.1 UG1.C39
  TOP w0.099: UG13.M11 11.48,114.23 11.48,113.7 11.77,113.4 15.99,113.4 16.66,114.07 v2(17.64,114.07) 17.69,114.07 20.93,110.83 21.13,110.83
