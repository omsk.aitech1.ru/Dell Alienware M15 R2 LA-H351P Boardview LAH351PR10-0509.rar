# Allegro board LAH351PR10-0509.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
NCP45491XMNTWG_QFN32_4X4
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.15,-2.8) 18(4.15,-2.4) 19(4.15,-2) 20(4.15,-1.6) 21(4.15,-1.2) 22(4.15,-0.8) 23(4.15,-0.4) 24(4.15,0)
  oval 0.254x0.889 smd: 9(0.675,-3.475) 10(1.075,-3.475) 11(1.475,-3.475) 12(1.875,-3.475) 13(2.275,-3.475) 14(2.675,-3.475) 15(3.075,-3.475) 16(3.475,-3.475) 25(3.475,0.675) 26(3.075,0.675) 27(2.675,0.675) 28(2.275,0.675) 29(1.875,0.675) 30(1.475,0.675) 31(1.075,0.675) 32(0.675,0.675)
  rect 2.692x2.692 smd: 33(2.075,-1.4)
NCP81162MNR2G_QFN16_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.397x1.397 smd: 17(1.55,-0.75)
NCP81215DMNTXG_QFN52_6X6
  oval 0.838x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 27(6.15,-4.8) 28(6.15,-4.4) 29(6.15,-4) 30(6.15,-3.6) 31(6.15,-3.2) 32(6.15,-2.8) 33(6.15,-2.4) 34(6.15,-2) 35(6.15,-1.6) 36(6.15,-1.2) 37(6.15,-0.8) 38(6.15,-0.4) 39(6.15,0)
  oval 0.203x0.838 smd: 14(0.675,-5.475) 15(1.075,-5.475) 16(1.475,-5.475) 17(1.875,-5.475) 18(2.275,-5.475) 19(2.675,-5.475) 20(3.075,-5.475) 21(3.475,-5.475) 22(3.875,-5.475) 23(4.275,-5.475) 24(4.675,-5.475) 25(5.075,-5.475) 26(5.475,-5.475) 40(5.475,0.675) 41(5.075,0.675) 42(4.675,0.675) 43(4.275,0.675) 44(3.875,0.675) 45(3.475,0.675) 46(3.075,0.675) 47(2.675,0.675) 48(2.275,0.675) 49(1.875,0.675) 50(1.475,0.675) 51(1.075,0.675) 52(0.675,0.675)
  rect 4.699x4.699 smd: 53(3.075,-2.4)
NCP302045MNTXG_PQFN33_5X5
  oval 0.305x0.711 smd: 1(0,-0.051) 2(0.5,-0.051) 3(1,-0.051) 4(1.5,-0.051) 5(2,-0.051) 6(2.5,-0.051) 7(3,-0.051) 8(3.5,-0.051)
  custom 0.32x0.32 smd: 9(3.135,1.215)
  custom 0.543x0.543 smd: 10(2.225,3.215)
  rect 3.81x0.711 smd: 11(1.75,4.851)
  rect 0.711x1.295 smd: 12(-0.701,3.65)
  oval 0.711x0.305 smd: 13(-0.701,2.65) 14(-0.701,2.15) 15(-0.701,1.65) 16(-0.701,1.15) 17(-0.701,0.65)
  rect 1.422x1.118 smd: 18(0.7,1.215)
  rect 0.584x0.356 smd: 19(0.09,2.625)
NL17SZ08DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
OCTEK_WTB-10FPBLAB-U_10P
  oval 0.787x1.499 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0) 5(-5,0) 6(-6.25,0) 7(-7.5,0) 8(-8.75,0) 9(-10,0) 10(-11.25,0)
  oval 1.041x1.6 hole 0.66x1.194: 11(-13,-2.95) 12(-13,-6.425) 13(1.75,-2.95) 14(1.75,-6.425)
OCTEK_WTB-12GCBWAB-U_12P
  oval 0.787x1.499 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0) 5(-5,0) 6(-6.25,0) 7(-7.5,0) 8(-8.75,0) 9(-10,0) 10(-11.25,0) 11(-12.5,0) 12(-13.75,0)
  oval 1.041x1.651 hole 0.66x1.245: 13(1.75,-2.95) 14(1.75,-6.425) 15(-15.5,-2.95) 16(-15.5,-6.425)
PESD5V0H1BSF_SOD962-2-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.4,0)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI6CEQ20200LIEX_TSSOP20
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(5.85,5.8) 12(5.2,5.8) 13(4.55,5.8) 14(3.9,5.8) 15(3.25,5.8) 16(2.6,5.8) 17(1.95,5.8) 18(1.3,5.8) 19(0.65,5.8) 20(0,5.8)
Q_N_DFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
R0402_0OHM
  custom 0.14x0.14 smd: 1(0,0)
  rect 0.508x0.559 smd: 2(0.914,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402-NPM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RL-3264-9W-R005-FNH_2512_2512
  rect 2.108x2.489 smd: 1(0,0) 4(1.35,-4.3)
  rect 1.041x2.489 smd: 2(1.875,0) 3(-0.525,-4.3)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207PGQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9059GSP_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.157) 6(2.54,5.157) 7(1.27,5.157) 8(0,5.157)
  rect 2.311x2.311 smd: 9(1.905,2.579)
RT9297GQW_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI2301CDS-T1-GE3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SI3457CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SN74CBT3257CPWR_TSSOP16
  oval 0.381x1.651 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(4.55,5.775) 10(3.9,5.775) 11(3.25,5.775) 12(2.6,5.775) 13(1.95,5.775) 14(1.3,5.775) 15(0.65,5.775) 16(0,5.775)
STARC_106A08-001020-A2-R_8P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  rect 0.406x1.194 smd: 9(-1,-2.85) 10(4.5,-2.85)
STM32F070CBT6TR_LQFP48_7X7
  oval 1.753x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 9(0,-4) 10(0,-4.5) 11(0,-5) 12(0,-5.5) 25(8.654,-5.5) 26(8.654,-5) 27(8.654,-4.5) 28(8.654,-4) 29(8.654,-3.5) 30(8.654,-3) 31(8.654,-2.5) 32(8.654,-2) 33(8.654,-1.5) 34(8.654,-1) 35(8.654,-0.5) 36(8.654,0)
  oval 0.254x1.753 smd: 13(1.577,-7.077) 14(2.077,-7.077) 15(2.577,-7.077) 16(3.077,-7.077) 17(3.577,-7.077) 18(4.077,-7.077) 19(4.577,-7.077) 20(5.077,-7.077) 21(5.577,-7.077) 22(6.077,-7.077) 23(6.577,-7.077) 24(7.077,-7.077) 37(7.077,1.577) 38(6.577,1.577) 39(6.077,1.577) 40(5.577,1.577) 41(5.077,1.577) 42(4.577,1.577) 43(4.077,1.577) 44(3.577,1.577) 45(3.077,1.577) 46(2.577,1.577) 47(2.077,1.577) 48(1.577,1.577)
SW_TST71-N-220-T170-S017_2P
  rect 0.61x1.499 smd: 1(0,0) 2(3.2,0)
SX34F_SMAF2
  rect 1.6x1.905 smd: 1(0,0) 2(4.3,0)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8270CTMC_QFN13_4X3
  custom 0.337x0.337 smd: 1(0,0)
  rect 0.457x1.702 smd: 2(1.18,-0.75) 12(1.18,1.25)
  rect 0.838x1.702 smd: 3(2.06,-0.75) 11(2.06,1.25)
  oval 0.203x0.787 smd: 4(2.81,-1.2) 10(2.81,1.7)
  oval 0.787x0.254 smd: 5(3.625,-0.65) 6(3.625,-0.2) 7(3.625,0.25) 8(3.625,0.7) 9(3.625,1.15)
  oval 0.254x0.787 smd: 13(0.55,1.7)
SY8386RHC_QFN16_2P5X2P5
  custom 0.064x0.064 smd: 1(0,0) 4(0,-1.35) 5(0.625,-1.975) 8(1.975,-1.975) 9(2.6,-1.35) 12(2.6,0) 13(1.975,0.625) 16(0.625,0.625)
  oval 0.889x0.254 smd: 2(0,-0.45) 3(0,-0.9) 10(2.6,-0.9) 11(2.6,-0.45)
  oval 0.254x0.889 smd: 6(1.075,-1.975) 7(1.525,-1.975) 14(1.525,0.625) 15(1.075,0.625)
  rect 0.61x0.61 smd: 17(1.3,-0.675)
SY8388BRHC_QFN16_2P5X2P5
  custom 0.064x0.064 smd: 1(0,0) 4(0,-1.35) 5(0.625,-1.975) 8(1.975,-1.975) 9(2.6,-1.35) 12(2.6,0) 13(1.975,0.625) 16(0.625,0.625)
  oval 0.889x0.254 smd: 2(0,-0.45) 3(0,-0.9) 10(2.6,-0.9) 11(2.6,-0.45)
  oval 0.254x0.889 smd: 6(1.075,-1.975) 7(1.525,-1.975) 14(1.525,0.625) 15(1.075,0.625)
  rect 0.61x0.61 smd: 17(1.3,-0.675)
TAI-T_TMPA0624S-R15MNR8805D_4P
  custom 0.54x0.54 smd: 1(0,0) 4(5.85,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(5.151,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SZ14FU_SSOP5
  oval 0.381x1.448 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.675) 5(0,1.675)
TE_2260531-1_46P
  oval 0.508x1.803 smd: 1(0,0) 2(0.8,0) 45(18.6,0) 46(19.4,0)
  oval 0.203x1.803 smd: 3(1.55,0) 4(1.95,0) 5(2.35,0) 6(2.75,0) 7(3.15,0) 8(3.55,0) 9(3.95,0) 10(4.35,0) 11(4.75,0) 12(5.15,0) 13(5.55,0) 14(5.95,0) 15(6.35,0) 16(6.75,0) 17(7.15,0) 18(7.55,0) 19(7.95,0) 20(8.35,0) 21(8.75,0) 22(9.15,0) 23(9.55,0) 24(9.95,0) 25(10.35,0) 26(10.75,0) 27(11.15,0) 28(11.55,0) 29(11.95,0) 30(12.35,0) 31(12.75,0) 32(13.15,0) 33(13.55,0) 34(13.95,0) 35(14.35,0) 36(14.75,0) 37(15.15,0) 38(15.55,0) 39(15.95,0) 40(16.35,0) 41(16.75,0) 42(17.15,0) 43(17.55,0) 44(17.95,0)
  custom 0.688x0.688 hole 0.889x2.007: 47(-6.7,0) 49(25.8,0)
  oval 1.651x2.769 hole 0.889x2.007: 48(-6.7,-4.6) 50(25.8,-4.6)
TLC59116FIRHBR_VQFN32_5X5
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 17(3.5,5.1) 18(3,5.1) 19(2.5,5.1) 20(2,5.1) 21(1.5,5.1) 22(1,5.1) 23(0.5,5.1) 24(0,5.1)
  oval 0.889x0.254 smd: 9(4.3,0.8) 10(4.3,1.3) 11(4.3,1.8) 12(4.3,2.3) 13(4.3,2.8) 14(4.3,3.3) 15(4.3,3.8) 16(4.3,4.3) 25(-0.8,4.3) 26(-0.8,3.8) 27(-0.8,3.3) 28(-0.8,2.8) 29(-0.8,2.3) 30(-0.8,1.8) 31(-0.8,1.3) 32(-0.8,0.8)
  rect 3.454x3.454 smd: 33(1.75,2.55)
TPC12
  round 0.305 smd: 1(0,0)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
TWVM_WTB1220-02RD-MAGHB_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.875) 4(4.1,-4.875)
UNIMI_FBGCAX011_68P-T
  round 1.194 hole 1.194 unplated: (-1.06,0.64) (11.88,0.64)
  round 0.991 hole 0.991 unplated: (5.41,-6.27)
  round 2.692 hole 2.692 unplated: (5.41,-2.82)
  oval 0.711x0.406 smd: A1(0,0) A2(0,-0.6) A3(0,-1.2) A4(0,-1.8) A5(0,-2.4) A6(0,-3) A7(0,-3.6) A8(0,-4.2) A9(0,-4.8) A10(0,-5.4) B1(0.92,0) B2(0.92,-0.6) B3(0.92,-1.2) B4(0.92,-1.8) B5(0.92,-2.4) B6(0.92,-3) B7(0.92,-3.6) B8(0.92,-4.2) B9(0.92,-4.8) B10(0.92,-5.4) C1(3.3,0) C2(3.3,-0.6) C3(3.3,-1.2) C4(3.3,-1.8) C5(3.3,-2.4) C6(3.3,-3) C7(3.3,-3.6) C8(3.3,-4.2) C9(3.3,-4.8) C10(3.3,-5.4) D1(4.22,0) D2(4.22,-0.6) D9(4.22,-4.8) D10(4.22,-5.4) E1(6.6,0) E2(6.6,-0.6) E9(6.6,-4.8) E10(6.6,-5.4) F1(7.52,0) F2(7.52,-0.6) F3(7.52,-1.2) F4(7.52,-1.8) F5(7.52,-2.4) F6(7.52,-3) F7(7.52,-3.6) F8(7.52,-4.2) F9(7.52,-4.8) F10(7.52,-5.4) G1(9.9,0) G2(9.9,-0.6) G3(9.9,-1.2) G4(9.9,-1.8) G5(9.9,-2.4) G6(9.9,-3) G7(9.9,-3.6) G8(9.9,-4.2) G9(9.9,-4.8) G10(9.9,-5.4) H1(10.82,0) H2(10.82,-0.6) H3(10.82,-1.2) H4(10.82,-1.8) H5(10.82,-2.4) H6(10.82,-3) H7(10.82,-3.6) H8(10.82,-4.2) H9(10.82,-4.8) H10(10.82,-5.4)
UP9512RQGJ_VQFN40_5X5
  oval 0.94x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 21(5.1,-3.6) 22(5.1,-3.2) 23(5.1,-2.8) 24(5.1,-2.4) 25(5.1,-2) 26(5.1,-1.6) 27(5.1,-1.2) 28(5.1,-0.8) 29(5.1,-0.4) 30(5.1,0)
  oval 0.254x0.94 smd: 11(0.75,-4.35) 12(1.15,-4.35) 13(1.55,-4.35) 14(1.95,-4.35) 15(2.35,-4.35) 16(2.75,-4.35) 17(3.15,-4.35) 18(3.55,-4.35) 19(3.95,-4.35) 20(4.35,-4.35) 31(4.35,0.75) 32(3.95,0.75) 33(3.55,0.75) 34(3.15,0.75) 35(2.75,0.75) 36(2.35,0.75) 37(1.95,0.75) 38(1.55,0.75) 39(1.15,0.75) 40(0.75,0.75)
  rect 3.505x3.505 smd: 41(2.55,-1.8)
UP9529PQKF_WQFN20_3X3
  oval 0.94x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 11(3.1,-1.6) 12(3.1,-1.2) 13(3.1,-0.8) 14(3.1,-0.4) 15(3.1,0)
  oval 0.254x0.94 smd: 6(0.75,-2.35) 7(1.15,-2.35) 8(1.55,-2.35) 9(1.95,-2.35) 10(2.35,-2.35) 16(2.35,0.75) 17(1.95,0.75) 18(1.55,0.75) 19(1.15,0.75) 20(0.75,0.75)
  rect 1.6x1.6 smd: 21(1.55,-0.8)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q80EWSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_5YEA27000163IF50Q5_4P
  rect 1.295x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_XRCGB25M000F2P18R0_4P
  rect 0.762x0.711 smd: 1(0,0) 2(1.35,0) 3(1.35,1) 4(0,1)

## Nets
1.8VS_PGOOD: PR1813.2 PU1802.7
1V8_AON_EN: CG7103.1 QG503.2 RG1516.1 UG45.3 UG46.4
1V8_ENP: PC1821.1 PR1811.1 PR1815.1 PU1802.9
1V8_MAIN_AON_EN: CG7089.1 RG1510.2 UG39.1
1V8_MAIN_EN: DG3.2 DG7.2 QG520.2 RG27.1 RG549.1 RG1544.1 RG1555.1 RG1557.1 UG1.BE1 UG40.2 UG42.2
1V8_MAIN_ENP: RG1556.1 UG39.4
1V8_MAIN_ENR: RG1514.2 RG1556.2 RG1557.2 UG45.5
3V3_SYS_EN: CG240.1 QG505.2 RG515.2 RG545.2 UG36.4
3V_ELC_ON: RE83.1 UE9.4 UE10.18
3V_FB: PC313.1 PR305.1 PR307.2 PU301.10
3V_SN: PC310.1 PR301.2
3VS: C2524.1 J5.2 U17.8 U17.9
3VS_GATE: C258.1 R174.2 U17.5
5V_FB: PC516.1 PR510.1 PR511.2 PU501.7
5V_SN: PC513.1 PR501.2
5VCC: PCV19.1 PRV3.2 PRV5.2 PRV75.1 PUV1.12
5VS: C2523.1 J4.2 U17.13 U17.14
5VS_GATE: R182.2 U17.3
+0.6V_B_VREFDQ: CD324.1 RD228.1 UC1.BR13
+0.6V_DDR_B_VREFDQ: CD320.1 CD321.1 CD322.1 CD323.1 RD226.2 RD227.1 RD228.2 UD5.M1 UD6.M1 UD7.M1 UD8.M1
+0.6V_DDR_VREFCA: CD263.1 CD264.1 CD292.1 CD316.1 RD160.2 RD161.2 RD162.1 UD1.M1 UD2.M1 UD3.M1 UD4.M1
+0.6V_VREFCA: CD291.1 RD161.1 UC1.BN13
+0.6VS: CD285.1 CD286.1 CD287.1 CD288.1 CD289.1 CD290.1 CD296.1 CD297.1 CD300.1 CD303.1 CD312.1 CD318.1 CD328.1 CD336.1 CD337.1 CD341.1 CD342.1 CD348.1 CD349.1 CD351.1 CD361.1 CD363.1 CD364.1 CD373.1 CD380.1 CD383.1 CD386.1 CD389.1 CD392.1 CD395.1 CD398.1 CD401.1 PJPM04.2 RD166.2 RD167.2 RD168.2 RD169.2 RD170.2 RD171.2 RD172.2 RD173.2 RD174.2 RD175.2 RD176.2 RD177.2 RD178.2 RD179.2 RD180.2 RD181.2 RD182.2 RD183.2 RD184.2 RD187.2 RD188.2 RD189.2 RD190.2 RD191.2 RD192.2 RD198.2 RD199.2 RD200.2 RD203.2 RD204.2 RD205.2 RD206.2 RD207.2 RD208.2 RD209.2 RD210.2 RD211.2 RD212.2 RD213.2 RD214.2 RD215.2 RD216.2 RD217.2 RD218.2 RD219.2 RD220.2 RD221.2 RD222.2 RD223.2 RD224.2 RD255.2
+0.6VSP: PCM8.1 PCM9.1 PJPM04.1 PUM1.2 PUM1.20
+0.9V_CIO: CT78.1 CT79.1 CT80.1 UT1.R8 UT1.R9 UT1.R11 UT1.R12
+0.9V_DP: CT54.1 CT57.1 CT58.1 CT59.1 CT60.1 CT61.1 CT62.1 UT1.L6 UT1.L8 UT1.L11 UT1.L12 UT1.M6 UT1.M8 UT1.T11 UT1.T12 UT1.V11 UT1.V12 UT1.V13
+0.9V_LVR_OUT: CT81.1 CT82.1 CT83.1 CT84.1 UT1.F18 UT1.H11 UT1.H18 UT1.J11
+0.9V_PCIE: CT55.1 CT70.1 CT71.1 CT72.1 UT1.L18 UT1.L19 UT1.M13 UT1.M15 UT1.M16 UT1.M18 UT1.N18 UT1.N19
+0.9V_SVR: CT63.1 CT64.1 CT65.1 CT66.1 CT67.1 CT68.1 CT69.1 CT73.1 CT74.1 CT75.1 LT1.2 UT1.E12 UT1.E13 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.J9 UT1.L9 UT1.M9
+0.9V_USB: CT56.1 CT77.1 UT1.R15 UT1.R16
+1.0VS_VGA_PGOOD: PR1108.2 PU1101.7 UG27.2
+1.0VS_VGAP: PC1101.1 PC1102.1 PC1103.1 PC1104.1 PC1111.1 PJP1101.1 PL1001.2 PR1110.1
+1.2V_DDR: C2518.1 C2527.1 C2528.1 CD265.1 CD266.1 CD267.1 CD268.1 CD269.1 CD270.1 CD271.1 CD272.1 CD273.1 CD274.1 CD275.1 CD276.1 CD277.1 CD278.1 CD295.1 CD298.1 CD299.1 CD302.1 CD304.1 CD306.1 CD307.1 CD308.1 CD309.1 CD310.1 CD311.1 CD313.1 CD315.1 CD317.1 CD325.1 CD329.1 CD330.1 CD332.1 CD334.1 CD335.1 CD338.1 CD339.1 CD340.1 CD343.1 CD346.1 CD350.1 CD352.1 CD353.1 CD354.1 CD355.1 CD356.1 CD357.1 CD358.1 CD360.1 CD362.1 CD367.1 CD368.1 CD369.1 CD371.1 CD372.1 CD374.1 CD375.1 CD376.1 CD378.1 CD381.1 CD384.1 CD387.1 CD390.1 CD393.1 CD396.1 CD399.1 CH118.1 CH119.1 CH120.1 CH121.1 CH122.1 CH123.1 CH124.1 CH125.1 CH126.1 CH127.1 CH128.1 CH129.1 CH130.1 CH131.1 CH132.1 CH197.1 PJPM03.2 RD35.1 RD160.1 RD193.1 RD202.1 RD226.1 RH530.2 UC1.AA6 UC1.AE12 UC1.AF5 UC1.AF6 UC1.AG5 UC1.AG9 UC1.AJ12 UC1.AL11 UC1.AP6 UC1.AP7 UC1.AR6 UC1.AR12 UC1.AT12 UC1.AW6 UC1.AY6 UC1.J5 UC1.J6 UC1.K6 UC1.K12 UC1.L6 UC1.L12 UC1.R6 UC1.T6 UC1.W6 UC1.Y12 UC2.5 UD1.A1 UD1.A9 UD1.B3 UD1.B9 UD1.C1 UD1.D1 UD1.D9 UD1.E2 UD1.E7 UD1.F2 UD1.F8 UD1.G1 UD1.G7 UD1.G9 UD1.J1 UD1.J2 UD1.J8 UD1.J9 UD1.L1 UD1.L9 UD1.R1 UD1.T9 UD2.A1 UD2.A9 UD2.B3 UD2.B9 UD2.C1 UD2.D1 UD2.D9 UD2.E2 UD2.E7 UD2.F2 UD2.F8 UD2.G1 UD2.G7 UD2.G9 UD2.J1 UD2.J2 UD2.J8 UD2.J9 UD2.L1 UD2.L9 UD2.R1 UD2.T9 UD3.A1 UD3.A9 UD3.B3 UD3.B9 UD3.C1 UD3.D1 UD3.D9 UD3.E2 UD3.E7 UD3.F2 UD3.F8 UD3.G1 UD3.G7 UD3.G9 UD3.J1 UD3.J2 UD3.J8 UD3.J9 UD3.L1 UD3.L9 UD3.R1 UD3.T9 UD4.A1 UD4.A9 UD4.B3 UD4.B9 UD4.C1 UD4.D1 UD4.D9 UD4.E2 UD4.E7 UD4.F2 UD4.F8 UD4.G1 UD4.G7 UD4.G9 UD4.J1 UD4.J2 UD4.J8 UD4.J9 UD4.L1 UD4.L9 UD4.R1 UD4.T9 UD5.A1 UD5.A9 UD5.B3 UD5.B9 UD5.C1 UD5.D1 UD5.D9 UD5.E2 UD5.E7 UD5.F2 UD5.F8 UD5.G1 UD5.G7 UD5.G9 UD5.J1 UD5.J2 UD5.J8 UD5.J9 UD5.L1 UD5.L9 UD5.R1 UD5.T9 UD6.A1 UD6.A9 UD6.B3 UD6.B9 UD6.C1 UD6.D1 UD6.D9 UD6.E2 UD6.E7 UD6.F2 UD6.F8 UD6.G1 UD6.G7 UD6.G9 UD6.J1 UD6.J2 UD6.J8 UD6.J9 UD6.L1 UD6.L9 UD6.R1 UD6.T9 UD7.A1 UD7.A9 UD7.B3 UD7.B9 UD7.C1 UD7.D1 UD7.D9 UD7.E2 UD7.E7 UD7.F2 UD7.F8 UD7.G1 UD7.G7 UD7.G9 UD7.J1 UD7.J2 UD7.J8 UD7.J9 UD7.L1 UD7.L9 UD7.R1 UD7.T9 UD8.A1 UD8.A9 UD8.B3 UD8.B9 UD8.C1 UD8.D1 UD8.D9 UD8.E2 UD8.E7 UD8.F2 UD8.F8 UD8.G1 UD8.G7 UD8.G9 UD8.J1 UD8.J2 UD8.J8 UD8.J9 UD8.L1 UD8.L9 UD8.R1 UD8.T9 UZ21.1 UZ21.2
+1.2V_VCCPLL_OC: C11.1 CC36.1 CC37.1 RH530.1 UC1.BH13 UC1.BJ13 UC1.G11 UZ21.7 UZ21.8
+1.2VP: PCM20.1 PJPM03.1 PLM01.1 PRM14.2 PUM1.5 PUM1.19
+1.8V_PRIM: CH176.1 CH233.1 RH218.2 RH595.2 RH598.2 RH599.1 UH1.AG19 UH1.AG20 UH1.AN15 UH1.AN32 UH1.AR15 UH1.BB11
+1.8V_RUN: JIO1.H10 PJP42.1
+1.8V_RUN_PWR: CZ120.1 PJP42.2 UZ45.7 UZ45.8
+1.8VA_TBTA_LDO: CT100.1 UT4.K1
+1.8VALW: CE186.1 CG7104.1 CV20.1 CV1056.1 PJP1803.2 PRV18.1 PRW24.1 RG1615.1 RG1616.1 RH111.2 RH181.1 RH182.1 RH518.2 RH599.2 RH603.1 RH1039.2 RH1040.2 UE5.J4 UG45.1 UG45.2 UX1.5 UX2.5 UZ45.1 UZ45.2
+1.8VD_TBTA_LDO: CT99.1 UT4.A2
+1.8VSP: PC1808.1 PC1809.1 PC1810.1 PC1811.1 PC1819.1 PJP1803.1 PL1802.2 PR1816.1
+1.35VS_VGA: CG101.2 CG102.2 CG103.2 CG104.2 CG105.2 CG106.2 CG107.1 CG108.1 CG109.1 CG110.1 CG111.1 CG112.1 CG516.1 CG517.1 CG518.1 CG519.1 CG520.1 CG521.1 CG546.2 CG547.2 CG548.2 CG549.2 CG550.2 CG551.2 CG573.2 CG574.2 CG575.2 CG576.2 CG577.2 CG578.2 CG579.1 CG580.1 CG581.1 CG582.1 CG583.1 CG584.1 CG638.2 CG639.2 CG640.2 CG641.2 CG642.2 CG643.2 CG644.1 CG645.1 CG646.1 CG647.1 CG648.1 CG649.1 CG679.1 CG680.1 CG681.2 CG682.1 CG683.1 CG684.2 CG685.2 CG686.2 CG687.1 CG688.2 CG689.2 CG690.1 CG732.2 CG733.1 CG734.1 CG735.2 CG736.2 CG737.1 CG738.1 CG739.2 CG740.1 CG741.1 CG742.2 CG743.2 CG768.1 CG771.1 CG772.1 CG773.1 CG774.1 CG776.1 CG777.1 CG779.1 CG780.1 CG782.1 CG783.1 CG784.1 CG785.2 CG786.2 CG787.1 CG788.1 CG789.2 CG790.1 CG791.1 CG792.1 CG793.2 CG794.2 CG795.2 CG796.1 CG838.1 CG839.1 CG840.2 CG841.1 CG842.1 CG843.2 CG844.2 CG845.2 CG846.2 CG847.1 CG848.2 CG849.1 CG6522.1 CG6523.1 CG6524.1 CG6525.1 CG6526.1 CG6527.1 CG6528.1 CG6529.1 CG6530.1 CG6531.1 CG6532.1 CG6533.1 CG6534.1 CG6535.1 CG6536.1 CG6537.1 CG6538.1 CG6539.1 CG6540.1 CG6541.1 CG6542.1 CG6543.1 CG6544.1 CG6545.1 CG6546.1 CG6547.1 CG6548.1 CG6549.1 CG6550.1 CG6551.1 CG6552.1 CG6553.1 CG6554.1 CG6555.1 CG6556.1 CG6557.1 CG6558.1 CG6559.1 CG6560.1 CG6561.1 CG6562.1 CG6563.1 CG6564.1 CG6565.1 CG6566.1 CG6567.1 CG6568.1 CG6569.1 CG6570.1 CG6571.1 CG6572.1 CG6573.1 CG6574.1 CG6575.1 CG6576.1 CG6577.1 CG6578.1 CG6579.1 CG6580.1 CG6581.1 CG6582.1 CG6583.1 CG6584.1 CG6585.1 CG6586.1 CG6587.1 CG6588.1 CG6589.1 CG6590.1 CG6591.1 CG6592.1 CG6593.1 CG6594.1 CG6595.1 CG6596.1 CG6597.1 CG6598.1 CG6599.1 CG6600.1 CG6601.1 CG6602.1 CG6603.1 CG6604.1 CG6605.1 CG6606.1 CG6607.1 CG6608.1 CG6609.1 CG6610.1 CG6611.1 CG6612.1 CG6613.1 CG6614.1 CG6615.1 CG6616.1 CG6617.1 CG6618.1 CG6619.1 CG6620.1 CG6621.1 CG6622.1 CG6623.1 CG6624.1 CG6625.1 CG6626.1 CG6627.1 CG6628.1 CG6629.1 CG6630.1 CG6631.1 CG6632.1 CG6633.1 CG6634.1 CG6635.1 CG6636.1 CG6637.1 CG6638.1 CG6639.1 CG6640.1 CG6641.1 CG6642.1 CG6643.1 CG6644.1 CG6645.1 CG6646.1 CG6647.1 CG6648.1 CG6649.1 CG6650.1 CG6651.1 CG6652.1 CG6653.1 CG6654.1 CG6655.1 CG6656.1 CG6657.1 CG6658.1 CG6659.1 CG6660.1 CG6661.1 CG6662.1 CG6663.1 CG6664.1 CG6665.1 CG6666.1 CG6667.1 CG6668.1 CG6669.1 CG6670.1 CG6671.1 CG6672.1 CG6673.1 CG6674.1 CG6675.1 CG6676.1 CG6677.1 CG6678.1 CG6679.1 CG6680.1 CG6681.1 CG6682.1 CG6683.1 CG6684.1 CG6685.1 CG6686.1 CG6687.1 CG6688.1 CG6689.1 CG6690.1 CG6691.1 CG6692.1 CG6693.1 CG6694.1 CG6695.1 CG6696.1 CG6697.1 CG6698.1 CG6699.1 CG6700.1 CG6701.1 CG6702.1 CG6703.1 CG6704.1 CG6705.1 CG6706.1 CG6707.1 CG6708.1 CG6709.1 CG6710.1 CG6711.1 CG6712.1 CG6713.1 CG6714.1 CG6715.1 CG6716.1 CG6717.1 CG6718.1 CG6719.1 CG6720.1 CG6721.1 CG6722.1 CG6723.1 CG6724.1 CG6725.1 CG6726.1 CG6727.1 CG6728.1 CG6729.1 CG6730.1 CG6731.1 CG6732.1 CG6733.1 CG6734.1 CG6735.1 CG6736.1 CG6737.1 CG6738.1 CG6739.1 CG6740.1 CG6741.1 CG6742.1 CG6743.1 CG6744.1 CG6745.1 CG6746.1 CG6747.1 CG6748.1 CG6749.1 CG6750.1 CG6751.1 CG6752.1 CG6753.1 CG6754.1 CG6755.1 CG6756.1 CG6757.1 CG6758.1 CG6759.1 CG6760.1 CG6761.1 CG6762.1 CG6763.1 CG6764.1 CG6765.1 CG6766.1 CG6767.1 CG6768.1 CG6769.1 CG6770.1 CG6771.1 CG6772.1 CG6773.1 CG6774.1 CG6775.1 CG6776.1 CG6777.1 CG6778.1 CG6779.1 CG6780.1 CG6781.1 CG6782.1 CG6783.1 CG6784.1 CG6785.1 CG6786.1 CG6787.1 CG6788.1 CG6789.1 CG6790.1 CG6791.1 CG6792.1 CG6793.1 CG6794.1 CG6795.1 CG6796.1 CG6797.1 CG6828.1 CG6829.1 CG6830.1 CG6831.1 CG6832.1 CG6833.1 CG6834.1 CG6835.1 CG6836.1 CG6837.1 CG6838.1 CG6839.1 CG6840.1 CG6841.1 CG6842.1 CG6843.1 CG6844.1 CG6845.1 CG6846.1 CG6847.1 CG6848.1 CG6849.1 CG6850.1 CG6851.1 CG6852.1 CG6853.1 CG6854.1 CG6855.1 CG6856.1 CG6857.1 CG6858.1 CG6859.1 CG6860.1 CG6861.1 CG6862.1 CG6863.1 CG6864.1 CG6865.1 CG6866.1 CG6867.1 CG6868.1 CG6869.1 CG6870.1 CG6871.1 CG6872.1 CG6873.1 CG6874.1 CG6875.1 CG6876.1 CG6877.1 CG6878.1 CG6879.1 CG6880.1 CG6881.1 CG6882.1 CG6883.1 CG6884.1 CG6885.1 CG6886.1 CG6887.1 CG6888.1 CG6889.1 CG6890.1 CG6891.1 CG6892.1 CG6893.1 CG6894.1 CG6895.1 CG6896.1 PCW26.1 PCW28.1 PLW01.4 PLW02.4 PRW7.2 RG67.2 RG110.1 RG121.1 RG132.1 RG155.1 RG1410.2 RG1411.2 RG1412.2 RG1413.2 RG1446.2 RG1451.2 RG1476.2 RG1478.2 RG1479.1 RG1480.1 RG1483.1 RG1484.1 RG1487.1 RG1488.1 RG1491.1 RG1492.1 RG1605.1 UG1.AA10 UG1.AA11 UG1.AA42 UG1.AA43 UG1.AC10 UG1.AC11 UG1.AC42 UG1.AC43 UG1.AD10 UG1.AD11 UG1.AD42 UG1.AD43 UG1.AF10 UG1.AF43 UG1.AG10 UG1.AG11 UG1.AG42 UG1.AG43 UG1.AJ10 UG1.AJ11 UG1.AJ42 UG1.AJ43 UG1.AK10 UG1.AK11 UG1.AK42 UG1.AK43 UG1.AM42 UG1.AM43 UG1.AN43 UG1.AR42 UG1.AR43 UG1.AT43 UG1.K12 UG1.K14 UG1.K15 UG1.K17 UG1.K18 UG1.K20 UG1.K21 UG1.K23 UG1.K24 UG1.K26 UG1.K27 UG1.K29 UG1.K30 UG1.K32 UG1.K33 UG1.K35 UG1.K36 UG1.K38 UG1.K39 UG1.K41 UG1.L14 UG1.L15 UG1.L18 UG1.L20 UG1.L21 UG1.L23 UG1.L24 UG1.L26 UG1.L27 UG1.L30 UG1.L32 UG1.L33 UG1.L35 UG1.L36 UG1.L39 UG1.M10 UG1.M43 UG1.P10 UG1.P11 UG1.P42 UG1.P43 UG1.R10 UG1.R11 UG1.R42 UG1.R43 UG1.U10 UG1.U11 UG1.U43 UG1.V10 UG1.V42 UG1.V43 UG1.Y10 UG1.Y11 UG1.Y42 UG1.Y43 UG11.A1 UG11.A14 UG11.B5 UG11.B10 UG11.C1 UG11.C4 UG11.C11 UG11.C14 UG11.E1 UG11.E5 UG11.E10 UG11.E14 UG11.F4 UG11.F11 UG11.H1 UG11.H2 UG11.H13 UG11.H14 UG11.J2 UG11.J13 UG11.K2 UG11.K13 UG11.L1 UG11.L2 UG11.L13 UG11.L14 UG11.N4 UG11.N11 UG11.P1 UG11.P5 UG11.P10 UG11.P14 UG11.T1 UG11.T4 UG11.T11 UG11.T14 UG11.U5 UG11.U10 UG11.V1 UG11.V14 UG12.A1 UG12.A14 UG12.B5 UG12.B10 UG12.C1 UG12.C4 UG12.C11 UG12.C14 UG12.E1 UG12.E5 UG12.E10 UG12.E14 UG12.F4 UG12.F11 UG12.H1 UG12.H2 UG12.H13 UG12.H14 UG12.J2 UG12.J13 UG12.K2 UG12.K13 UG12.L1 UG12.L2 UG12.L13 UG12.L14 UG12.N4 UG12.N11 UG12.P1 UG12.P5 UG12.P10 UG12.P14 UG12.T1 UG12.T4 UG12.T11 UG12.T14 UG12.U5 UG12.U10 UG12.V1 UG12.V14 UG13.A1 UG13.A14 UG13.B5 UG13.B10 UG13.C1 UG13.C4 UG13.C11 UG13.C14 UG13.E1 UG13.E5 UG13.E10 UG13.E14 UG13.F4 UG13.F11 UG13.H1 UG13.H2 UG13.H13 UG13.H14 UG13.J2 UG13.J13 UG13.K2 UG13.K13 UG13.L1 UG13.L2 UG13.L13 UG13.L14 UG13.N4 UG13.N11 UG13.P1 UG13.P5 UG13.P10 UG13.P14 UG13.T1 UG13.T4 UG13.T11 UG13.T14 UG13.U5 UG13.U10 UG13.V1 UG13.V14 UG14.A1 UG14.A14 UG14.B5 UG14.B10 UG14.C1 UG14.C4 UG14.C11 UG14.C14 UG14.E1 UG14.E5 UG14.E10 UG14.E14 UG14.F4 UG14.F11 UG14.H1 UG14.H2 UG14.H13 UG14.H14 UG14.J2 UG14.J13 UG14.K2 UG14.K13 UG14.L1 UG14.L2 UG14.L13 UG14.L14 UG14.N4 UG14.N11 UG14.P1 UG14.P5 UG14.P10 UG14.P14 UG14.T1 UG14.T4 UG14.T11 UG14.T14 UG14.U5 UG14.U10 UG14.V1 UG14.V14 UG15.A1 UG15.A14 UG15.B5 UG15.B10 UG15.C1 UG15.C4 UG15.C11 UG15.C14 UG15.E1 UG15.E5 UG15.E10 UG15.E14 UG15.F4 UG15.F11 UG15.H1 UG15.H2 UG15.H13 UG15.H14 UG15.J2 UG15.J13 UG15.K2 UG15.K13 UG15.L1 UG15.L2 UG15.L13 UG15.L14 UG15.N4 UG15.N11 UG15.P1 UG15.P5 UG15.P10 UG15.P14 UG15.T1 UG15.T4 UG15.T11 UG15.T14 UG15.U5 UG15.U10 UG15.V1 UG15.V14 UG16.A1 UG16.A14 UG16.B5 UG16.B10 UG16.C1 UG16.C4 UG16.C11 UG16.C14 UG16.E1 UG16.E5 UG16.E10 UG16.E14 UG16.F4 UG16.F11 UG16.H1 UG16.H2 UG16.H13 UG16.H14 UG16.J2 UG16.J13 UG16.K2 UG16.K13 UG16.L1 UG16.L2 UG16.L13 UG16.L14 UG16.N4 UG16.N11 UG16.P1 UG16.P5 UG16.P10 UG16.P14 UG16.T1 UG16.T4 UG16.T11 UG16.T14 UG16.U5 UG16.U10 UG16.V1 UG16.V14 UG17.A1 UG17.A14 UG17.B5 UG17.B10 UG17.C1 UG17.C4 UG17.C11 UG17.C14 UG17.E1 UG17.E5 UG17.E10 UG17.E14 UG17.F4 UG17.F11 UG17.H1 UG17.H2 UG17.H13 UG17.H14 UG17.J2 UG17.J13 UG17.K2 UG17.K13 UG17.L1 UG17.L2 UG17.L13 UG17.L14 UG17.N4 UG17.N11 UG17.P1 UG17.P5 UG17.P10 UG17.P14 UG17.T1 UG17.T4 UG17.T11 UG17.T14 UG17.U5 UG17.U10 UG17.V1 UG17.V14 UG18.A1 UG18.A14 UG18.B5 UG18.B10 UG18.C1 UG18.C4 UG18.C11 UG18.C14 UG18.E1 UG18.E5 UG18.E10 UG18.E14 UG18.F4 UG18.F11 UG18.H1 UG18.H2 UG18.H13 UG18.H14 UG18.J2 UG18.J13 UG18.K2 UG18.K13 UG18.L1 UG18.L2 UG18.L13 UG18.L14 UG18.N4 UG18.N11 UG18.P1 UG18.P5 UG18.P10 UG18.P14 UG18.T1 UG18.T4 UG18.T11 UG18.T14 UG18.U5 UG18.U10 UG18.V1 UG18.V14
+1.35VS_VGA_PGOOD: PRW27.2 PUW1.1 UG29.1 UG46.1
+1V8_AON: CG66.1 CG246.1 CG270.2 CG476.1 CG478.1 CG483.1 CG552.1 CG553.1 CG554.1 CG555.1 CG556.1 CG621.1 CG622.1 CG623.1 CG624.1 CG625.1 CG674.1 CG676.1 CG677.1 CG678.1 CG769.1 CG770.1 CG775.1 CG778.1 CG781.1 CG823.1 CG826.1 CG827.1 CG835.1 CG837.1 CG878.1 CG882.1 CG887.1 CG888.1 CG889.1 CG6803.1 CG6815.1 CG6816.1 CG6817.1 CG6818.1 CG6819.1 CG6820.1 CG6821.1 CG6822.1 CG6823.1 CG6824.1 CG7082.1 CG7083.1 CG7084.1 CG7085.1 CG7087.1 CG7088.1 CG7091.1 CG7092.1 CG7093.1 CG7100.1 CG7101.1 CG7106.1 PRV52.1 PRV53.1 PRW27.1 QG511.2 RG2.2 RG8.2 RG9.2 RG13.2 RG15.2 RG16.2 RG17.2 RG18.2 RG19.2 RG20.2 RG27.2 RG28.2 RG29.2 RG74.1 RG78.2 RG79.2 RG80.2 RG81.2 RG82.2 RG83.2 RG84.2 RG85.2 RG86.2 RG501.2 RG504.1 RG510.1 RG516.1 RG522.2 RG523.2 RG524.2 RG526.2 RG530.1 RG533.1 RG1497.2 RG1514.1 RG1518.1 RG1522.2 RG1581.2 RV648.1 RV652.1 RX5.1 RX7.1 UG1.AW9 UG1.BA10 UG1.BB14 UG1.BC14 UG9.5 UG9.6 UG10.5 UG11.A5 UG11.A10 UG11.V5 UG11.V10 UG12.A5 UG12.A10 UG12.V5 UG12.V10 UG13.A5 UG13.A10 UG13.V5 UG13.V10 UG14.A5 UG14.A10 UG14.V5 UG14.V10 UG15.A5 UG15.A10 UG15.V5 UG15.V10 UG16.A5 UG16.A10 UG16.V5 UG16.V10 UG17.A5 UG17.A10 UG17.V5 UG17.V10 UG18.A5 UG18.A10 UG18.V5 UG18.V10 UG22.5 UG26.5 UG27.5 UG29.5 UG34.3 UG34.7 UG34.8 UG39.5 UG40.5 UG41.5 UG42.5 UG43.5 UG44.5 UG45.6 UG45.7 UG45.13 UG45.14 UG47.5
+1V8_MAIN: CG3.1 CG4.1 CG8.2 CG9.2 CG10.2 CG31.1 CG32.1 CG33.1 CG34.1 CG35.1 CG36.1 CG37.1 CG38.1 CG39.1 CG40.1 CG41.1 CG42.1 CG43.1 CG45.1 CG312.1 CG7098.1 LG1.2 LG6.2 LG8.1 LG9.1 LG10.1 RG512.1 RG515.1 RG1517.1 RG1519.1 RX3.1 UG1.BB26 UG1.BB27 UG1.BB29 UG1.BB32 UG1.BC26 UG1.BC27 UG1.BC29 UG1.BC30 UG1.BC32 UG1.BD21 UG1.BD27 UG1.BD30 UG45.8 UG45.9
+1V_MPHY: CH82.1 CH187.1 RH12.2 UH1.B1 UH1.B2 UH1.B3 UH1.C1 UH1.C2 UH1.C49 UH1.D49 UH1.E49 UH1.P2 UH1.P3 UH1.V19 UH1.W19 UH1.W20 UH1.W31
+1V_PCH: JP1.2 RH71.1 UH1.W22 UH1.W23
+1V_VCCDSW: UH1.BG45 UH1.BG46
+1VALW: C4.1 C7.1 CH180.1 CH181.1 CH188.1 JP1.1 JPCMC.22 PJPH02.2 RC353.1 RH12.1 U19.1 U19.2 U19.7 U20.1 U20.2 U20.7 UH1.AA22 UH1.AA23 UH1.AB20 UH1.AB22 UH1.AB23 UH1.AB27 UH1.AB28 UH1.AB30 UH1.AD20 UH1.AD23 UH1.AD27 UH1.AD28 UH1.AD30 UH1.AD31 UH1.AE17 UH1.AF23 UH1.AF27 UH1.AF30 UH1.AF31 UH1.AG31 UH1.D1 UH1.E1 UH1.U26 UH1.U29 UH1.V25 UH1.V27 UH1.V28 UH1.V30 UH1.V31
+1VALWP: PCH11.1 PCH12.1 PJPH02.1 PLH01.2 PRH7.2
+1VALWP_PGOOD: PRH4.2 PUH1.1 UE5.J1
+2.5V_MEM: CD256.1 CD279.1 CD280.1 CD281.1 CD282.1 CD283.1 CD284.1 CD293.1 CD301.1 CD305.1 CD314.1 CD319.1 CD326.1 CD327.1 CD331.1 CD333.1 CD344.1 CD345.1 CD347.1 CD359.1 CD365.1 CD366.1 CD370.1 CD377.1 CD379.1 CD382.1 CD385.1 CD388.1 CD391.1 CD394.1 CD397.1 CD400.1 PJP2502.2 UD1.B1 UD1.R9 UD2.B1 UD2.R9 UD3.B1 UD3.R9 UD4.B1 UD4.R9 UD5.B1 UD5.R9 UD6.B1 UD6.R9 UD7.B1 UD7.R9 UD8.B1 UD8.R9
+2.5V_MEMP: PC2504.1 PC2505.1 PC2506.1 PJP2502.1 PR2504.1 PU2501.6
+2.5VOUT: CM9.1 CM32.1 CM34.1 CM35.1 CM36.1 UM8.9 UM8.14 UM8.36 UM8.41 UM8.51
+2.5VSP_ADJ: PC2504.2 PR2504.2 PR2505.1 PU2501.7
+2.5VSP_ON: PC2501.1 PR2501.2 PR2502.1 PU2501.2
+2.5VSP_PGOOD: PR2503.2 PU2501.1
+2.5VSP_VIN: PC2502.1 PC2503.1 PJP2501.2 PU2501.3
+3.3V_ANA_PCIE: CT85.1 RT200.2 UT1.L16
+3.3V_ANA_USB2: CT86.1 UT1.J16
+3.3V_ELC: CE1.1 CE6.1 CE19.1 CE59.1 CE60.1 CE64.1 CE65.1 CE168.1 CE170.1 JELC2.1 LE4.1 RE1.1 RE2.1 RE4.1 RE6.2 RE7.2 RE8.1 RE12.1 RE13.1 RE14.1 RE15.1 RE16.1 RE17.1 RE21.1 RE23.1 RE165.1 RE166.1 RE657.1 UE1.1 UE1.24 UE1.36 UE1.48 UE2.8 UE8.27 UE9.1
+3.3V_FLASH: CT45.1 CT103.1 RT48.1 RT49.1 RT50.1 RT51.1 RT66.1 RT67.1 RT124.1 RT130.1 UT2.8 UT4.B1 UT4.G1
+3.3V_LC: CT46.1 RT6.1 RT7.1 RT8.1 RT9.1 UT1.R6
+3.3V_TBT_SX: CT47.1 RT26.1 RT27.1 RT28.1 RT29.1 RT30.1 RT31.1 RT32.1 RT33.1 RT36.1 RT61.2 RT70.1 RT86.1 RT94.1 RT97.2 UT1.F8
+3.3V_TBT_SX_R: CT102.1 RT61.1 UT4.H2
+3V3_SYS: CG323.1 CG385.1 PR1108.1 QX1.2 RG514.1 RG1608.2 RV655.1 RX1.1 UG36.6
+3V_OC_PWR: CG6802.1 RG135.2 RG1562.2 RG1570.1 RG1571.1 RG1572.1 RG1573.1 RG1608.1 RG1609.1 RG1611.1 UG37.27
+3V_PCH: C266.1 C267.1 CH49.1 CH182.1 CH186.1 CH190.1 CH192.1 CH231.1 J6.1 R367.2 RC9.1 RH7.2 RH21.2 RH25.2 RH27.2 RH29.2 RH63.1 RH75.1 RH78.1 RH95.1 RH99.2 RH100.1 RH130.1 RH453.2 RH460.1 RH461.1 RH493.1 RH506.2 RH515.2 RH524.1 RH533.2 RH545.2 RH558.2 RH571.2 RH594.1 RH1019.2 RH1020.2 RH1035.1 RH1600.2 UH1.AC35 UH1.AC36 UH1.AE35 UH1.AE36 UH1.AN21 UH1.AN24 UH1.AN26 UH1.AN44 UH1.AP26 UH1.AT44 UH1.AW9 UH1.AY8 UH1.BB7 UH1.BB14 UH1.V23 UH4.8
+3VALW: C262.1 C263.1 C269.1 C270.1 C2514.1 C2515.1 CE22.1 CE62.1 CM23.1 CM70.1 CT121.1 CT122.1 CT5361.1 CV1075.1 CV1076.1 CV1077.1 JIO1.A10 JIO2.F9 JIO2.F10 JWDB1.1 PC1108.1 PC1816.1 PCH21.1 PJP302.2 PJP2501.1 PR3.2 PR32.1 PR1103.2 PR1810.2 PR2503.1 PRH4.1 PRH15.2 PRM10.1 PRV50.1 PRV226.1 PRW21.1 PRW23.1 PU1101.12 PU1802.12 PUH2.12 R307.1 R325.1 RE64.2 RE70.1 RE201.1 RE530.1 RE642.1 RE643.1 RE652.1 RE688.1 RE689.1 RE709.2 RE723.1 RG1601.1 RG1609.2 RH2.1 RH6.2 RM5.1 RM41.1 RT88.1 RT111.1 RT728.1 U16.1 U16.2 U16.7 U17.6 U17.7 U18.5 UE9.5 UE10.24 UM3.5 UM7.5 UT3.5 UT8.5 UV4.6
+3VALW_EC: CE29.1 CE30.1 CE31.2 CE32.2 LE1.1 PR16.2 PR24.2 RE78.2 RE90.5 RE90.6 RE715.2 RE723.2 RG1612.1 UE5.K12 UE5.M12
+3VALW_PD: CT88.1 CT101.1 RT53.2 RT728.2 UT4.H1
+3VALW_TBT: CH242.1 CT48.1 CT49.1 CT50.1 CT51.1 CT52.1 CT53.1 LT4.2 RT20.1 RT21.1 RT76.2 RT77.2 RT95.2 RT695.1 RT723.1 RT729.2 UT1.A2 UT1.A3 UT1.B3 UT1.H9
+3VALW_TBT_S5: CT124.1 RT53.1 RT95.1 RT97.1 RT107.1 UT8.1
+3VALWP: PC302.1 PC303.1 PC304.1 PC305.1 PC306.1 PJP302.1 PL301.2 PR303.2 PR304.1 PR307.1 PR509.1 PU301.11
+3VLP: CE196.2 CE197.2 CU26.1 DU8.1 JIO1.H9 PJP303.2 PR11.1 PR25.2 RE78.1 RE684.1 RE717.2 RG1611.2 RG1613.1 RU4.1 RU5.1 UE5.J7 UU5.5
+3VS: C260.1 C261.1 C2498.1 CG322.1 CG7105.1 CH201.1 CM18.1 CM19.1 CM20.1 CM21.1 CM29.1 CM30.1 CM31.1 CM33.1 FV2.1 J5.1 JGYRO.6 JIO1.A9 JIO2.E9 JIO2.E10 PR1813.1 PRH18.1 PRV30.1 PRV59.1 PRW15.1 PRZ40.1 QG525.2 QH5.2 QH5.5 QX2.1 QX3.1 R181.1 R368.2 R369.1 R370.1 RC62.2 RC63.2 RE20.2 RE84.1 RE90.7 RE90.8 RE656.1 RF1.2 RF2.2 RF4.2 RF5.2 RG506.1 RG534.1 RG561.1 RG1600.2 RH5.1 RH85.2 RH462.1 RH463.1 RH501.1 RH502.1 RH512.2 RH516.1 RH517.1 RH520.1 RH521.1 RH525.1 RH537.2 RH588.1 RH600.2 RH601.1 RH602.1 RH604.1 RH605.1 RH606.1 RH607.1 RH1023.1 RH1026.1 RH1028.1 RH1030.1 RH1033.1 RM14.1 RM18.1 RM20.1 RM26.1 RM66.2 RM76.1 RM79.1 RM81.1 RM85.1 RM86.1 RM96.1 RP3.1 RP3.2 RP3.3 RP3.4 RP5.1 RP5.2 RP5.3 RP5.4 RPC7.5 RPC7.6 RPC7.7 RPC7.8 RT132.2 RT729.1 RV16.1 RV671.2 RV672.2 U2407.1 UG36.1 UG36.2 UG36.7 UG46.5 UH3.5 UM4.5 UM4.9 UM4.12 UM4.16 UM8.24 UV1.1 UX3.5
+3VS_CAMERA: CV7160.1 CV7161.1 JEDP.33 UV1.3
+3VS_DP: CV34.1 CV35.1 FV2.2 JDP.20 RX9.2 UX3.1
+3VS_SSD: C617.1 C618.1 C621.1 C622.1 C623.1 C629.1 C630.1 C631.1 C632.1 C633.1 C634.1 C635.1 C636.1 C639.1 C640.1 C641.1 C2512.1 C2513.1 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.70 JSSD1.72 JSSD1.74 JSSD3.2 JSSD3.4 JSSD3.12 JSSD3.14 JSSD3.16 JSSD3.18 JSSD3.70 JSSD3.72 JSSD3.74 R363.2 R364.2 U16.6
+3VS_TOUCH: C2.1 C2526.1 CT116.1 CT118.1 JTP15.8 JTP17.1 RE33.1 RE100.1 RE101.1 RE661.1 RT89.1 UT5.7 UT5.8
+5V_TOBII: JTOBII.2 UE12.1
+5VALW: C264.1 C265.1 C2516.1 C2519.1 C2520.1 C2521.1 C2525.1 CE81.1 CE183.1 CE184.1 CG384.1 CT90.1 CT91.1 CT92.1 CT93.1 CT157.1 CV1074.1 JIO1.E1 JIO1.E9 JIO1.E10 JIO1.F5 JIO1.F6 JIO1.F7 JIO1.F8 JIO1.F9 JIO1.F10 JIO2.F5 JIO2.F6 JIO2.F7 JIO2.F8 JWDB.1 PCA2.1 PCG8.1 PCH10.1 PCZ55.1 PCZ56.1 PCZ88.1 PCZ89.1 PCZ117.1 PCZ118.1 PJP502.2 PR8.1 PR2506.1 PRA3.1 PRG01.1 PRM2.1 PRM4.1 PRV91.2 PRW5.1 PRW25.1 PRW26.1 PRW60.2 PRZ3.1 PRZ37.1 PRZ83.1 PRZ84.1 PRZ85.2 PRZ91.1 PRZ96.1 PRZ97.1 PRZ106.1 PRZ107.1 PRZ108.2 PRZ113.1 PRZ115.1 PRZ120.1 PRZ129.1 PRZ130.1 PRZ131.2 PRZ135.1 PRZ139.1 PRZ143.1 PRZ155.1 PUA1.15 PUG01.2 PUG01.15 PUH1.7 PUZ2.2 PUZ2.15 PUZ3.2 PUZ3.15 PUZ4.3 PUZ5.2 PUZ5.15 PUZ6.2 PUZ6.15 PUZ7.3 PUZ8.2 PUZ8.15 PUZ9.2 PUZ9.15 PUZ10.3 QE8.3 RE28.1 RE154.1 RE156.1 RE158.1 RE161.2 RG509.1 RG511.1 RG513.1 RG543.1 RG1604.1 RG1606.1 RM91.1 RM92.1 RM93.1 RM94.1 U16.3 U17.1 U17.2 U17.4 U19.3 U20.3 UE12.5 UG36.3 UT4.A11 UT4.B11 UT4.C11 UT4.D11 UT4.H10 UZ21.4 UZ45.4
+5VALW_LED: JIO2.H9 QE8.1
+5VALWP: PC502.1 PC503.1 PC504.1 PC505.1 PC506.1 PC507.1 PJP502.1 PL501.2 PR506.2 PR511.1 PU501.8
+5VL: PJP503.2
+5VS: C256.1 C257.1 CE86.1 CG7096.1 CV23.1 FV3.1 J4.1 JEDP.32 JPK.1 JPK.2 JPK.3 JPK.4 JPK.5 JPTRON.1 JPTRON.7 PCV64.1 PCV67.1 PCV98.1 PCV99.1 PCV128.1 PCV131.1 PCV159.1 PCV161.1 PCW15.1 PCW31.1 PJP2503.1 PR2508.1 PRV5.1 PRV112.2 PRV113.1 PRV134.1 PRV135.1 PRV156.1 PRV157.1 PRV178.1 PRV179.1 PRW37.1 PRW43.1 PRW47.1 PRW53.1 PUV4.15 PUV5.15 PUV6.15 PUV7.15 PUV8.15 PUV9.15 PUV10.15 PUV11.15 PUW2.15 PUW3.15 RF3.2 RF6.2 RX39.1 UG45.4 UV3.16
+12.6V_BATT: PC6.1 PC7.1 PCB5.1 PCB9.1 PCB11.1 PCB12.1 PCB14.1 PCB17.1 PL14.2 PL15.2 PQB17.3 PRB2.4 PRB11.1 PRB26.2
+12.6V_BATT+: PBATT1.8 PBATT1.9 PBATT1.10 PC8.1 PC9.1 PL14.1 PL15.1
+12V_COMP: PR2512.1 PU2502.1
+12V_COMP_1: PC2515.1 PR2512.2
+12V_ENA: PR2507.1 PR2508.2 PU2502.3
+12V_FAN: CF4.1 CF5.1 JFAN1.1 JFAN2.1 PJP2504.2
+12V_FB: PC2514.2 PR2510.1 PR2511.2 PU2502.2
+12V_LX: PD1202.2 PL6124.2 PR2509.1 PU2502.6 PU2502.7
+12V_SNUB: PC2517.1 PR2509.2
+12V_SS: PC2513.1 PU2502.10
+12V_VIN: PC2516.2 PC2518.1 PJP2503.2 PL6124.1 PU2502.8 PU2502.9
+12VP: PC2512.1 PC2514.1 PC2519.1 PD1202.1 PJP2504.1 PR2511.1
+19V_ADPIN: PC1.1 PC2.1 PJPDC1.1 PJPDC1.2 PJPDC1.3 PJPDC1.4 PJPDC1.5 PL11.1 PL12.1
+19V_VIN: PC3.1 PC4.1 PCB34.1 PDB1.3 PL11.2 PL12.2 PQB11.5 PQB13.5 PR31.1 PRB39.1
+19VB: CV15.1 PC301.1 PC311.1 PC501.1 PC514.1 PC1107.1 PC1110.1 PC1815.1 PC1818.1 PCH4.1 PCH6.1 PCH20.1 PCH24.1 PCM10.1 PCM13.1 PCV207.1 PCV208.1 PCZ63.1 PCZ69.1 PJP81.1 PJP301.1 PJP501.1 PJPH01.2 PJPH03.1 PJPM01.1 PL311.1 PL511.1 PL711.1 PL1011.1 PL1811.1 PL6123.1 PLH11.2 PLM11.1 PLW12.1 PLZ11.1 PLZ12.1 PQB15.5 PR308.2 PRB10.4 QV1.4 RV9.1
+19VB_1.0VS_VGAP: PC1106.1 PC1114.1 PC1115.1 PL1011.2 PU1101.2 PU1101.3 PU1101.4
+19VB_1.2V: PCM2.1 PCM4.1 PCM5.1 PCM6.1 PCM7.1 PCM14.1 PJPM01.2 PLM11.2 PQM01.5 PRM18.1
+19VB_1.8VGS: PC1813.1 PC1814.1 PC2508.1 PC2509.1 PL1811.2 PU1802.2 PU1802.3 PU1802.4
+19VB_1VALWP: PCH1.1 PCH2.1 PCH3.1 PCH7.1 PJPH01.1 PLH11.1 PQH01.5
+19VB_3V: PC307.1 PC308.1 PC312.1 PC314.1 PJP301.2 PL311.2 PU301.2 PU301.3 PU301.4
+19VB_5V: PC508.1 PC509.1 PC515.1 PC517.1 PJP501.2 PL511.2 PU501.1
+19VB_CHG: PCB1.1 PCB10.1 PCB13.1 PCB15.1 PCB16.1 PCB25.1 PCB26.1 PCB28.1 PCB29.1 PL711.2 PQB1.5
+19VB_CPU: PCA10.1 PCA11.1 PCG11.1 PCG12.1 PCZ47.1 PCZ48.1 PCZ49.1 PCZ50.1 PCZ52.1 PCZ53.1 PCZ64.1 PCZ68.1 PCZ70.1 PCZ71.1 PCZ74.1 PCZ75.1 PCZ80.1 PCZ81.1 PCZ84.1 PCZ85.1 PCZ86.1 PCZ87.1 PCZ95.1 PCZ96.1 PCZ101.1 PCZ102.1 PCZ103.1 PCZ104.1 PCZ109.1 PCZ110.1 PCZ111.1 PCZ113.1 PCZ114.1 PCZ116.1 PCZ124.1 PCZ126.1 PCZ130.1 PCZ131.1 PCZ132.1 PCZ133.1 PJPG01.1 PJPG02.1 PLZ11.2 PLZ12.2 PRZ39.1 PUZ2.8 PUZ2.9 PUZ3.8 PUZ3.9 PUZ5.8 PUZ5.9 PUZ6.8 PUZ6.9 PUZ8.8 PUZ8.9 PUZ9.8 PUZ9.9
+19VB_VCCGT: PCG01.1 PCG02.1 PCG03.1 PCG04.1 PJPG01.2 PUG01.8 PUG01.9
+19VB_VCCIO: PCH13.1 PCH19.1 PCH25.1 PCH28.1 PJPH03.2 PL6123.2 PUH2.2 PUH2.3 PUH2.4
+19VB_VCCSA: PCA3.1 PCA6.1 PCA7.1 PCA12.1 PJPG02.2 PUA1.8 PUA1.9
+V18R: RE715.1 UE5.N1
+VCC_CORE: PCZ138.1 PCZ139.1 PCZ140.1 PCZ142.1 PCZ143.1 PCZ144.1 PCZ145.1 PCZ146.1 PCZ147.1 PCZ148.1 PCZ149.1 PCZ151.1 PCZ154.1 PCZ155.1 PCZ158.1 PCZ159.1 PCZ162.1 PCZ165.1 PCZ168.1 PCZ169.1 PCZ170.1 PCZ173.1 PCZ176.1 PCZ182.1 PCZ183.1 PCZ184.1 PCZ185.1 PCZ186.1 PCZ187.1 PCZ188.1 PCZ189.1 PCZ190.1 PCZ191.1 PCZ192.1 PCZ193.1 PCZ194.1 PCZ195.1 PCZ196.1 PCZ197.1 PCZ198.1 PCZ199.1 PCZ200.1 PCZ201.1 PCZ202.1 PCZ203.1 PCZ204.1 PCZ205.1 PCZ206.1 PCZ207.1 PCZ208.1 PCZ209.1 PCZ210.1 PCZ211.1 PCZ212.1 PCZ213.1 PCZ214.1 PCZ215.1 PCZ216.1 PCZ217.1 PCZ218.1 PCZ219.1 PCZ220.1 PCZ221.1 PCZ222.1 PCZ223.1 PCZ224.1 PCZ225.1 PCZ226.1 PCZ227.1 PCZ228.1 PCZ229.1 PCZ230.1 PCZ231.1 PCZ232.1 PCZ233.1 PCZ234.1 PCZ235.1 PCZ236.1 PCZ237.1 PCZ238.1 PCZ239.1 PCZ240.1 PCZ241.1 PCZ242.1 PCZ243.1 PCZ244.1 PCZ248.1 PCZ249.1 PLZ01.4 PLZ02.4 PLZ03.4 PLZ04.4 PLZ05.4 PLZ06.4 PRZ29.1 RH197.1 UC1.AA13 UC1.AA31 UC1.AA32 UC1.AA33 UC1.AA34 UC1.AA35 UC1.AA36 UC1.AA37 UC1.AA38 UC1.AB29 UC1.AB30 UC1.AB31 UC1.AB32 UC1.AB35 UC1.AB36 UC1.AB37 UC1.AB38 UC1.AC13 UC1.AC14 UC1.AC29 UC1.AC30 UC1.AC31 UC1.AC32 UC1.AC33 UC1.AC34 UC1.AC35 UC1.AC36 UC1.AD13 UC1.AD14 UC1.AD31 UC1.AD32 UC1.AD33 UC1.AD34 UC1.AD35 UC1.AD36 UC1.AD37 UC1.AD38 UC1.AE13 UC1.AE14 UC1.AE30 UC1.AE31 UC1.AE32 UC1.AE35 UC1.AE36 UC1.AE37 UC1.AE38 UC1.AF29 UC1.AF30 UC1.AF31 UC1.AF32 UC1.AF33 UC1.AF34 UC1.AF35 UC1.AF36 UC1.AF37 UC1.AF38 UC1.AG14 UC1.AG31 UC1.AG32 UC1.AG33 UC1.AG34 UC1.AG35 UC1.AG36 UC1.AH13 UC1.AH14 UC1.AH29 UC1.AH30 UC1.AH31 UC1.AH32 UC1.AJ14 UC1.AJ29 UC1.AJ30 UC1.AJ31 UC1.AJ32 UC1.AJ33 UC1.AJ34 UC1.AJ35 UC1.AJ36 UC1.AK31 UC1.AK32 UC1.AK33 UC1.AK34 UC1.AK35 UC1.AK36 UC1.AK37 UC1.AK38 UC1.AL13 UC1.AL29 UC1.AL30 UC1.AL31 UC1.AL32 UC1.AL35 UC1.AL36 UC1.AL37 UC1.AL38 UC1.AM13 UC1.AM14 UC1.AM29 UC1.AM30 UC1.AM31 UC1.AM32 UC1.AM33 UC1.AM34 UC1.AM35 UC1.AM36 UC1.AN13 UC1.AN14 UC1.AN31 UC1.AN32 UC1.AN33 UC1.AN34 UC1.AN35 UC1.AN36 UC1.AN37 UC1.AN38 UC1.AP13 UC1.AP30 UC1.AP31 UC1.AP32 UC1.AP35 UC1.AP36 UC1.AP37 UC1.AP38 UC1.K13 UC1.K14 UC1.L13 UC1.L14 UC1.N13 UC1.N14 UC1.N30 UC1.N31 UC1.N32 UC1.N35 UC1.N36 UC1.N37 UC1.N38 UC1.P13 UC1.P14 UC1.P29 UC1.P30 UC1.P31 UC1.P32 UC1.P33 UC1.P34 UC1.P35 UC1.P36 UC1.R13 UC1.R31 UC1.R32 UC1.R33 UC1.R34 UC1.R35 UC1.R36 UC1.R37 UC1.R38 UC1.T29 UC1.T30 UC1.T31 UC1.T32 UC1.T35 UC1.T36 UC1.T37 UC1.T38 UC1.U29 UC1.U30 UC1.U31 UC1.U32 UC1.U33 UC1.U34 UC1.U35 UC1.U36 UC1.V13 UC1.V14 UC1.V31 UC1.V32 UC1.V33 UC1.V34 UC1.V35 UC1.V36 UC1.V37 UC1.V38 UC1.W13 UC1.W14 UC1.W29 UC1.W30 UC1.W31 UC1.W32 UC1.W35 UC1.W36 UC1.W37 UC1.W38 UC1.Y29 UC1.Y30 UC1.Y31 UC1.Y32 UC1.Y33 UC1.Y34 UC1.Y35 UC1.Y36
+VCCGT: PCZ161.1 PCZ163.1 PCZ166.1 PCZ167.1 PCZ171.1 PCZ172.1 PCZ174.1 PCZ177.1 PCZ178.1 PCZ179.1 PCZ180.1 PCZ246.1 PLG01.4 PRZ31.2 RH203.2 UC1.AT14 UC1.AT31 UC1.AT32 UC1.AT33 UC1.AT34 UC1.AT35 UC1.AT36 UC1.AT37 UC1.AT38 UC1.AU14 UC1.AU29 UC1.AU30 UC1.AU31 UC1.AU32 UC1.AU35 UC1.AU36 UC1.AU37 UC1.AU38 UC1.AV29 UC1.AV30 UC1.AV31 UC1.AV32 UC1.AV33 UC1.AV34 UC1.AV35 UC1.AV36 UC1.AW14 UC1.AW31 UC1.AW32 UC1.AW33 UC1.AW34 UC1.AW35 UC1.AW36 UC1.AW37 UC1.AW38 UC1.AY29 UC1.AY30 UC1.AY31 UC1.AY32 UC1.AY35 UC1.AY36 UC1.AY37 UC1.AY38 UC1.BA13 UC1.BA14 UC1.BA29 UC1.BA30 UC1.BA31 UC1.BA32 UC1.BA33 UC1.BA34 UC1.BA35 UC1.BA36 UC1.BB13 UC1.BB14 UC1.BB31 UC1.BB32 UC1.BB33 UC1.BB34 UC1.BB35 UC1.BB36 UC1.BB37 UC1.BB38 UC1.BC29 UC1.BC30 UC1.BC31 UC1.BC32 UC1.BC35 UC1.BC36 UC1.BC37 UC1.BC38 UC1.BD13 UC1.BD14 UC1.BD29 UC1.BD30 UC1.BD31 UC1.BD32 UC1.BD33 UC1.BD34 UC1.BD35 UC1.BD36 UC1.BE31 UC1.BE32 UC1.BE33 UC1.BE34 UC1.BE35 UC1.BE36 UC1.BE37 UC1.BE38 UC1.BF13 UC1.BF14 UC1.BF29 UC1.BF30 UC1.BF31 UC1.BF32 UC1.BF35 UC1.BF36 UC1.BF37 UC1.BF38 UC1.BG29 UC1.BG30 UC1.BG31 UC1.BG32 UC1.BG33 UC1.BG34 UC1.BG35 UC1.BG36 UC1.BH33 UC1.BH34 UC1.BH35 UC1.BH36 UC1.BH37 UC1.BH38 UC1.BJ16 UC1.BJ17 UC1.BJ19 UC1.BJ20 UC1.BJ21 UC1.BJ23 UC1.BJ24 UC1.BJ26 UC1.BJ27 UC1.BJ37 UC1.BJ38 UC1.BK16 UC1.BK17 UC1.BK19 UC1.BK20 UC1.BK21 UC1.BK23 UC1.BK24 UC1.BK26 UC1.BK27 UC1.BL15 UC1.BL16 UC1.BL17 UC1.BL23 UC1.BL24 UC1.BL25 UC1.BL26 UC1.BL27 UC1.BL28 UC1.BL36 UC1.BL37 UC1.BM15 UC1.BM16 UC1.BM17 UC1.BM36 UC1.BM37 UC1.BN15 UC1.BN16 UC1.BN17 UC1.BN36 UC1.BN37 UC1.BN38 UC1.BP15 UC1.BP16 UC1.BP17 UC1.BP37 UC1.BP38 UC1.BR15 UC1.BR16 UC1.BR17 UC1.BR37 UC1.BT15 UC1.BT16 UC1.BT17 UC1.BT37
+VCCIO: CH102.1 CH103.1 CH104.1 PJPH04.2 RC2.1 RC30.2 UC1.AG12 UC1.G15 UC1.G17 UC1.G19 UC1.G21 UC1.H15 UC1.H16 UC1.H17 UC1.H19 UC1.H20 UC1.H21 UC1.H26 UC1.H27 UC1.J15 UC1.J16 UC1.J17 UC1.J19 UC1.J20 UC1.J21 UC1.J26 UC1.J27
+VCCIOP: PCH14.1 PCH15.1 PCH16.1 PCH17.1 PCH26.1 PJPH04.1 PLH02.2 PRH16.1
+VCCRTCEXT: UH1.BF47 UH1.BG47
+VCCSA: PCZ141.1 PCZ150.1 PCZ152.1 PCZ153.1 PCZ156.1 PCZ157.1 PCZ160.1 PCZ164.1 PCZ175.1 PCZ181.1 PLG02.4 PRZ30.1 RH201.2 UC1.J30 UC1.K29 UC1.K30 UC1.K31 UC1.K32 UC1.K33 UC1.K34 UC1.K35 UC1.L31 UC1.L32 UC1.L35 UC1.L36 UC1.L37 UC1.L38 UC1.M29 UC1.M30 UC1.M31 UC1.M32 UC1.M33 UC1.M34 UC1.M35 UC1.M36
+VCCST: C6.1 C8.1 CC39.1 CH106.1 CH107.1 PCZ10.2 PRZ6.1 PRZ7.1 PRZ35.2 PRZ73.1 RC693.1 RH151.1 RH152.1 RH156.1 RH163.1 RH164.1 RH613.2 U19.6 UC1.H28 UC1.H30 UC1.J28
+VCCST_PECI: CE171.1 RH613.1 UE5.H4
+VCCSTG: C10.1 CH105.1 RH165.1 RH494.1 RH495.1 RH496.1 U20.6 UC1.G30 UC1.H29
+VDDA: CE7.1 CE169.1 LE4.2 UE1.9
+VIN_DGPU: PCV27.1 PCV28.1 PCV29.1 PCV32.1 PCV44.1 PCV213.1 PCV242.1 PCV243.1 PCV244.1 PCV245.1 PJP81.2 PQV3.3 PQV3.4 PQV3.9 PQV4.3 PQV4.4 PQV4.9 PRV83.2 PRV84.2 PRV88.1 PRV97.2 PRV109.1
