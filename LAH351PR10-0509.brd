# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C_0_SCL: length 79.5
  TOP w0.081: v8(117.54,37.13) 117.62,37.22 v13(118.78,37.22) 119.29,37.22 119.68,36.83 119.98,36.83 120.12,36.69 RPC7.2
  TOP w0.089: v5(103.59,24.56) 103.79,24.77 103.79,25.43 103.7,25.52 103.48,25.52 103.21,25.78 103.21,27.11 103.2,27.13 UH1.BC22
  IN1 w0.058: v8(117.54,37.13) 117.45,37.23 117.26,37.23 117.26,37.23 117.24,37.23
  IN1 w0.089: v5(103.59,24.56) 103.76,24.39 103.76,24.3 103.61,24.15 103.36,24.15 103.19,24.32 103.19,24.54 102.93,24.79 102.93,25.74 103.06,25.87 103.06,26.36 103.05,26.37 103.05,28.75 104.4,30.1 104.4,31.14 104.31,31.23 104.31,32.52 104.83,33.03 104.83,34.24 105.04,34.45 107.63,34.45 109.91,36.73 116.14,36.73 116.64,37.23 117.24,37.23
  IN3 w0.058: v9(83.11,4.22) 83.19,4.29 83.19,4.73 82.98,4.94 81.45,4.94 81.23,5.15 81.23,7.21 v9(81.15,7.29)
  GND4 w0.081: v9(83.11,4.22) 83.15,4.26 83.15,4.52 v4(83.13,4.54) ; v6(81.28,7.65) 81.28,7.42 v9(81.15,7.29)
  IN4 w0.058: 106.24,22.69 106.24,22.68 106.23,22.67 106.23,22.27 103.96,20 100.86,20 100.71,19.85 99.85,19.85 99.31,19.31 98.15,19.31 97.13,20.33 94.22,20.33 92.39,18.5 91.03,18.5 89.65,17.13 89.65,14.24 89.14,13.72 88.28,13.72 87.2,12.64 87.2,11.78 85.98,10.56 84.97,10.56 84.14,9.73 84.14,8.61 83.84,8.32 82.73,8.32 82.49,8.08 81.71,8.08 v6(81.28,7.65)
  IN4 w0.089: 106.24,22.69 106.24,23.02 105.78,23.47 104.38,23.47 103.79,24.06 103.79,24.36 v5(103.59,24.56)
  BOTTOM w0.081: v4(83.13,4.54) 83.21,4.47 83.21,4 83.2,4 83.2,3.5 83.21,3.5 83.21,3.29 82.63,2.71 82.3,2.71 RE71.1
I2C_0_SCL_R: length 27.4
  TOP w0.081: JTP17.3 61.96,5.93 61.9,5.87 61.9,5.22 63.19,3.93 67.96,3.93 68.7,4.68 70.65,4.68 v13(72,3.33) 72.38,2.95 73.39,2.95 73.39,2.95 73.86,2.95 73.86,2.95 74.09,2.95 74.35,3.21 78.49,3.21 78.81,3.53 78.81,3.92 78.66,4.06 JTP15.6 78.66,5.05 78.81,5.2 78.81,5.45 79.01,5.65 79.9,5.65 80.22,5.33 80.22,3.7 80.31,3.61 v4(80.39,3.61)
  BOTTOM w0.081: v4(80.39,3.61) 80.21,3.43 80.21,2.83 80.44,2.61 80.67,2.61 80.75,2.69 80.75,2.8 80.83,2.89 RE71.2
I2C_0_SDA: length 79.5
  TOP w0.081: RPC7.1 120.15,37.19 120.01,37.04 119.77,37.04 119.38,37.43 119.11,37.43 119.11,37.43 118.46,37.43 118.45,37.43 117.62,37.43 v8(117.54,37.52)
  TOP w0.089: v5(104.17,24.56) 103.97,24.77 103.97,25.5 103.78,25.69 103.55,25.69 103.39,25.85 103.39,26.02 103.49,26.11 UH1.BF23
  IN1 w0.058: v8(117.54,37.52) 117.44,37.41 117.34,37.41 117.34,37.42 117.24,37.42
  IN1 w0.089: v5(104.17,24.56) 103.94,24.33 103.94,24.22 103.68,23.97 103.29,23.97 103.01,24.25 103.01,24.47 102.76,24.72 102.76,25.82 102.88,25.95 102.88,26.28 102.87,26.29 102.87,28.83 104.22,30.18 104.22,31.06 104.13,31.15 104.13,32.59 104.65,33.11 104.65,34.31 104.96,34.63 107.56,34.63 109.84,36.91 116.07,36.91 116.57,37.41 117.24,37.41 117.24,37.42
  IN3 w0.058: v9(83.49,4.24) 83.37,4.36 83.37,4.81 83.06,5.12 81.53,5.12 81.42,5.23 81.42,7.15 v9(81.53,7.27)
  GND4 w0.081: v4(83.54,4.55) 83.52,4.53 83.52,4.27 v9(83.49,4.24) ; v6(81.65,7.53) 81.65,7.39 v9(81.53,7.27)
  IN4 w0.058: 106.41,22.69 106.41,22.68 106.42,22.67 106.42,22.19 104.04,19.81 100.94,19.81 100.79,19.66 99.92,19.66 99.39,19.13 98.07,19.13 97.05,20.14 94.29,20.14 92.47,18.32 91.1,18.32 89.84,17.05 89.84,14.16 89.21,13.53 88.36,13.53 87.39,12.56 87.39,11.71 86.06,10.38 85.05,10.38 84.33,9.65 84.33,8.54 83.92,8.13 82.8,8.13 82.57,7.89 82.02,7.89 v6(81.65,7.53)
  IN4 w0.089: v5(104.17,24.56) 103.97,24.36 103.97,24.14 104.46,23.65 105.85,23.65 106.41,23.09 106.41,22.69
  BOTTOM w0.081: RE653.1 82.22,2.12 82.6,2.5 82.71,2.5 83.41,3.2 v13(83.41,3.75) 83.41,4.42 v4(83.54,4.55)
I2C_0_SDA_R: length 27.7
  TOP w0.081: v4(79.86,3.61) 79.92,3.61 80.01,3.7 80.01,5.25 79.81,5.45 79.1,5.45 79.01,5.36 79.01,5.3 79.16,5.16 JTP15.7 79.16,4.06 79.01,3.92 79.01,3.44 78.58,3 74.44,3 74.18,2.74 v13(73.62,2.74) 72.29,2.74 72.01,3.02 72.01,3.02 71.68,3.35 71.68,3.35 70.56,4.47 68.79,4.47 68.05,3.72 63.11,3.72 61.72,5.11 61.72,5.86 61.66,5.93 JTP17.2
  BOTTOM w0.081: v4(79.86,3.61) 80,3.46 80,2.75 80.35,2.4 80.67,2.4 80.75,2.32 80.75,2.2 80.83,2.12 RE653.2
I2C_CLK: length 211.5
  IN3 w0.058: 117.24,26.44 118.49,26.44 118.61,26.57 119.71,26.57 119.93,26.34 121.1,26.34 121.23,26.47 121.23,26.56 121.07,26.72 v4(120.98,26.72) ; v6(81.87,92.85) 82.06,92.66 83.22,92.66 83.28,92.72 83.28,96.42 76.46,103.25 76.46,113.7 70.68,119.47 70.68,120.66 68.46,122.88 67.33,122.88 64.2,126.01 64.2,138.78 57.59,145.39 47.37,145.39 46.41,146.36 36.82,146.36 36.74,146.44 36,146.44 35.94,146.38 v3(35.94,146.17) ; 113.83,22.69 113.83,22.49 113.84,22.48 113.84,19.3 113.12,18.58 105.83,18.58 105.3,18.05 105.3,17.88 v4(105.11,17.69)
  IN3 w0.089: 113.83,22.69 113.83,22.77 113.84,22.78 113.84,23.62 116.66,26.44 117.24,26.44
  IN4 w0.058: 117.24,26.25 117.26,26.25 117.26,26.25 120.94,26.25 121.27,26.58 121.27,26.66 121.21,26.72 v4(120.98,26.72) ; v6(81.87,92.85) 82.2,92.52 82.2,71.75 82.58,71.37 82.58,63.73 82.83,63.49 82.83,46.1 85.02,43.91 88.5,43.91
  IN4 w0.089: 88.5,43.91 89.72,43.91 90.74,42.89 92.83,42.89 98.18,37.54 100.91,37.54 101.4,37.06 101.4,35.66 101.86,35.19 102.46,35.19 102.72,35.46 103.94,35.46 104.2,35.19 107.39,35.19 108.33,34.25 108.33,33.49 109.6,32.22 109.6,28.98 112.59,26 114.17,26 114.42,26.25 117.24,26.25
  BOTTOM w0.081: UE1.42 121.94,25.82 121.56,26.2 121.5,26.2 121.32,26.37 121.32,26.38 v4(120.98,26.72) ; UE8.25 105.07,17.48 105.13,17.54 105.13,17.67 v4(105.11,17.69)
I2C_DAT: length 212.7
  IN3 w0.058: 117.24,26.25 118.56,26.25 118.69,26.38 119.63,26.38 119.86,26.16 121.18,26.16 121.74,26.72 v4(121.74,26.72) ; 114.02,22.69 114.02,22.56 114.03,22.55 114.03,22.5 114.02,22.49 114.02,19.22 113.2,18.4 105.91,18.4 105.48,17.97 105.48,17.85 v4(105.64,17.69) ; v3(35.31,146.17) 35.76,146.62 36.82,146.62 36.9,146.54 46.48,146.54 47.45,145.58 57.67,145.58 64.39,138.86 64.39,126.09 67.41,123.07 68.53,123.07 70.87,120.74 70.87,119.55 76.64,113.77 76.64,103.32 83.46,96.5 83.46,92.64 83.3,92.48 82.05,92.48 v6(81.87,92.29)
  IN3 w0.089: 117.24,26.25 116.72,26.25 114.02,23.55 114.02,22.69
  IN4 w0.058: v4(121.74,26.72) 121.51,26.72 121.46,26.66 121.46,26.5 121.02,26.07 117.26,26.07 117.26,26.07 117.24,26.07 ; 88.5,43.72 84.95,43.72 82.64,46.03 82.64,63.41 82.4,63.65 82.4,71.29 82.02,71.67 82.02,92.15 v6(81.87,92.29)
  IN4 w0.089: 88.5,43.72 89.66,43.72 90.67,42.71 92.76,42.71 98.11,37.37 100.84,37.37 101.22,36.98 101.22,35.59 101.79,35.02 102.53,35.02 102.8,35.28 103.86,35.28 104.13,35.02 107.32,35.02 108.15,34.18 108.15,33.42 109.42,32.15 109.42,28.91 112.51,25.82 114.25,25.82 114.5,26.07 117.24,26.07
  BOTTOM w0.081: UE1.43 122.44,25.82 122.06,26.2 121.9,26.2 121.62,26.48 121.62,26.6 v4(121.74,26.72) ; UE8.26 105.57,17.63 v4(105.64,17.69)
I2C_INT: length 14.8
  TOP w0.076: UE5.A1 77.16,10.8 v6(77.16,10.8)
  IN4 w0.058: v7(71.37,10.34) 71.48,10.34 71.6,10.47 76.45,10.47 76.58,10.59
  IN4 w0.076: v7(80.45,11.08) 79.99,10.62 77.65,10.62 77.47,10.8 v6(77.16,10.8) 77.11,10.8 77.01,10.7 76.68,10.7 76.58,10.59
  BOTTOM w0.076: v7(80.45,11.08) 80.45,10.57
  BOTTOM w0.081: 80.45,10.57 80.45,10.49 RE656.2 ; v7(71.37,10.34) v2(69.77,8.73) 69.45,8.42 JPK.15
I2CC_SCL: length 20.2
  TOP w0.081: QG7.4 61.52,90.35 61.95,90.78 62.36,90.78 v6(62.76,91.19) 63.83,91.19 RG28.1 64,90.16 v2(63.83,89.99)
  IN4 w0.058: v6(55.45,88.75) 55.65,88.75 55.71,88.69 55.71,86.55 56.69,85.57 62.95,85.57 63.3,85.92 63.3,89.7 62.67,90.32 62.67,90.71 62.79,90.83 62.79,91.16 v6(62.76,91.19)
I2CC_SDA: length 18.1
  TOP w0.081: v6(62.23,91.21) 62.23,91.58 QG7.1 63.54,92.16 63.7,92 63.84,92 RG29.1
  IN4 w0.058: v6(62.23,91.21) 62.48,90.96 62.48,90.25 63.11,89.62 63.11,85.99 62.87,85.75 56.77,85.75 55.89,86.63 55.89,88.69 55.95,88.75 v6(56.15,88.75)
IDLE_IN_SW: length 9
  TOP w0.081: RG1504.1 54.79,79.42 54.3,79.9 53.74,79.9 53.25,79.41 52.96,79.41 52.62,79.75 52.62,79.79 51.25,81.16 51.25,82.73 51.54,83.03 51.54,84.25 UG1.BA3
IFPAB_RSET: length 14.6
  TOP w0.081: v8(53.34,93.8) 53.72,94.19 53.72,97.82 53.35,98.19 UG1.BD23 ; v8(60.27,93.96) 60.92,93.31 v2(61.08,93.31) 61.11,93.31 61.39,93.58 61.39,93.81 RG1502.1
  IN1 w0.058: v8(60.27,93.96) 60.25,93.93 56.59,93.93 56.21,93.55 54.78,93.55 54.39,93.93 53.47,93.93 v8(53.34,93.8)
IFPCD_RSET: length 11.1
  TOP w0.081: RG1499.1 61.43,95.85 v8(60.25,94.67) ; v8(53.04,94.67) 53.04,95.89 53.35,96.2 UG1.BD20
  IN1 w0.058: 53.97,94.67 v8(53.04,94.67) ; v8(60.25,94.67) 54.81,94.67
  IN1 w0.089: 54.81,94.67 53.97,94.67
IFPEF_RSET: length 9.3
  TOP w0.081: RG1500.1 61.09,95.02 60.83,94.77 60.73,94.77 60.27,94.31 v8(60.25,94.31)
  IN1 w0.058: v8(60.25,94.31) 60.25,94.34 58.12,94.34 57.87,94.09 56.52,94.09 56.14,93.71 54.84,93.71 54.46,94.09 53.61,94.09 v8(53.35,94.35)
ILIM_1.0VS_VGAP: length 6
  BOTTOM w0.081: PR1103.1 67.25,102.06 v2(67.25,100.79)
  BOTTOM w0.254: PR1103.1 PR1104.1 67.53,103.09 68.39,103.09 68.96,103.66 68.96,104.32 69.22,104.58 PU1101.10
ILIM_1PH: length 4.2
  TOP w0.203: PUZ1.49 147.26,129.05 v5(147.35,129.14) 147.73,129.14 147.93,128.93 PCZ24.2
  BOTTOM w0.081: v2(149.16,127.68) 148.16,128.68 PRZ1.2
  BOTTOM w0.254: v5(147.35,129.14) 147.56,129.14 148.02,128.68 PRZ1.2
ILIM_2PH: length 2.1
  TOP w0.203: PUZ1.32 142.92,123.99 142.56,123.63 PRZ50.1
ILIM_4PH: length 1.7
  TOP w0.203: PUZ1.7 PRZ69.2
ILIM_VCCIO: length 5.4
  TOP w0.081: PRH15.1 v2(138.23,56.25)
  TOP w0.254: PUH2.10 135.38,54.06 135.64,54.32 137.49,54.32 137.62,54.45 PRH14.1 PRH15.1
IMON1_NVVDD: length 77
  TOP w0.254: PLV01.3 v5(27.66,51.62)
  IN4 w0.152: v4(77.79,21.8) 77.79,21.36 75.95,19.52 69.91,19.52 68.58,20.86 68.58,22.7 66.87,24.41 66.87,29.81 65.34,31.33 65.34,36.48 64.83,36.98 58.04,36.98 55.5,39.52 50.48,39.52 49.21,40.79 38.16,40.79 37.08,41.87 37.08,44.73 37.66,45.3 37.66,46.57 37.27,46.95 34.23,46.95 29.44,51.74 27.79,51.74 v5(27.66,51.62)
  BOTTOM w0.081: v5(27.66,51.62) v2(28.37,51.62)
IMON2_NVVDD: length 67.7
  TOP w0.254: PLV02.3 v5(35.22,51.55)
  IN4 w0.152: v4(76.77,21.8) 76.77,21.43 75.37,20.03 70.12,20.03 69.09,21.07 69.09,22.91 67.37,24.62 67.37,30.02 66.1,31.29 66.1,36.69 65.17,37.62 58.55,37.62 56.05,40.12 54.72,40.12 53.75,41.09 53.75,42.05 52.13,43.66 52.13,44.6 52.77,45.24 52.77,46.64 52.39,47.02 41.4,47.02 36.72,51.7 35.37,51.7 v5(35.22,51.55)
  BOTTOM w0.081: v5(35.22,51.55) v2(35.94,51.55)
IMON3_NVVDD: length 58.7
  TOP w0.254: v5(42.87,51.49) 42.87,50.77 PLV03.3
  IN4 w0.152: v5(42.87,51.49) 43.04,51.65 43.91,51.65 48.04,47.53 53.42,47.53 53.57,47.37 53.57,43.7 54.25,43.02 54.25,41.3 54.93,40.63 56.28,40.63 58.72,38.19 65.45,38.19 66.8,36.84 66.8,31.31 67.88,30.23 67.88,24.83 69.6,23.12 69.6,21.28 70.34,20.54 74.87,20.54 75.76,21.43 v4(75.76,21.8)
  BOTTOM w0.081: v5(42.87,51.49) v2(43.65,51.49)
IMON4_NVVDD: length 51.3
  TOP w0.254: PLV04.3 v5(50.6,51.55)
  IN4 w0.152: v4(74.74,21.8) 73.99,21.05 70.55,21.05 70.1,21.49 70.1,23.33 68.39,25.04 68.39,30.44 67.5,31.33 67.5,37.17 65.91,38.76 58.86,38.76 56.49,41.14 55.14,41.14 54.76,41.51 54.76,43.23 54.17,43.82 54.17,50.64 53.09,51.72 50.76,51.72 v5(50.6,51.55)
  BOTTOM w0.081: v5(50.6,51.55) 51.23,51.55 v2(51.3,51.49)
IMON5_NVVDD: length 54.1
  TOP w0.081: PRV15.2 73.72,21.85 v1(74.09,22.22)
  TOP w0.254: PLV05.3 58.32,51.68 v5(58.67,52.03)
  IN1 w0.152: v5(58.67,52.03) 58.8,51.91 64.26,51.91 65.15,51.02 71.99,51.02 76.07,46.93 76.07,44.12 75.18,43.23 75.18,35.69 78.11,32.77 78.11,31.88 79.44,30.55 79.44,23.55 78.58,22.68 74.55,22.68 v1(74.09,22.22)
  GND2 w0.081: v4(73.72,21.92) 73.79,21.92 v1(74.09,22.22)
  BOTTOM w0.081: v2(59.25,51.44) 58.67,52.01 v5(58.67,52.03)
IMON6_NVVDD: length 49.1
  TOP w0.081: v4(72.71,21.8) v2(72.71,20.72)
  TOP w0.254: PLV06.3 66.11,51.79 v5(66.42,52.1)
  IN1 w0.152: v4(72.71,21.8) 73.06,21.8 73.38,21.48 74.92,21.48 75.58,22.14 78.92,22.14 80.14,23.35 80.14,31.78 75.76,36.16 75.76,43.04 76.71,43.99 76.71,47.08 72.07,51.72 66.8,51.72 v5(66.42,52.1)
IMON7_NVVDD: length 82.2
  TOP w0.254: PLV07.3 73.9,51.64 v5(74.3,52.03)
  IN1 w0.152: v4(71.69,21.8) 71.69,21.39 72.11,20.97 75.26,20.97 75.52,21.22 78.37,21.22 78.78,21.63 79.13,21.63 80.64,23.14 80.64,23.5 80.77,23.63 80.77,33.05 78.17,35.65 77.15,35.65 76.26,36.54 76.26,42.79 77.34,43.86 77.34,47.25 75.88,48.71 75.88,51.26 75.1,52.03 v5(74.3,52.03)
  IN4 w0.254: v4(71.69,21.8) 72.16,22.27 72.16,24.06 72.54,24.44 72.54,26.57 72.06,27.05 72.06,32.11 70.44,33.73 70.05,33.73 69.02,34.77 69.02,35.24 70.03,36.25 70.95,36.25 74.87,40.16 74.87,43.4 75.76,44.29 75.76,47.02 74.87,47.91 74.87,51.21 74.3,51.78 v5(74.3,52.03)
  BOTTOM w0.081: v5(74.3,52.03) v2(74.98,52.03)
IMON8_NVVDD: length 72.5
  TOP w0.254: PLV08.3 v5(76.01,84.04)
  IN3 w0.254: v5(76.01,84.04) 75.91,83.94 75.91,81.98 77.95,79.93 77.95,72.27 75.98,70.3 75.98,47.4 77.33,46.05 77.33,43.73 77.94,43.13 77.94,36.35 77.4,35.82 73.74,35.82 71.56,33.64 71.56,28.79 70.99,28.22 70.99,25.76 71.22,25.53 71.22,22.34 v4(70.68,21.8)
IMON_1PH: length 3.7
  TOP w0.203: v5(147.35,127.99) 147.29,127.99 147.19,127.89 146.96,127.89 146.94,127.87 146.91,127.87 146.9,127.85 PUZ1.46
  BOTTOM w0.254: PCZ21.2 PRZ67.2 147.35,128.48 v5(147.35,127.99)
IMON_GPU: length 5.1
  TOP w0.203: PUV1.25 77.81,28.7 v5(78.11,28.41) 78.74,27.78 PRV67.2
  BOTTOM w0.081: v2(76.67,29.56) 76.86,29.56 77.29,29.12 PCV8.1
  BOTTOM w0.254: PCV8.1 77.91,28.54 78.04,28.41 v5(78.11,28.41)
IMVP_VR_ON: length 215.5
  TOP w0.081: v8(143.19,119.8) 143.97,119.03 148.23,119.03 149.52,120.31 149.52,126.05 149.05,126.52 PRZ20.2 ; v1(78.46,113.08) 78.26,112.88 v2(78.26,112.3) 78.26,109.63 79.25,108.64 79.25,105.29 83.29,101.24 83.29,88.42 84.18,87.54 84.18,75.73 80.77,72.32 80.77,69.85 v8(80.49,69.57) ; v8(85.47,35.18) 84.89,34.6 84.89,34.24 84.79,34.14 Q7.6 84.5,34.14 83.77,34.87 83.77,43.2 82.02,44.95 82.02,45.18 82.02,45.18 82.02,52.75 80.1,54.67 80.1,60.21 80.84,60.95 80.84,67.65 80.64,67.85 v8(80.64,67.91)
  IN1 w0.058: v8(143.19,119.8) 143.19,119.33 140.74,116.87 140.74,113.87 138.72,111.86 138.72,111.19 138.53,111 138.53,109.82 137.85,109.14 137.85,108.63 v11(137.86,108.61) ; v1(87.05,12.73) 87.27,12.96 87.27,13.5 86.32,14.46 86.32,16.03 85.24,17.11 85.24,20.96 85.75,21.47 85.75,34.9 v8(85.47,35.18) ; v8(80.49,69.57) 80.49,68.06 v8(80.64,67.91)
  GND2 w0.076: v3(81.08,13.41) 81.03,13.36 v1(80.67,13.36)
  GND2 w0.081: v3(85.8,12.7) 86.67,12.7 86.7,12.73 v1(87.05,12.73) ; v1(78.46,113.08) 78.56,113.18 v12(78.74,113.18) ; v12(138.12,108.61) v11(137.86,108.61)
  IN2 w0.058: v12(138.12,108.61) 138.4,108.61 138.89,109.1 138.89,110.21 137.85,111.25 137.85,112.82 136.5,114.18 114.63,114.18 113.47,115.34 102.89,115.34 100.94,113.39 95.91,113.39 95.4,112.88 81.81,112.88 81.57,112.64 80.17,112.64 79.62,113.18 v12(78.74,113.18)
  GND4 w0.076: v3(81.08,13.41) 81.05,13.39 v6(80.72,13.39)
  GND4 w0.081: v6(85.42,12.78) 85.43,12.79 85.72,12.79 85.8,12.71 v3(85.8,12.7)
  IN4 w0.058: v6(85.42,12.78) 84.73,12.09 84.2,12.09
  IN4 w0.076: 84.2,12.09 83.81,12.09 83.27,11.56 83.27,11.13 82.83,10.68 81.78,10.68 81.38,11.08 81.38,12.73 v6(80.72,13.39)
INTRUDER#: length 6.5
  TOP w0.254: v5(114.36,28.27) 114.19,28.09 UH1.BB44
  BOTTOM w0.254: RH531.1 118,26.25 116.2,26.25 115.83,26.63 v10(115.83,27.08) 115.83,27.83 115.33,28.34 114.43,28.34 v5(114.36,28.27)
ISEN1N_CHG: length 15.9
  TOP w0.254: PRB2.3 26.7,11.06 v5(26.31,11.45)
  BOTTOM w0.254: PRB21.2 39.92,11.59 39.32,11.59 v13(39,11.28) 38.44,10.71 36.99,10.71 36.69,11.01 27.45,11.01 27.45,11.01 27.29,11.01 27.27,10.99 26.89,10.99 26.8,11.08 26.68,11.08 v5(26.31,11.45)
ISEN1P_CHG: length 14.7
  TOP w0.254: v5(27.08,11.45) 26.95,11.45 26.7,11.7 PRB2.2
  BOTTOM w0.254: PRB8.2 40.09,11.93 40.07,11.94 39.17,11.94 38.3,11.08 v13(37.55,11.08) 37.13,11.08 36.84,11.37 27.3,11.37 27.3,11.37 27.15,11.37 v5(27.08,11.45)
ISH_GP1: length 38.4
  TOP w0.089: UH1.BD34 109.27,27.51 v5(109.41,27.65)
  IN3 w0.058: 84.2,12.42 84.2,12.42 84.2,13.52 85.24,14.55 86.6,14.55 86.79,14.36 91.02,14.36 93.11,16.46 93.11,16.86 93.11,17 93.81,17.69 94.2,18.08 96.87,18.08 97.33,18.54 99.59,18.54 100.2,19.15 101.18,19.15 104,21.97 107.88,21.97 108.6,22.69
  IN3 w0.076: 84.2,12.42 83.95,12.16 82.97,12.16 v3(82.67,11.86)
  IN3 w0.089: 108.6,22.69 108.67,22.76 108.67,24.43 109.16,24.91 109.16,25.49 108.78,25.87 108.78,26.82 109.41,27.46 v5(109.41,27.65)
  BOTTOM w0.089: v2(109.73,27.02) 109.41,27.33 v5(109.41,27.65)
ISH_I2C0_SCL: length 184.8
  TOP w0.089: v5(113.89,34.65) 113.91,34.67 113.96,34.67 114.49,35.2 UH1.AG45
  IN2 w0.058: v6(78.33,107.39) 78.51,107.57 78.51,107.74 78.45,107.8 76.79,107.8 76.42,107.42 69.23,107.42 66.58,110.07 64.33,110.07 60.01,114.39 60.01,119.15 60.68,119.83 60.68,121.09 60.34,121.44 60.34,138.18 58.28,140.24 50.72,140.24 50.41,140.56 46.24,140.56 45.21,139.52 45.21,138.91 44.17,137.87 42.18,137.87 39.18,140.87 29.92,140.87 28.95,139.9 28.95,137.68 28.41,137.14 26.32,137.14 26.24,137.05 26.24,136.3 26.36,136.17 v5(26.41,136.17)
  IN4 w0.058: 94.54,49.05 94.48,49.05 94.47,49.04 94.45,49.04 94.44,49.05 93.04,49.05 90.29,51.79 90.29,52 86.89,55.39 86.89,72.57 84.47,75 84.47,98.81 78.49,104.79 78.49,107.24 v6(78.33,107.39)
  IN4 w0.089: v5(113.89,34.65) 114.1,34.87 114.1,34.99 114.1,35.41 113.87,35.64 113.87,36.85 113.61,37.1 113.61,38.88 112.94,39.55 111.15,39.55 109.01,41.69 109.01,41.96 107.91,43.06 106.5,43.06 103.98,45.57 103.05,45.57 100.76,47.86 98.61,47.86 97.41,49.05 94.54,49.05
  BOTTOM w0.081: v5(26.41,136.17) 26.28,136.03 26.28,135.55 26.07,135.35 25.77,135.35 25.43,135.01 JGYRO.4
ISH_I2C0_SDA: length 185.7
  TOP w0.081: v5(25.83,136.17) v2(25.83,137.06)
  TOP w0.089: UH1.AH46 114.9,34.98 114.74,34.83 114.58,34.83 114.48,34.72 v5(114.48,34.67)
  IN2 w0.058: v5(25.83,136.17) 26.05,136.4 26.05,137.13 26.25,137.32 28.33,137.32 28.77,137.75 28.77,139.98 29.84,141.06 39.26,141.06 42.26,138.06 44.09,138.06 45.02,138.99 45.02,139.6 46.16,140.74 50.48,140.74 50.8,140.43 58.36,140.43 60.52,138.26 60.52,121.52 60.87,121.17 60.87,119.75 60.2,119.08 60.2,114.47 64.41,110.26 66.66,110.26 69.31,107.61 76.34,107.61 76.72,107.99 78.53,107.99 78.7,107.82 78.7,107.56 v6(78.87,107.39)
  IN4 w0.058: v6(78.87,107.39) 78.68,107.2 78.68,104.86 84.65,98.89 84.65,75.08 87.08,72.65 87.08,55.47 90.47,52.07 90.47,51.87 93.11,49.23 94.52,49.23 94.52,49.23 94.54,49.23
  IN4 w0.089: 94.54,49.23 97.49,49.23 98.68,48.03 100.84,48.03 103.12,45.75 104.06,45.75 106.57,43.23 107.99,43.23 109.19,42.03 109.19,41.76 111.22,39.73 113.02,39.73 113.79,38.95 113.79,37.18 114.05,36.92 114.05,35.71 114.28,35.48 114.28,34.99 114.28,34.87 v5(114.48,34.67)
  BOTTOM w0.081: JGYRO.5 25.53,135.81 25.78,135.56 25.99,135.56 26.07,135.64 26.07,135.93 v5(25.83,136.17)
ISL95338_N003: length 1
  BOTTOM w0.203: PCV22.1 58.62,26.38 58.57,26.43 PRV105.2
ISL95338_SCL: length 2.5
  BOTTOM w0.081: PRV197.2 60.24,31.38 60,31.38 59.88,31.26 59.88,31.25 59.53,30.9 59.53,30.9 59.31,30.69 59.11,30.69 59.01,30.59 PUV3.22
ISL95338_SDA: length 2.5
  BOTTOM w0.081: PUV3.21 59.01,30.99 59.11,30.89 59.22,30.89 v13(59.55,31.23) 59.92,31.59 60.14,31.59 PRV196.2
IST_TRIG: length 8.2
  TOP w0.081: UC1.E3 99.01,85.74 99.53,85.74 99.77,85.5 v8(99.77,85.17)
  IN1 w0.058: v8(95.47,80.6) 95.65,80.78 95.67,80.78 96.16,81.27 96.44,81.27 98.73,83.56 98.73,84.13 v8(99.77,85.17)
JRTC1: length 83.2
  TOP w0.081: v5(19.89,10.99) 19.66,10.99 19.38,10.71 v2(19.32,10.71) 18.91,10.71 18.63,10.43 PR2.2
  TOP w0.254: PR2.2 18.29,9.1 PD4.2
  IN3 w0.058: v9(82.65,20.78) 82.55,20.68 80.15,20.68 79.94,20.89 78.98,20.89 78.69,20.6 75.37,20.6 73.48,18.71 73.48,17.56 74.2,16.84 74.2,16.56 74,16.36 74,15.85 74.16,15.7 74.16,12.21 73.16,11.22 73.16,9.93 72.73,9.5 70.78,9.5 69.44,8.17 68.58,8.17 67.37,6.96 63.89,6.96 62.06,8.79 59.46,8.79 58.46,9.79 56.91,9.79 55.11,11.59 50.12,11.59 49.51,12.2 39.82,12.2 38.55,10.93 27.88,10.93 27.69,10.74 26.95,10.01 22.5,10.01 21.52,10.99 v5(19.89,10.99)
  GND4 w0.081: v4(82.96,21.08) v9(82.65,20.78)
  BOTTOM w0.081: QH98.2 83.15,22.58 83.15,21.28 v4(82.96,21.08)
JTAG_TCLK: length 1.3
  TOP w0.117: v5(57.88,98.9) 57.87,98.9 57.55,99.22 UG1.BK24
  BOTTOM w0.081: v5(57.88,98.9) 57.88,99.51 T10.1
JTAG_TDI: length 3.9
  TOP w0.117: v5(61.96,98.11) 61.96,98.17 61.62,98.52 58.98,98.52 UG1.BM23
  BOTTOM w0.081: v5(61.96,98.11) 62.03,98.17 T12.1
JTAG_TDO: length 3
  TOP w0.117: UG1.BM24 60.49,99.25 60.87,99.63 v5(60.87,99.68)
  BOTTOM w0.081: T13.1 60.48,100.08 v5(60.87,99.68)
JTAG_TMS: length 3.4
  TOP w0.117: UG1.BL23 58.82,97.98 v5(60.86,97.98)
  BOTTOM w0.081: v5(60.86,97.98) 60.74,97.86 T11.1
JTAG_TRST#: length 4.7
  TOP w0.081: RG518.1 61.4,99.77 v5(61.48,99.68)
  TOP w0.117: UG1.BL24 58.63,99.63 60.18,99.63 60.8,100.25 RG518.1
  BOTTOM w0.081: v5(61.48,99.68) 61.48,100.18 T16.1
LCD_BL_PWM: length 18.3
  TOP w0.081: v8(66.52,86.41) 66.52,86.13 RG150.1
  IN1 w0.058: v8(53.35,87.35) 53.35,88.2 55.4,90.25 59.47,90.25 59.94,90.72 63.18,90.72 65.12,88.78 65.12,88.07 66.26,86.93 66.26,86.67 66.52,86.41 v8(66.52,86.41)
LCD_BLEN: length 9
  TOP w0.081: UG1.BA5 50.93,85.63 50.93,81.22 52.25,79.9 52.25,79.86 52.98,79.13 53.54,79.13 RG525.1
LDO_EN: length 25.5
  IN4 w0.058: v7(81.66,9.68) 81.66,9.22 80.64,8.2 76.8,8.2 76.49,7.89 68.53,7.89 68.06,7.42 v7(67.95,7.42) ; 84.2,14.4 84.68,14.89 84.68,15.43 84.96,15.71 v7(85.6,15.71)
  IN4 w0.076: v7(82.21,12.98) 82.77,12.98 84.2,14.4
  BOTTOM w0.076: 80.46,12.08 81.15,11.39 81.15,10.57 ; 80.46,12.08 80.77,12.4 81.64,12.4 v7(82.21,12.98) ; 80.46,12.08 DK3.3
  BOTTOM w0.081: 81.15,10.57 81.15,10.19 v7(81.66,9.68) ; UE10.15 85.69,15.62 v7(85.6,15.71)
LG1_ISL95338_1: length 20.4
  TOP w0.635: v5(44.87,30.69) 44.87,30.85 45.35,31.33 45.52,31.33 45.53,31.35 PQV01.8 ; v5(44.93,25.39) 45.34,25.8 PQV02.8
  IN2 w0.635: v5(44.87,30.69) 44.93,30.62 v5(44.93,25.39)
  IN4 w0.508: 50.03,34.48 49.2,34.48
  IN4 w0.635: 50.03,34.48 50.04,34.47 52.43,34.47 53.11,33.78 ; 49.2,34.48 49.12,34.56 45.52,34.56 44.87,33.91 v5(44.87,30.69)
  BOTTOM w0.081: v4(53.66,33.56) v2(53.24,33.98)
  vias: v4(53.66,33.17) v9(53.28,33.56) v9(53.28,33.17)
LG2_ISL95338_1: length 27.8
  IN2 w0.635: v5(38.71,27.21) 38.1,27.82 v5(38.1,33)
  IN3 w0.635: v5(38.71,27.21) 38.73,27.23 42.2,27.23 43.99,29.02 48.7,29.02 48.71,29.02 48.95,29.02 49.33,29.4 49.33,29.64 50.23,30.54 50.23,31.5 51.28,32.55 52.06,32.55 52.24,32.55 52.45,32.77 52.74,32.77
  BOTTOM w0.081: v10(39.61,26.93) 39.33,27.21 v5(38.71,27.21)
  BOTTOM w0.203: v4(53.28,32.19) v4(53.66,32.19) PUV3.7
  BOTTOM w0.635: v5(38.71,27.21) 37.85,28.06 PQV3.8 ; PQV4.8 38.1,33.18 v5(38.1,33)
  vias: v9(53.28,32.54) v9(53.66,32.54)
LG_+1VALWP:
  vias: v2(134.47,31.63) v5(135.19,31.65) v5(135.89,31.65)
LG_CHG: length 0.9
  TOP w0.081: v2(43.07,18.14) 42.67,17.74 v5(42.29,17.74)
  vias: v3(31.45,25.95) v3(31.95,25.95) v4(31.5,25.52) v4(31.81,25.52) v5(41.78,18) v11(31.45,26.55) v11(31.95,26.55)
LID_SW#: length 86.8
  TOP w0.081: v5(116.54,20.89) 116.43,21 114.13,21 114.05,20.91 114.05,14.54 114.09,14.5 v10(114.09,14.5) 114.09,12.9 v8(114.05,12.85) ; UE5.H1 80.67,10.99 81.22,10.44 81.22,9.69 RE70.2 81.86,9.05 81.86,8.93 81.86,8.93 81.86,8.27 82.06,8.08 83.11,8.08 83.58,7.61 v8(83.8,7.61)
  IN1 w0.058: v8(114.05,12.85) 111.79,12.85 111.62,13.02 108.94,13.02 108.48,13.48 107.99,13.48 107.76,13.25 106.43,13.25 105.72,12.55 103.99,12.55 103.7,12.83 93.03,12.83 92.36,12.16 90.69,12.16 86.62,8.09 85.78,8.09 85.22,7.53 83.87,7.53 v8(83.8,7.61)
  IN3 w0.058: v5(116.54,20.89) 116.65,20.89 117.45,20.09 128.46,20.09 129.49,19.07 132.7,19.07 134.49,20.86 134.49,22.02 139.29,26.82 v9(141.2,26.82)
  GND4 w0.081: v9(141.2,26.82) v4(141.4,27.03)
  BOTTOM w0.081: v4(141.4,27.03) 140.5,27.03 CE43.1 140.4,27.33 140.59,27.52 141.48,27.52 141.97,27.03 143.21,27.03 144.14,27.96 JIO2.F4 ; DE1.1 115.7,20.21 116.38,20.89 v5(116.54,20.89)
LPC_GPU: length 4
  TOP w0.203: v5(78.41,27.02) 78.36,27.07 78.36,27.35 v2(77.98,27.73) 77.4,28.3 PUV1.24
  TOP w0.254: v5(78.41,27.02) 78.47,26.95 PRV75.2
  BOTTOM w0.203: PRV79.1 79.04,27.02 v5(78.41,27.02)
LX1_ISL95338_1: length 18.1
  TOP w0.635: PQV01.2 50.51,32.63 50.53,32.63 51.18,33.28 v5(51.18,33.38)
  IN1 w0.635: 51.14,27.85 51.14,29.56 50.34,30.36 50.34,31.92 51.04,32.62 51.04,33.24 v5(51.18,33.38)
  IN3 w0.508: 49.17,33.28 49.82,33.28 49.92,33.38 50.04,33.38
  IN3 w0.635: 53.37,34.11 51.92,34.11 v5(51.18,33.38) 50.04,33.38 ; 49.17,33.28 49.15,33.25 44.54,33.25 v5(43.93,32.64)
  BOTTOM w0.081: v10(43.15,32.67) 43.9,32.67 v5(43.93,32.64)
  vias: v1(50.97,27.21) v1(50.98,26.9) v1(51.31,27.22) v1(51.3,26.9) v1(53.39,35.11) v1(53.7,35.11) v3(51.44,26.37) v3(51.79,26.72) v3(52.31,27.24) v3(52.3,26.74) v3(54.11,34.18) v3(54.62,34.29) v4(51.24,27.33) v4(51.27,26.96) v4(51.51,27.17) v4(51.74,27.38) v4(54.62,33.95) v4(54.94,33.98)
LX1_NVVDD:
  vias: v5(25.54,49.94) v5(25.54,49.37) v10(29.44,47.6)
LX2_ISL95338_1: length 42.5
  IN1 w0.508: v5(38.99,28.01) 37.33,28.01 36.26,29.07 v5(31.57,29.07)
  IN2 w0.635: v5(31.71,34.71) 32.18,34.24 32.18,29.68 v5(31.57,29.07)
  IN3 w0.508: 51.12,28.25 50.61,27.74 50.05,27.74 50,27.69 49.78,27.69
  IN3 w0.635: 49.78,27.69 43.7,27.69 42.24,26.23 34.92,26.23 32.08,29.07 v5(31.57,29.07) ; 51.12,28.25 51.12,31.18 51.75,31.82
  BOTTOM w0.203: PUV3.6 v4(53.66,31.79) v4(53.28,31.79)
  BOTTOM w0.635: v5(31.71,34.71) 32.06,35.05 PQV4.2 ; PQV3.2 31.83,29.33 v5(31.57,29.07)
  vias: v1(53.52,31.49) v1(53.52,31.18) v3(52.36,31.82) v3(52.87,31.82) v5(38.99,35.93) v5(38.99,35.32) v5(38.99,34.71) v5(38.99,34.1) v5(38.99,33.49) v5(38.99,32.88) v5(38.99,32.27) v5(38.99,31.66) v5(38.99,31.05) v5(38.99,30.44) v5(38.99,29.83) v5(38.99,29.23) v5(38.99,28.62) v5(39.71,36.27) v5(39.71,35.66) v5(39.71,35.05) v5(39.71,34.44) v5(39.71,33.84) v5(39.71,33.23) v5(39.71,32.62) v5(39.71,32.01) v5(39.71,31.4) v5(39.71,30.79) v5(39.71,30.18) v5(39.71,29.57) v5(39.71,28.96) v5(39.71,28.35) v10(40.58,36.62)
LX2_NVVDD:
  vias: v2(32.92,50.4) v5(33.09,49.88) v5(33.09,49.3)
LX3_NVVDD:
  vias: v2(40.65,50.42) v5(40.78,49.94) v5(40.78,49.37)
LX4_NVVDD:
  vias: v2(48.27,50.41) v5(48.46,49.88) v5(48.46,49.3)
LX5_NVVDD:
  vias: v2(56.12,50.51) v5(56.21,50) v5(56.21,49.43)
LX6_NVVDD:
  vias: v2(63.94,50.49) v5(64.02,50) v5(64.02,49.43)
LX7_NVVDD:
  vias: v2(71.7,50.62) v5(71.75,50.13) v5(71.77,49.56)
LX8_NVVDD:
  vias: v2(78.38,78.67)
LX_1.0VS_VGAP: length 4.9
  IN4 w0.508: 71.45,108.13 72.05,107.53 v7(72.05,103.5)
  vias: v2(71.79,107.53) v5(70.8,109.06) v5(71.44,109.06) v7(71.56,108.61)
LX_3V: length 9
  TOP w0.254: PU301.5 v5(64.89,27.45)
  IN1 w0.254: v8(66.17,21.17) 66.23,21.24 66.23,27.2 65.98,27.45 v5(64.89,27.45)
  BOTTOM w0.081: v5(64.64,22.32) v10(64.64,21.66)
  vias: v5(64.63,22.89)
LX_5V:
  vias: v2(56.86,17.92) v5(54.61,18.18) v5(54.61,17.6)
LX_+1.8VGS: length 4.4
  IN1 w0.508: v5(45.96,7.33) 46.02,7.27 v5(50.36,7.27)
  vias: v10(50.99,8.41)
LX_CHG:
  vias: v2(40.49,20.23) v5(31.6,21.39) v5(32.56,21.45) v5(33.13,21.45) v5(33.81,21.47) v5(34.38,21.47) v5(35.06,22.11) v5(35.06,21.54) v5(35.64,22.11) v5(35.64,21.54) v5(36.25,21.57) v5(41.78,18.57) v5(42.29,18.32)
LX_VCCIO: length 4.2
  IN1 w0.508: v8(132.78,51.72) 133.81,51.72 135.01,50.51 v5(136.47,50.51)
  vias: v2(128.69,54.24) v5(131.51,54.13) v5(132.08,54.13)
ME_EN: length 28.4
  TOP w0.081: v8(96.11,13.29) 96.27,13.44 96.27,17.05 v2(96.23,17.08) 96.14,17.17 96.14,18.96 RH16.1
  IN1 w0.058: v8(96.11,13.29) 95.85,13.55 91.62,13.55 86.85,8.79 85.55,8.79 84.91,8.15 82.87,8.15 82.47,8.15 81.7,8.92 81.13,8.92 81.1,8.94 79.48,10.57
  IN1 w0.076: v8(78.16,11.36) 78.16,11.29 78.6,10.85 79.19,10.85 79.48,10.57
ME_SUS_PWR_ACK: length 5.9
  TOP w0.089: 110.46,25.82 110.59,25.95 110.59,25.97 110.62,26 110.62,26.85 110.78,27 110.78,27.43 UH1.BC37
  TOP w0.122: 110.46,25.82 110.19,25.56 110.19,25.11 110.2,25.1 110.2,24.79 110.19,24.78 110.19,23.72 109.95,23.48 v2(109.95,23.19) 109.95,22.3 RH506.1
MEM_VDD_CTL: length 115.4
  TOP w0.081: v1(57.61,80.72) 57.61,82.04 57.18,82.48 57.18,83.26 56.92,83.52 56.72,83.52 56.54,83.7 56.54,84.66 56.15,85.05 v8(56.15,85.25) ; v1(2.53,22.09) 2.53,22.06 2.32,21.86 v2(1.59,21.86)
  GND2 w0.081: v12(57.85,80.48) v1(57.61,80.72) ; v1(2.53,22.09) 2.71,22.27 v12(2.88,22.27)
  IN2 w0.058: v12(2.88,22.27) 3.49,22.27 5,23.78 7.24,23.78 8.31,24.84 8.31,31.19 9.5,32.39 9.5,39.11 11.64,41.25 11.64,53.05 15.01,56.42 17.1,56.42 19.3,58.63 28.9,58.63 29.25,58.97 33.99,58.97 34.33,58.63 56.32,58.63 60.82,63.13 60.82,76.01 58.67,78.16 58.67,79.66 v12(57.85,80.48)
MEM_VREF_CTL: length 225.5
  TOP w0.152: UG1.BD3 53.7,84.2 53.7,82.7 54.66,81.74 RG24.1
  TOP w0.254: v3(60.69,102.63) 61.43,103.37 61.43,109.88 v10(63,111.45) 63.21,111.65 63.21,113.37 60.33,116.26 60.33,119.99 59.92,120.4 59.92,121.03 60.17,121.29 61.26,121.29 62.46,122.48 62.51,122.48 62.67,122.64 62.87,122.64 63.31,123.08 63.31,125.2 QG2.2
  IN1 w0.254: v5(22.48,62.13) 16.45,62.13 15.3,63.27 5.46,63.27 2.1,66.64 v5(2.1,70.26) ; v3(63.08,74.72) v11(59.05,74.72)
  GND2 w0.254: v1(54.69,80.7) 54.63,80.75 v12(54.36,80.75) ; v11(59.05,74.72) 58.66,74.72 v12(58.65,74.7)
  IN2 w0.254: v12(54.36,80.75) 54.36,80.06 58.65,75.77 v12(58.65,74.7) 58.65,64.11 55.78,61.24 42.61,61.24 v3(41.85,62) 41.11,61.27 23.34,61.27 v5(22.48,62.13) ; v3(3.05,118.65) 1.78,118.65 1.46,118.33 1.46,87.34 v5(2.67,86.13) 2.67,84.86 1.41,83.6 1.41,70.69 1.84,70.26 v5(2.1,70.26)
  IN3 w0.254: v3(63.08,74.72) 63.42,75.06 63.42,91.45 60.38,94.49 60.38,99.89 61.02,100.54 61.02,102.3 v3(60.69,102.63)
  GND4 w0.254: v4(3.56,118.65) v3(3.05,118.65) ; v4(41.85,62.51) v3(41.85,62)
  BOTTOM w0.254: v4(41.85,62.51) 42.1,62.77 42.1,65.5 42.35,65.75 43.4,65.75 QG8.2 ; QG3.2 10.6,119.66 4.57,119.66 v4(3.56,118.65) ; QG4.2 10.95,84.58 10.29,85.24 7.05,85.24 6.16,86.13 v5(2.67,86.13)
MIC_CLK: length 258.2
  TOP w0.081: RV679.1 39.95,145.01 v3(39.74,145.23)
  IN1 w0.058: 10.22,10.1 10.24,10.08 10.24,9.92 10.24,9.84 v4(10.06,9.66)
  IN1 w0.076: 10.22,10.1 10.22,11.65 9.07,12.8 6.91,12.8 5.77,13.95 5.77,17.22 9.1,20.56 9.1,22.03 10.13,23.06 10.13,27.35 11.61,28.82 11.61,33.52 11.05,34.08 11.05,39.98 12.8,41.73 12.8,47.77 12.27,48.3 12.27,52.71 19.66,60.1 32.89,60.1 33.75,59.24 80.23,59.24 80.78,58.69 81.09,58.69 v5(81.28,58.88)
  IN2 w0.058: v5(43.18,152.91) 43.18,150.17 39.74,146.73 v3(39.74,145.23)
  IN3 w0.058: v5(81.28,58.88) 81.5,58.65 81.63,58.65 81.87,58.89 81.87,66.34 84.07,68.53 84.07,82.98 84.86,83.77 85.53,83.77 86.26,84.51 86.26,86.9 85.74,87.41 85.74,102.42 79.77,108.4 79.77,112.01 78.03,113.74 78.03,114.35 72.21,120.17 72.21,121.29 69.09,124.41 68.25,124.41 65.8,126.86 65.8,132.15 66.41,132.76 66.41,133.17 65.8,133.78 65.8,140.85 64.13,142.52 62.69,142.52 58.23,146.98 48.2,146.98 46.93,148.25 44.92,148.25 43.34,149.83 43.34,152.75 v5(43.18,152.91)
  BOTTOM w0.081: JEDP.26 43.25,151.98 43.44,152.17 43.44,152.65 v5(43.18,152.91)
MIC_DATA: length 248.1
  IN1 w0.058: v4(10.66,9.66) 10.4,9.92 10.4,10.14 10.4,10.14 10.4,10.16
  IN1 w0.076: 10.4,10.16 10.4,11.72 9.14,12.98 6.99,12.98 5.97,14 5.97,17.17 9.28,20.48 9.28,21.96 10.31,22.99 10.31,27.27 11.79,28.74 11.79,33.59 11.23,34.15 11.23,39.91 12.97,41.66 12.97,47.84 12.45,48.37 12.45,52.64 19.73,59.92 32.82,59.92 33.68,59.06 80.16,59.06 80.71,58.51 81.06,58.51 v5(81.28,58.29)
  IN3 w0.058: v5(43.79,152.91) 43.5,152.62 43.5,149.89 44.99,148.41 47,148.41 48.27,147.14 58.3,147.14 62.75,142.68 64.19,142.68 65.96,140.92 65.96,133.85 66.57,133.24 66.57,132.69 65.96,132.08 65.96,126.93 68.31,124.57 69.16,124.57 72.37,121.36 72.37,120.24 78.19,114.42 78.19,113.81 79.93,112.07 79.93,108.46 85.9,102.48 85.9,87.48 86.42,86.96 86.42,84.44 85.59,83.61 84.93,83.61 84.23,82.91 84.23,68.47 82.03,66.27 82.03,58.82 81.7,58.49 81.48,58.49 v5(81.28,58.29)
  BOTTOM w0.081: JEDP.25 43.75,152.05 43.62,152.17 43.62,152.75 v5(43.79,152.91)
MODE_SEL: length 5.5
  TOP w0.254: RG1565.1 9.94,38.86 9.94,38.5 8.98,37.54 8.86,37.54 8.45,37.12 8.45,36.43 v2(8.29,36.27) 8.18,36.27 7.67,35.76 UG37.26
N17_ID0: length 9.2
  TOP w0.089: UH1.AR18 v5(100.97,31.64)
  IN1 w0.089: v5(99.49,25.49) 98.87,26.11 98.87,28.92 100.39,30.44 100.39,31.14 100.89,31.64 v5(100.97,31.64)
  BOTTOM w0.089: RH28.1 RH27.1 99.87,25.87 v5(99.49,25.49)
N17_ID1: length 5.1
  TOP w0.081: RH25.1 RH26.1 100.34,22.38 100.14,22.38 99.83,22.69
  TOP w0.089: 99.83,22.69 99.25,23.27 v2(99.25,23.55) 99.25,25.17 99.12,25.3 99.12,25.81 99.21,25.9 UH1.BF14
NB_FGC6: length 30.1
  TOP w0.081: v5(69.92,91.25) 69.42,90.74 69.42,89.04 68.91,88.53 68.91,88.32 68.64,88.05 68.3,88.05 68.08,88.27 68.08,88.46 67.92,88.62 67.59,88.62 67.47,88.5 66.7,88.5 66.38,88.82 65.17,88.82 64.74,88.39 63.56,88.39 v2(63.36,88.19) 63.36,86.38 v8(63.41,86.32) ; v8(54.05,85.95) 54.05,85.96 53.67,86.34 53.67,86.72 53.92,86.97 58.34,86.97 v8(58.98,87.61)
  IN1 w0.058: v8(58.98,87.61) 59.25,87.61 60.69,86.17 63.26,86.17 v8(63.41,86.32)
  BOTTOM w0.081: v5(69.92,91.25) 70.01,91.25 70.61,91.84 72.89,91.84 75.03,93.98 UG41.2
NC_B4: length 8.8
  IN3 w0.058: v9(89.28,145.7) 89.11,145.53 88.67,145.53 88.57,145.43 88.19,145.43 86.86,146.76 83.74,146.76 v9(83.69,146.71)
  GND4 w0.081: v4(88.91,145.74) 88.95,145.7 v9(89.28,145.7) ; v4(83.34,146.79) 83.41,146.71 v9(83.69,146.71)
  BOTTOM w0.081: RT86.2 RT45.1 88.43,145.19 88.91,145.67 v4(88.91,145.74) ; v4(83.34,146.79) UT1.B4
NC_B5: length 3.9
  BOTTOM w0.081: RT46.1 80.11,148.96 81.03,148.05 82.15,148.05 82.49,147.71 82.49,147.32 UT1.B5
NC_G2: length 5.5
  BOTTOM w0.081: RT47.1 86.37,140.93 86.37,140.99 v2(85.79,141.57) 85.65,141.71 85.65,142.04 85.41,142.28 85.41,144.06 84.91,144.56 84.33,144.56 UT1.G2
Net_3220:
  vias: v8(58.95,95.05)
NRB_BIT: length 6.3
  TOP w0.081: 107.75,22.69 107.57,22.51 107.57,21.47 RH524.2
  TOP w0.089: 107.75,22.69 108.03,22.96 108.03,23.4 107.82,23.6 107.82,24.53 107.36,24.99 107.36,25.33 107.3,25.4 107.3,25.98 107.25,26.02 107.25,26.6 UH1.BE30
NTC_CHG: length 2.5
  BOTTOM w0.203: PUB1.17 42.98,16.27 v2(42.2,15.5) 41.78,15.08 PRB30.1
NTC_LA: length 93.8
  TOP w0.254: PRV210.2 v2(81.22,26.13) 81.8,26.13 v4(81.93,26) ; PHV01.1 v5(30.98,58.05)
  IN3 w0.254: v9(69.95,29.14) 69.49,28.68 69.49,21.41 69.75,21.16 72.01,21.16 72.21,21.36 72.21,23.98 73.03,24.79 80.64,24.79 81.85,26 v4(81.93,26)
  GND4 w0.254: v6(70.18,29.36) v9(69.95,29.14)
  IN4 w0.254: v6(70.18,29.36) 69.47,30.08 69.47,33.62 68.52,34.57 68.52,38.5 67.81,39.21 67.81,44.27 68.71,45.18 68.71,50 67.56,51.15 67.56,56.8 65.79,58.57 31.37,58.57 30.98,58.18 v5(30.98,58.05)
NTC_LB: length 88.7
  TOP w0.203: PCV210.2 80.07,25.3 79.25,24.48 79.25,24.15 v1(78.68,23.57)
  TOP w0.254: PHV01.2 v5(31.89,58.05)
  IN4 w0.254: v5(31.89,58.05) 65.8,58.05 67.21,56.65 67.21,50.93 68.2,49.94 68.2,45.24 67.44,44.48 67.44,38.89 68.14,38.19 68.14,34.19 69.11,33.21 69.11,26.05 v7(70.68,24.49)
  BOTTOM w0.203: 80.95,26.06 81.05,26.16 v2(81.05,27.26) 80.59,27.71 PRV213.2 ; 80.95,26.06 PRV212.2 PCV209.2 ; 80.95,26.06 PRV211.2
  BOTTOM w0.254: 78.73,23.92 78.68,23.87 v4(78.68,23.56) ; 78.73,23.92 79.15,24.34 ; 78.73,23.92 PCV211.2 ; 79.15,24.34 79.68,24.34 80.09,24.74 PCV209.2 ; 79.15,24.34 78.99,24.49 PRV215.1 PRV216.1 PRV217.1 PRV218.1 PRV219.1 PRV220.1 PRV221.1 v7(70.68,24.49)
NVVDD_1: length 80.7
  TOP w0.254: PLV01.2 v5(27.66,52.19)
  IN4 w0.152: v5(27.66,52.19) 27.81,52.03 29.53,52.03 34.35,47.21 37.4,47.21 37.97,46.64 37.97,45.24 37.4,44.67 37.4,41.94 38.29,41.05 49.4,41.05 50.65,39.8 55.58,39.8 58.14,37.24 64.94,37.24 65.6,36.58 65.6,31.44 67.12,29.91 67.12,24.52 68.83,22.8 68.83,20.96 70.02,19.78 75.82,19.78 77.22,21.17 77.22,21.81 77.79,22.38 v4(77.79,23.57)
  BOTTOM w0.081: v5(27.66,52.19) v2(27.14,52.19)
NVVDD_2: length 71.6
  TOP w0.254: PLV02.2 v5(35.22,52.12)
  IN4 w0.152: v4(76.77,23.57) 76.77,22.44 76.26,21.94 76.26,21.3 75.25,20.28 70.23,20.28 69.34,21.17 69.34,23.01 67.63,24.73 67.63,30.13 66.36,31.4 66.36,36.79 65.28,37.87 58.67,37.87 56.17,40.38 54.82,40.38 54,41.2 54,42.15 52.39,43.77 52.39,44.48 53.02,45.11 53.02,46.76 52.51,47.27 41.51,47.27 36.79,52 35.34,52 v5(35.22,52.12)
  BOTTOM w0.081: v5(35.22,52.12) v2(34.53,52.12)
NVVDD_3: length 62.7
  TOP w0.254: v5(42.87,52.06) 42.87,55.19 PLV03.2
  IN4 w0.152: v4(75.76,23.57) 75.06,22.88 75.06,21.17 74.68,20.79 70.44,20.79 69.85,21.38 69.85,23.22 68.14,24.94 68.14,30.34 67.06,31.42 67.06,36.94 65.55,38.45 58.82,38.45 56.38,40.88 55.03,40.88 54.51,41.41 54.51,43.12 53.84,43.8 53.84,47.63 53.68,47.78 48.36,47.78 44.23,51.91 43.03,51.91 v5(42.87,52.06)
  BOTTOM w0.081: v5(42.87,52.06) v2(42.08,52.06)
NVVDD_4: length 55.4
  TOP w0.254: PLV04.2 v5(50.6,52.12)
  IN4 w0.152: v5(50.6,52.12) 50.75,51.97 53.21,51.97 54.42,50.76 54.42,44.55 55.27,43.7 55.27,43.45 55.03,43.21 55.03,41.61 55.24,41.39 56.59,41.39 58.97,39.02 66.02,39.02 67.75,37.28 67.75,31.44 68.64,30.55 68.64,25.15 70.36,23.44 70.36,21.59 70.65,21.3 73.85,21.3 74.23,21.68 74.23,23.07 v4(74.74,23.57)
  BOTTOM w0.081: v2(49.87,52.06) 49.94,52.12 v5(50.6,52.12)
NVVDD_5: length 56.1
  TOP w0.254: v5(57.98,52.03) 58.32,52.38 PLV05.2
  IN1 w0.152: v5(57.98,52.03) 58.42,51.59 64.2,51.59 65.02,50.76 71.88,50.76 75.82,46.83 75.82,44.22 74.93,43.33 74.93,35.59 77.85,32.67 77.85,31.78 79.18,30.44 79.18,23.65 78.47,22.94 73.94,22.94 73.79,23.09 73.79,23.51 v4(73.72,23.57)
  BOTTOM w0.081: v5(57.98,52.03) v2(56.91,52.03)
NVVDD_6: length 51.3
  TOP w0.254: v5(65.66,52.1) 66.11,52.55 PLV06.2
  IN1 w0.152: v5(65.66,52.1) 66.29,51.46 71.97,51.46 76.45,46.98 76.45,44.1 75.5,43.14 75.5,36.03 79.88,31.65 79.88,23.46 78.84,22.42 74.93,22.42 74.24,21.73 73.48,21.73 73.15,22.06 73.15,23.13 v4(72.71,23.57)
NVVDD_7: length 49.5
  TOP w0.081: PCV15.2 v4(71.69,23.59)
  TOP w0.254: v5(73.6,52.03) 73.9,52.34 PLV07.2
  IN1 w0.152: v5(73.6,52.03) 74.04,51.59 75.12,51.59 75.63,51.08 75.63,48.61 77.09,47.14 77.09,43.97 76.01,42.89 76.01,36.41 77.15,35.27 78.17,35.27 80.52,32.92 80.52,23.73 80.39,23.6 80.39,23.25 79.03,21.88 78.67,21.88 78.26,21.48 75.41,21.48 75.16,21.22 72.21,21.22 72.01,21.43 72.01,23.27 v4(71.69,23.59)
  BOTTOM w0.081: v5(73.6,52.03) v2(72.92,52.03)
NVVDD_8: length 69.6
  TOP w0.254: PLV08.2 v5(75.37,84.04)
  IN3 w0.254: v5(75.37,84.04) 75.55,83.86 75.55,81.83 77.6,79.78 77.6,72.42 75.63,70.45 75.63,47.25 76.97,45.9 76.97,43.59 77.58,42.98 77.58,36.5 77.25,36.17 73.59,36.17 71.21,33.79 71.21,28.94 70.64,28.37 70.64,25.61 70.87,25.38 70.87,23.76 v4(70.68,23.57)
NVVDD_B+: length 17.5
  IN4 w0.254: v7(78.49,29.95) 77.88,29.95 77.01,30.81 77.01,31.75 76.63,32.13 74.55,32.13 73.94,32.74 73.94,35.79 74.6,36.45 74.6,37.61 v5(76.71,39.72)
  BOTTOM w0.254: v7(78.49,29.95) 78.61,30.08 79.71,30.08 80.09,29.7 PRV82.1 81.01,29.56 PCV4.2
  vias: v1(72.77,73.81) v1(72.77,73.43) v1(73.03,73.05) v1(73.15,73.81) v1(73.15,73.43) v1(73.41,73.05) v1(73.53,73.81) v1(73.91,73.81) v2(72.68,73.27) v5(26.23,38.19) v5(26.48,37.68) v5(26.8,38.19) v5(26.77,37.14) v5(27.11,37.68) v5(27.08,36.6) v5(27.37,38.19) v5(27.41,37.14) v5(27.65,36.6) v5(27.67,41.29) v5(27.69,37.68) v5(27.94,38.19) v5(27.98,37.14) v5(28.13,42.45) v5(28.13,41.87) v5(28.24,41.29) v5(28.26,37.68) v5(28.51,38.19) v5(28.7,42.45) v5(28.7,41.87) v5(33.7,43.55) v5(35.69,42.45) v5(35.69,41.87) v5(35.69,41.3) v5(35.87,43.55) v5(36.26,42.45) v5(36.26,41.87) v5(36.26,41.3) v5(41.26,43.55) v5(43.24,42.26) v5(43.24,41.68) v5(43.43,43.55) v5(43.81,42.26) v5(43.81,41.68) v5(48.88,43.55) v5(50.55,41.75) v5(51.05,43.55) v5(51.12,41.75) v5(56.56,43.55) v5(58.55,42.26) v5(58.55,41.68) v5(58.73,43.55) v5(59.12,42.26) v5(59.12,41.68) v5(66.36,42.48) v5(66.36,41.91) v5(66.36,41.34) v5(66.93,42.48) v5(66.93,41.91) v5(66.93,41.34) v5(71.86,43.55) v5(73.43,76.56) v5(73.43,75.48) v5(73.43,74.39) v5(73.8,42.51) v5(73.8,41.94) v5(73.8,41.37) v5(74.04,43.55) v5(74.37,42.51) v5(74.37,41.94) v5(74.37,41.37) v5(74.73,73.05) v5(76.71,42.57) v5(76.71,42) v5(76.71,41.43) v5(76.71,40.86) v5(76.71,40.29) v7(19.94,33.14) v7(19.94,32.56) v7(20.57,33.14) v7(20.57,32.56) v7(21.21,33.14) v7(21.21,32.56) v7(21.85,33.15) v7(21.85,32.57) v7(23.23,33) v7(23.23,32.42) v7(23.95,33.01) v7(23.95,32.43) v7(24.59,33.01) v7(24.59,32.43) v7(25.22,33.01) v7(25.22,32.43) v12(72.64,73.05) v12(72.77,72.67) v12(73.15,72.67) v12(73.53,73.43) v12(73.53,72.67) v12(73.91,73.43) v12(73.91,73.05) v12(73.91,72.67)
NVVDD_EN_17123971: length 120.7
  TOP w0.081: PQV1.2 71.62,17.49 72.17,18.05 PRV30.2 72.26,17.55 72.01,17.3 72.01,16.64 71.45,16.08 v6(70.89,16.08) ; v5(69.19,87.09) 69.19,86.77 69.44,86.51 QG508.2
  IN4 w0.058: v7(61.96,30.19) 61.53,29.76 61.53,29.08 65.54,25.07 65.54,19.29 68.75,16.08 v6(70.89,16.08) ; v7(70.93,34.64) 70.93,34.84 75.95,39.86 75.95,42.76 76.96,43.78 76.96,47.72 75.95,48.73 75.95,56.92 75.25,57.62 v7(75.25,57.8) 75.25,66.13 69.32,72.06 68.05,72.06 63.1,77.02 63.1,83.85 64.52,85.27 64.52,85.28 64.61,85.37 64.61,86.71 v7(64.87,86.97) ; v5(69.19,87.09) 69.19,87.17 69.36,87.35 69.36,89.23 70.41,90.27 70.41,92.76 68.47,94.7 68.47,99.66 v7(68.73,99.91)
  BOTTOM w0.081: v7(64.87,86.97) v2(68.19,86.97) 69.06,86.97 v5(69.19,87.09) ; PR1105.2 68.26,100.38 v7(68.73,99.91) ; v7(61.96,30.19) 61.96,30.72 62.06,30.83 63.22,30.83 63.58,30.47 64.36,30.47 64.94,31.04 64.94,32.04 65.89,33 67.46,33 68.17,33.71 70,33.71 v7(70.93,34.64) ; v7(75.25,57.8) RG549.2 75.93,56.87 DG7.1
NVVDD_ENP: length 2.2
  BOTTOM w0.081: v2(65.81,87.78) 66.26,87.78 66.56,88.09 RG1555.2 67.04,88.26 UG42.4
NVVDD_PGOOD: length 245.1
  TOP w0.081: UG29.2 66.51,93.95 66.53,93.93 67.31,93.93 v8(67.49,93.75) ; v8(80.4,42.05) 79.86,41.51 79.86,39.37 78.84,38.36 73.18,38.36 72.63,37.81 72.63,37.13 v2(72.47,36.97) 71.83,36.33 71.83,34.39 PRV59.2
  TOP w0.203: PRV59.2 73.17,31.97 PUV1.38
  IN1 w0.058: v8(80.4,42.05) 80.4,41.84 81.01,41.23 86.31,41.23 87.66,39.88 87.72,39.88 ; v6(69.19,94.36) 68.77,93.95 67.68,93.95 v8(67.49,93.75) ; 87.72,39.88 v6(88.67,39.88) ; 87.72,39.88 88.06,39.54 88.06,39.21 v11(87.74,38.89)
  GND2 w0.081: v11(87.74,38.89) v12(88.04,38.89)
  IN2 w0.058: v12(88.04,38.89) 88.29,38.89 89.4,37.78 89.4,28.53 88.18,27.32 88.18,26.37 88.25,26.3 88.25,25.95 88.18,25.88 88.18,24.59 90.82,21.96 91.66,21.96 96.19,17.43 96.82,17.43 98.33,15.92 98.33,13.3 97.85,12.82 93.48,12.82 92.78,12.12 90.57,12.12 89.2,10.76 89.2,8.73 88.85,8.37 v12(88.85,7.5) ; v3(81.99,114.56) 71.83,114.56 v6(71.65,114.38)
  IN3 w0.058: v3(81.99,114.56) 82.07,114.56 82.38,114.87 82.38,115.87 81.44,116.82 81.44,130.01 83.43,132.01 83.51,132.01 85.05,133.55 86,133.55 86.76,134.31 88.52,134.31 89.89,135.68 92.55,135.68 93.38,136.51 96.83,136.51 97.99,137.67 100.3,137.67 101.05,136.92 104.89,136.92 106.17,135.64 v9(106.43,135.64)
  GND4 w0.081: v9(106.43,135.64) v4(106.68,135.64)
  IN4 w0.058: v6(88.67,39.88) 86.43,39.88 80.55,45.76 80.55,48.8 80.89,49.14 80.89,57.82 80.47,58.25 v7(80.47,59.41) 80.47,64.71 72.54,72.63 72.54,72.97 72.27,73.24 72.08,73.43 72.08,79.33 70,81.4 70,81.99 68.99,83.01 68.99,84.61 69.55,85.17 69.55,89.13 70.57,90.16 70.57,92.82 69.19,94.21 v6(69.19,94.36) 69.19,99.88 v7(69.11,99.95) 69.11,100.52 71.04,102.45 72.26,102.45 72.91,103.1 72.91,107.85 73.69,108.63 73.69,112.35 v6(71.65,114.38) ; v7(74.3,57.81) 74.3,59.98 74.6,60.29 v7(74.6,60.35)
  BOTTOM w0.081: UG44.1 72.16,59.97 73.28,59.97 73.66,60.35 v7(74.6,60.35) 76.49,60.35 DG4.1 78.47,59.25 78.64,59.41 v7(80.47,59.41) ; PR1106.2 70.36,100.43 69.59,100.43 v7(69.11,99.95) ; QV3.2 108.55,139.69 108.42,139.57 108.41,139.57 108.28,139.43 108.28,136.25 107.67,135.64 v4(106.68,135.64)
NVVDD_PSI#: length 58
  TOP w0.081: RG1580.2 RG1595.1 63.18,70.39 62.42,69.62 62.42,65.37 63.5,64.29 70.13,64.29 70.55,63.87 70.55,61.25 71.58,60.23 74.33,60.23 76.21,58.35 76.21,52.85 79.88,49.18 79.88,44.47 80.73,43.62 80.73,41.85 80.07,41.19 80.07,39.06 v2(79.39,38.37) 79.15,38.13 73.23,38.13 73.04,37.94 73.04,36.86 72.29,36.11 PRV20.2
NVVDD_PWM_VID: length 78.9
  TOP w0.254: PRV22.1 69.84,34.76 v5(69.6,35)
  IN1 w0.254: v8(53.35,86.65) 53.71,87.01 53.71,88.05 55.66,89.99 59.58,89.99 60.05,90.47 63.05,90.47 64.36,89.16 v6(64.36,88.78)
  IN4 w0.254: v5(69.6,35) 70.43,35.84 71.05,35.84 75.25,40.04 75.25,43.21 76.2,44.16 76.2,47.34 75.25,48.29 75.25,55.37 73.51,57.11 73.51,64.57 71.97,66.11 71.97,67.27 62.48,76.76 62.48,84.12 63.99,85.63 63.99,87.1 64.47,87.57 64.47,88.67 v6(64.36,88.78)
  BOTTOM w0.081: v5(69.6,35) v2(70.23,35)
NVVDD_VCC_SENSE: length 104.3
  GND2 w0.203: v12(57.81,113.69) v1(57.55,113.95)
  IN2 w0.254: v12(57.81,113.69) 57.81,110.52 53.53,106.24 53.53,99.61 55.19,97.94 58.09,97.94 64.16,91.87 66.33,91.87 69.06,89.14 71.21,89.14 71.78,88.57 81.03,88.57 83.19,86.42 83.19,69.97 81.65,68.43 81.65,60.25 82.17,59.73 82.17,38.9 80.8,37.52 v4(80.8,36.35)
  BOTTOM w0.127: v4(80.8,36.35) 80.8,36.41 v2(81.22,36.83)
  BOTTOM w0.254: PRV13.2 v4(80.8,36.35)
NVVDD_VSS_SENSE: length 114.7
  TOP w0.254: v6(78.42,34.32) 77.95,34.79 PRV28.2
  GND2 w0.254: v1(58.25,113.95) v12(58.53,113.67)
  IN2 w0.254: v12(58.53,113.67) 58.17,113.32 58.17,110.33 53.89,106.05 53.89,99.76 55.34,98.3 58.24,98.3 64.31,92.23 66.48,92.23 69.19,89.51 71.45,89.51 72.03,88.93 81.18,88.93 83.33,86.77 83.54,86.57 83.54,69.82 82.02,68.3 82.02,60.49 82.56,59.95 82.56,38.21 v6(81.89,37.54)
  IN4 w0.254: v6(81.89,37.54) 81.81,37.54 80.19,39.17 79.04,39.17 77.95,38.08 76.66,38.08 75.77,37.19 75.77,35.44 76.42,34.79 77.76,34.79 78.23,34.32 v6(78.42,34.32)
OC_EN#: length 139.8
  TOP w0.081: v5(9.3,40.92) 9.26,40.88 8.99,40.88 8.76,40.66 RG1610.2
  IN1 w0.076: v8(81.67,15.36) 81.6,15.36 81.35,15.62 80.99,15.62 80.58,16.03 80.58,17.1 80.01,17.67 79.43,17.67 v11(79.13,17.97)
  GND2 w0.076: v3(78.36,18.33) 78.73,18.33 79.09,17.97 v11(79.13,17.97)
  IN3 w0.058: v5(9.3,40.92) 9.3,39.92 7.68,38.3 7.68,36.28 8.25,35.71 8.25,30.2 6.16,28.1 6.16,27.81 5.71,27.37 5.71,21.63 4.67,20.59 4.67,19.12 2.95,17.39 2.95,9.26 3.48,8.73 5.52,8.73 6.22,8.03 8.51,8.03 9.71,6.82 11.38,6.82 11.76,6.44 11.76,5.88 12.85,4.79 14.95,4.79 15.7,4.04 20.9,4.04 21.86,4.99 26.47,4.99 27.17,5.69 31.41,5.69 31.59,5.51 38.61,5.51 39.99,6.89 39.99,6.89 40.08,6.99 42.75,6.99 42.75,6.98 42.84,6.98 43.71,6.81 44.53,6.47 44.72,6.35 45.04,6.13 47.51,6.13 50.36,3.29 64.22,3.29 64.81,3.88 69.81,3.88 69.91,3.98 77.78,3.98 78.22,3.53 78.63,3.53 79.54,4.45 79.54,5.35 80.18,5.99 80.18,6.96 79.82,7.32 79.59,7.32 78.91,8 78.91,10.57
  IN3 w0.076: v3(78.36,18.33) 77.68,18.33 77.44,18.09 77.44,14.51 78.68,13.27 78.68,12.05 78.91,11.83 78.91,10.57
OC_WARN#: length 123.9
  TOP w0.081: RG522.1 65.49,88.55 65.58,88.64 66.31,88.64 66.62,88.32 v8(67.81,88.32)
  IN1 w0.058: v8(67.81,88.32) 67.81,88.84 67.08,89.56 66.43,89.56 63.29,92.7 61.99,92.7 61.79,92.9 57.83,92.9 57.63,92.7 57.63,92.46 57.03,91.86 54.75,91.86 51.31,88.42 51.31,85.69 51.75,85.25 v1(51.95,85.25)
  GND2 w0.081: v1(51.95,85.25) v12(52.2,85.25) ; v12(6.74,40.3) v1(6.35,40.3)
  IN2 w0.058: v12(52.2,85.25) 52.23,85.25 56.55,80.93 56.55,80.06 60.66,75.95 60.66,63.19 56.25,58.79 34.39,58.79 34.05,59.13 29.18,59.13 28.84,58.79 19.24,58.79 17.03,56.58 14.95,56.58 11.48,53.11 11.48,41.32 10.47,40.3 v12(6.74,40.3)
ON/OFF#: length 171.2
  TOP w0.081: v10(11.33,19.28) 11.82,19.78 v5(12.06,19.78)
  IN1 w0.058: 76.58,15.12 76.16,15.12 75.92,14.89 75.54,14.89 v11(75.13,15.29)
  IN1 w0.076: 76.58,15.12 78.41,15.12 78.52,15.01 78.53,15.01 78.77,14.77 78.77,14.76 v3(80.17,13.36)
  GND2 w0.081: v3(74.78,15.29) v11(75.13,15.29)
  IN3 w0.058: 117.24,33.96 119.03,33.96 119.11,34.04 126.13,34.04 126.57,34.48 137.6,34.48 140.69,31.4 142.65,31.4 v9(142.75,31.5) ; 84.2,15.62 84.98,16.4 85.28,16.4 86.46,17.58 91.87,17.58 93.5,19.2 94.07,19.2 94.54,18.73 95.48,18.73 95.98,19.23 97.49,19.23 99.38,21.12 99.38,22.56 99.5,22.69 ; v3(74.78,15.29) 74.48,14.99 74.48,9.88 73.94,9.34 70.85,9.34 69.51,8.01 68.67,8.01 67.46,6.8 63.82,6.8 62.26,8.37 58.1,8.37 55.08,11.39 44.45,11.39 44.01,11.84 40.08,11.84 38.93,10.68 27.93,10.68 26.77,9.52 14.01,9.52 13.2,10.33 13.2,18.64 v5(12.06,19.78)
  IN3 w0.076: v3(80.17,13.36) 80.17,13.43 80.53,13.79 82.14,13.79 82.54,14.2 82.78,14.2 84.2,15.62
  IN3 w0.089: 117.24,33.96 114.19,33.96 112.8,32.57 109,32.57 108.71,32.86 108.1,32.86 107.46,32.22 106.93,32.22 106.81,32.1 106.81,30.72 105,28.92 104.65,28.92 104.01,28.29 104.01,26.89 103.57,26.44 103.57,26.29 102.84,25.57 102.84,24.51 102.62,24.28 102.22,24.28 101.87,24.64 101.87,25.22 101.52,25.57 100.47,25.57 99.5,24.6 99.5,22.69
  GND4 w0.081: v9(142.75,31.5) 142.75,31.55 v4(142.94,31.74)
  BOTTOM w0.081: v5(12.06,19.78) 12.06,19.71 11.87,19.52 v7(11.29,19.52) 10.74,19.52 CE27.1 RE717.1
OPCN_CHG: length 2.8
  TOP w0.081: v5(45.02,20.67) 45.44,20.67 v2(45.68,20.91)
  TOP w0.203: PCB18.2 45.02,20.06 v5(45.02,20.67)
  BOTTOM w0.203: v5(45.02,20.67) 45.11,20.58 PUB1.28
OSC24M_IN: length 1.8
  BOTTOM w0.081: UE1.5 128.14,21.58 RE18.2
OSC24M_IN_R: length 5.5
  BOTTOM w0.081: YE1.1 130.86,21.24 129.48,21.24 128.97,21.74 RE3.1 128.97,22.06 128.74,22.29 RE18.1 CE2.1
OSC24M_OUT: length 1.8
  BOTTOM w0.081: RE19.2 128.26,21.08 UE1.6
OSC24M_OUT_R: length 3.2
  BOTTOM w0.081: YE1.3 129.49,20.84 RE3.2 128.63,20.5 RE19.1 128.27,19.78 CE5.1
OVERT#: length 46.5
  IN1 w0.058: v8(55.45,85.95) 56.38,85.95 56.81,85.52 59.16,85.52 59.88,84.8 64.03,84.8 v8(64.29,85.05) 64.29,85.04 64.54,84.79 65.46,84.79 66.37,83.87 66.37,74.94 v6(66.29,74.86)
  IN4 w0.058: v7(76.3,56.57) 76.3,57.52 75.41,58.41 75.41,66.43 66.98,74.86 v6(66.29,74.86)
  BOTTOM w0.081: v7(76.3,56.57) 76.47,56.73 UG23.5
P_SYS: length 262.1
  TOP w0.203: PUZ1.24 139.24,126.25
  TOP w0.254: v5(138.86,126.11) 139,126.25 139.24,126.25
  IN2 w0.254: v6(66.48,119.43) 66.48,116.96 66.74,116.7 71.03,116.7 71.62,116.12 78.67,116.12 80.94,118.38 80.94,126.27 79.25,127.96 79.25,132.84 79.98,133.57 82.61,133.57 83.07,134.04 84.54,134.04 85.97,135.47 89.42,135.47 90.02,136.07 92.94,136.07 93.65,136.78 96.29,136.78 98.2,138.69 107.42,138.69 108.26,137.84 112.24,137.84 113.08,138.69 131.8,138.69 133.15,140.03 134.39,140.03 136.5,137.92 136.5,128.64 138.86,126.28 v5(138.86,126.11)
  IN4 w0.254: v5(51,14.18) 56.03,14.18 58.06,12.14 62.99,12.14 63.75,12.91 67.56,12.91 68.58,13.92 68.58,14.8 69.14,15.36 72.99,15.36 73.37,15.74 74.36,15.74 74.75,16.13 74.75,17.63 79.18,22.06 79.18,24.03 78.87,24.35 78.87,27.52 78.49,27.9 77.28,27.9 76.45,28.73 76.45,30.58 75.56,31.47 73.2,31.47 70.36,34.32 70.36,34.95 70.73,35.33 71.05,35.33 75.63,39.9 75.63,42.95 76.64,43.97 76.64,47.59 75.63,48.61 75.63,55.58 73.93,57.28 73.93,64.66 72.33,66.26 72.33,67.42 62.84,76.91 62.84,83.97 64.35,85.48 64.35,86.95 64.82,87.42 64.82,91.21 62.8,93.23 62.8,96.64 63,96.83 63,110.39 64.46,111.85 64.46,114.86 65.79,116.19 65.79,118.73 v6(66.48,119.43)
  BOTTOM w0.081: PRB23.1 50.18,13.13 v2(50.57,12.74)
  BOTTOM w0.254: PRB23.1 50.89,14.06 v5(51,14.18) ; v5(138.86,126.11) 138.81,126.11 138.71,126.01 PRZ62.1
