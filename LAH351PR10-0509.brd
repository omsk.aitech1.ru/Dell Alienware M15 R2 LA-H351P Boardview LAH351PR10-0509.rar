# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWM1_1PH/ICCMAX1: length 32.9
  TOP w0.203: v5(147.45,126.99) 147.32,126.86 147.03,126.86 146.84,127.05 PUZ1.44
  IN4 w0.152: v5(147.45,126.99) 147.22,126.76 147.22,123.08 146.65,122.51 145.75,122.51 144.57,121.33 144.57,118.94 143.01,117.38 143.01,99.9 v6(143.38,99.53)
  BOTTOM w0.081: v2(147.86,127.23) 147.69,127.23 v5(147.45,126.99)
  BOTTOM w0.254: v5(147.45,126.99) 147.33,126.88 146.77,126.88 146.73,126.91 146.69,126.91 PRZ70.1
PWM1_2PH/ICCMAX2: length 47.8
  TOP w0.203: v6(137.87,126.01) 138.05,126.01 138.69,126.65 PUZ1.23
  IN3 w0.254: v3(143.26,84.3) 143.26,84.43 142.27,85.42 142.27,89.26 v5(139.5,92.03)
  IN4 w0.254: v5(139.5,92.03) 138.86,92.66 138.86,101.09 139.47,101.7 139.47,109.83 139.83,110.19 139.83,114.48 140.36,115.01 140.36,117.05 138.43,118.98 138.43,125.45 v6(137.87,126.01)
PWM1_4PH/ICCMAX4: length 62.9
  TOP w0.203: v8(139.47,128.65) PUZ1.18
  TOP w0.254: v8(97.32,138.62) 97.22,138.53 PUZ4.7 ; PRZ48.1 138.07,129.82 v2(138.89,129) 139.24,128.65 v8(139.47,128.65)
  IN1 w0.254: v8(97.32,138.62) 98.36,139.66 113.73,139.66 114.45,138.94 142.19,138.94 143.81,137.31 143.81,134.04 143.17,133.39 143.17,131.45 142.33,130.61 140.77,130.61 140.26,130.1 140.26,129.44 v8(139.47,128.65)
PWM1_A: length 12.6
  TOP w0.254: v5(88.77,132.36) 88.39,132.36 88.24,132.21 PUZ3.1 ; PUZ4.14 97.22,134.21 97.09,134.08 v5(97.09,133.44)
  IN2 w0.254: v5(88.77,132.36) 88.77,132.41 89.23,132.87 90.09,132.87 90.88,132.08 94.77,132.08 96.13,133.44 v5(97.09,133.44)
  BOTTOM w0.081: v2(96.62,133.94) 97.09,133.47 v5(97.09,133.44)
PWM1_B: length 5.1
  TOP w0.254: v5(96.25,132.48) 95.87,132.48 95.72,132.32 PUZ2.1 ; PUZ4.15 v5(97.72,133.44)
  IN2 w0.254: v5(97.72,133.44) 97.72,133.36 97.26,132.9 96.67,132.9 v5(96.25,132.48)
  BOTTOM w0.081: v5(96.25,132.48) 96.34,132.48 96.51,132.64 v2(96.96,132.64)
PWM1_FBVDDQ: length 9.5
  TOP w0.254: PRW12.2 2.44,54.98 v1(2.87,55.41) ; v5(4.79,62.25) 5.03,62 PUW2.1
  GND2 w0.254: v12(3.2,55.74) v1(2.87,55.41)
  IN2 w0.254: v5(4.79,62.25) 2.5,59.96 2.5,56.44 v12(3.2,55.74)
PWM1_FBVDDQ_R: length 2.6
  TOP w0.254: PUW1.20 5.47,54.44 4.95,54.96 PRW12.1
PWM2_2PH/ROSC1: length 2.5
  TOP w0.203: PRZ77.1 138.15,127.05 PUZ1.22
PWM2_4PH/ADDR: length 12.3
  TOP w0.203: PUZ1.19 138.98,128.25 v5(138.71,128.53) 138.18,129.06 PRZ2.1
  TOP w0.254: v5(135.03,132.72) 134.94,132.63 PUZ7.7
  IN3 w0.254: v5(138.71,128.53) 139.8,129.62 139.8,130.08 139.55,130.33 138.71,130.33 136.32,132.72 v5(135.03,132.72)
  BOTTOM w0.081: v5(138.71,128.53) v2(138.71,127.8)
PWM2_A: length 30
  TOP w0.203: PUZ7.14 130.41,132.63 v6(130.35,132.69)
  TOP w0.254: PUZ6.1 104.35,132.36 104.51,132.51 v5(104.89,132.51)
  IN4 w0.254: v6(130.35,132.69) 130.12,132.69 130.07,132.74 126.28,132.74 125.52,133.5 123.63,133.5 122.97,132.84 113.06,132.84 112.78,132.57 112.78,131.88 112.14,131.24 107.16,131.24 105.89,132.51 v5(104.89,132.51)
  BOTTOM w0.081: v5(104.89,132.51) v2(105.31,132.93)
PWM2_B: length 20.3
  TOP w0.203: PUZ7.15 130.4,132.13 v6(130.35,132.08)
  TOP w0.254: v5(113.33,132.39) 112.83,132.39 112.67,132.23 PUZ5.1
  IN4 w0.254: v6(130.35,132.08) 130.3,132.13 130.18,132.13 129.92,132.39 126.14,132.39 125.37,133.15 123.77,133.15 123.01,132.39 v5(113.33,132.39)
  BOTTOM w0.081: v2(113.88,132.96) 113.33,132.41 v5(113.33,132.39)
PWM2_FBVDDQ_R: length 22.9
  TOP w0.254: PUW1.19 5.87,54.73 v5(5.52,55.08) ; v6(13.13,39.16) PRW11.1
  IN4 w0.254: v6(13.13,39.16) 12.85,39.44 12.85,41.51 12.06,42.29 12.06,46.51 11.43,47.14 9.58,47.14 8.26,48.47 8.26,53.69 6.86,55.08 v5(5.52,55.08)
PWM3_4PH/VBOOT: length 9.7
  TOP w0.203: PUZ1.20 138.75,127.85 138.3,128.3 v8(137.87,128.3)
  TOP w0.254: v5(137.86,123.03) 137.74,123.15 PUZ10.7
  IN1 w0.254: v5(137.86,123.03) 138.2,123.37 138.2,125.5 138.35,125.66 138.35,127.28 137.87,127.76 v8(137.87,128.3)
  BOTTOM w0.081: v5(137.86,123.03) v2(138.51,123.03)
PWM3_A: length 10.2
  TOP w0.254: PUZ8.1 128.08,128.39 v5(128.46,128.01) ; PUZ10.14 133.61,123.15 v5(133.03,123.73)
  IN3 w0.508: v5(128.46,128.01) 129.15,127.32 129.68,127.32 130.76,126.24 130.76,124.39 131.42,123.73 v5(133.03,123.73)
  BOTTOM w0.081: v5(133.03,123.73) 132.83,123.73 v2(132.41,123.31)
PWM3_B: length 12
  TOP w0.254: PUZ10.15 133.41,122.65 v5(133.03,123.03) ; PUZ9.1 129.84,118.29 v5(130.07,118.07)
  IN4 w0.508: v5(133.03,123.03) 133.03,118.13 131.73,116.82 130.58,116.82 130.07,117.33 v5(130.07,118.07)
  BOTTOM w0.081: v5(130.07,118.07) v2(129.28,118.07)
PWM4_4PH/ROSC_MPH: length 2.4
  TOP w0.203: PRZ78.1 137.88,127.54 137.97,127.45 v2(139,127.45) PUZ1.21
PWR_B#: length 71.9
  IN3 w0.058: v9(147.74,35.56) 143.51,31.33 143.51,29.77 144.25,29.03 144.25,27.69 144.02,27.46 142.9,27.46 140.36,24.92 139.19,24.92 137.92,23.65 137.92,15.95 135.07,13.1 128.2,13.1 127.32,12.22 120.84,12.22 118.68,14.38 117.86,14.38 117.13,15.11 106.78,15.11 106.3,14.63 102.49,14.63 101.35,13.49 v9(101.35,12.47)
  GND4 w0.081: v9(101.35,12.47) v4(101.04,12.47) ; v9(147.74,35.56) v4(147.74,35.96)
  BOTTOM w0.081: RE160.1 RE154.2 v4(101.04,12.47) 101.04,11.21 QE13.3 102.54,10.7 v2(102.63,10.61)
PWR_B_7313#: length 8.1
  IN3 w0.058: v9(105.66,10.95) 105.59,10.87 100.13,10.87 v9(100.08,10.82)
  GND4 w0.081: v4(99.66,10.7) 99.79,10.82 v9(100.08,10.82) ; v4(106.07,10.87) 106,10.95 v9(105.66,10.95)
  BOTTOM w0.081: UE8.14 v4(106.07,10.87) 106.03,10.87 v2(105.66,10.51)
PWR_B_EC: length 36.1
  TOP w0.076: v8(80.42,13.67) 80.17,13.92 UE5.G9
  IN1 w0.058: v11(102.54,14.32) 102.02,13.79 99.95,13.79 98.7,15.04 91.97,15.04 86.56,9.63 85.09,9.63 84.65,9.19 83.95,9.19 83.26,9.88 81.83,9.88 81.14,10.57
  IN1 w0.076: 81.14,10.57 80.42,11.3 v8(80.42,13.67)
  GND2 w0.081: v11(102.54,14.32) 102.87,14.32 v3(102.93,14.25)
  GND4 w0.081: v3(102.93,14.25) 102.93,14.44 v4(103.12,14.63)
  BOTTOM w0.081: v4(103.12,14.63) 103.31,14.44 103.31,13.63 RE1616.1 103.09,12.92 v2(103.09,11.86) 102.57,11.35 QE13.2
PWR_G#: length 62.3
  IN4 w0.058: v7(100.24,16.62) 100.28,16.65 109.33,16.65 110.8,15.18 115.95,15.18 117.05,14.08 122.13,14.08 122.83,14.78 129.96,14.78 130.34,14.4 131.83,14.4 132.61,15.19 132.61,15.66 133.07,16.11 v7(133.07,22.74)
  BOTTOM w0.081: v7(100.24,16.62) RE156.2 101.11,16.11 100.9,15.9 100.9,14.38 101.09,14.19 QE21.3 ; JIO2.H10 147.74,23.74 146.96,22.96 v10(140.25,22.96) 133.3,22.96 v7(133.07,22.74)
PWR_G_7313#: length 17.2
  IN2 w0.058: v5(97.01,10) 99.6,12.58 v4(99.6,14.19)
  BOTTOM w0.081: v5(97.01,10) 97.47,10 v2(97.49,9.97) 97.76,9.7 105.53,9.7 106.86,11.03 107.42,11.03 107.57,11.18 UE8.11
PWR_LED#: length 6.8
  TOP w0.076: UE5.A3 76.72,12.36 76.58,12.22
  TOP w0.081: 76.58,12.22 75.9,11.53 v2(75.9,11.41) 75.56,11.08 73.47,11.08 72.9,11.65 72.07,11.65 72.01,11.58 QE4.2
PWR_R#: length 67.1
  IN3 w0.058: 117.24,31.33 118.62,31.33 119.7,32.41 119.7,32.86 120.08,33.24 120.62,33.24 121.27,32.59 127.94,32.59 128.55,33.2 128.55,33.84 128.87,34.16 137.42,34.16 140.5,31.08 143.04,31.08 146.62,34.66 146.62,35.07 v9(147.14,35.59) ; v9(101.23,19.66) 101.46,19.66 103.93,22.13 107.7,22.13 107.93,22.36 107.93,22.69
  IN3 w0.089: 107.93,22.69 107.93,24.3 107.38,24.86 107.38,25.68 108.9,27.2 108.9,27.9 109.35,28.35 109.35,30.51 110.17,31.33 114.3,31.33 114.94,30.7 116.38,30.7 117.02,31.33 117.24,31.33
  GND4 w0.081: v4(100.97,19.46) 101.03,19.46 v9(101.23,19.66) ; v9(147.14,35.59) v4(147.14,35.96)
  BOTTOM w0.081: v2(100.39,21.08) 100.31,21 RE157.1 RE158.2 101.17,19.67 v4(100.97,19.46) 100.84,19.33 100.84,18.06 101.22,17.68 QE22.3
PWR_R_7313#: length 22.3
  IN2 w0.058: v4(99.66,17.68) 99.66,15.13 99.26,14.74 99.26,12.86 v5(96.39,9.98)
  BOTTOM w0.081: UE8.10 108.07,11.22 107.45,10.61 v2(107.15,10.61) 106.7,10.61 105.61,9.51 96.86,9.51 v5(96.39,9.98)
PWR_R_EC: length 33.9
  TOP w0.076: UE5.E13 78.91,17.11 78.91,16.68 v8(79.18,16.41)
  TOP w0.081: RE1615.1 88.47,12.28 v8(88.28,12.47)
  IN1 w0.058: v11(100.74,15.5) 100.48,15.76 91.69,15.76 88.6,12.67 88.47,12.67 v8(88.28,12.47) 88.07,12.47 87.05,11.46 87.05,11.46 86.72,11.13 86.72,10.75 86.36,10.39 84.05,10.39 83.87,10.57
  IN1 w0.076: v8(79.18,16.41) 79.4,16.41 79.68,16.13 79.68,15.73 81.36,14.05 81.36,13.79 81.54,13.61 81.77,13.61 81.91,13.47 81.91,12.5 81.66,12.25 81.66,11.79 81.97,11.48 82.96,11.48 83.87,10.57
  GND2 w0.081: v12(100.71,15.2) 100.71,15.47 v11(100.74,15.5)
  IN2 w0.058: v3(101.56,18.33) 100.71,17.48 v12(100.71,15.2)
  GND4 w0.081: v4(101.56,18.33) v3(101.56,18.33)
PWR_SRC_ON: length 13.5
  TOP w0.254: RV9.2 29.57,145.89 30.38,145.89 CV15.2 30.42,145.93 31.24,145.93 RV12.1 31.25,147.27 31.89,147.91 33.82,147.91 34.85,146.88 34.85,145.77 35.31,145.32 36.07,145.32 v2(36.08,145.31) 36.97,144.41 37.25,144.41 38.06,143.6 QV1.3
PWRSHARE_EN_EC#: length 76.5
  TOP w0.081: v5(11.19,5.49) v2(10.59,5.49)
  IN1 w0.058: v5(11.19,5.49) 12.5,5.49 14.61,7.6 14.72,7.6 15.81,8.69 16.08,8.95 67.03,8.95 70.56,12.48 70.56,14.63 71.8,15.88 71.8,16.01 73.65,17.85 76.44,17.85 76.58,17.72
  IN1 w0.076: 76.58,17.72 77.02,17.27 77.33,17.27 77.44,17.17 78.01,17.17 78.06,17.12 78.27,17.12 78.32,17.17 79.36,17.17 v8(79.67,16.87)
  BOTTOM w0.081: v5(11.19,5.49) 10.71,5.49 JIO1.A1
QPCP_CHG: length 3.1
  TOP w0.081: v2(43.69,21.03) 44.02,21.03 v5(44.39,20.67)
  TOP w0.203: PCB18.1 43.97,20.25 v5(44.39,20.67)
  BOTTOM w0.203: v5(44.39,20.67) 44.71,20.35 PUB1.27
RASTER_SYNC1: length 22.3
  TOP w0.081: RG527.1 66.08,86.35 66.52,86.79 66.52,86.92 v8(66.55,86.95)
  IN1 w0.058: v8(55.45,84.55) 55.09,84.55 53.61,86.03 53.61,86.06 53.27,86.39 53.24,86.39 53.09,86.54 53.09,88.17 55.34,90.41 59.41,90.41 59.88,90.88 63.25,90.88 65.28,88.85 65.28,88.14 66.47,86.95 v8(66.55,86.95)
REF_ISL95338_1: length 1.8
  BOTTOM w0.203: PCV41.1 56.2,27.47 PUV3.29
REFADJ_GPU: length 3.9
  TOP w0.203: PUV1.40 72.37,31.87 71.88,32.35 v2(70.31,32.35) PRV81.1
REFIN_FBVDDQ: length 41
  TOP w0.081: v8(4.36,22.19) 4.37,22.18 4.38,22.18 4.71,21.85 v2(5.31,21.85)
  TOP w0.254: PRW22.2 2.78,50.57 v8(2.81,50.57) ; PUW1.6 5.47,51.02 5.22,50.76 3,50.76 v8(2.81,50.57) ; v8(2.81,50.57) PCW7.1
  IN1 w0.254: v8(2.81,50.57) 2.81,46.26 1.8,45.26 1.8,41.11 4.31,38.61 4.31,36.79 5.29,35.8 7.28,35.8 8.53,34.55 8.53,31.33 7.42,30.22 7.42,28.54 5.96,27.08 5.96,25.21 4.01,23.27 4.01,22.53 v8(4.36,22.19)
REFIN_GPU: length 4.6
  TOP w0.203: PUV1.1 71.15,30.7 v5(70.56,31.3) 69.79,31.3 69.56,31.52 PRV2.1
  BOTTOM w0.254: PRV69.1 v2(70.09,31.77) v5(70.56,31.3)
REFOUT_FBVDDQ: length 4.5
  TOP w0.254: PUW1.12 8.59,52.27 9.53,51.34 PRW60.1 10.4,50.83 11.62,50.83 PCW1.1
REFOUT_GPU: length 3.9
  TOP w0.203: PUV1.23 77.23,27.9 77.8,27.34 77.8,27.2 v5(77.85,27.14)
  BOTTOM w0.081: v2(77.09,27.14) v5(77.85,27.14)
  BOTTOM w0.203: v5(77.85,27.14) 77.85,27.2 78.37,27.71 PRV213.1
REMOTE1+: length 20.5
  TOP w0.081: Q2407.1 70.78,69.94 71.43,69.29 Q2407.2 73.14,69.29 v8(73.28,69.43) 74.22,69.43 74.34,69.56 74.7,69.56 v2(75.01,69.26) ; U2407.2 60.63,69.98 v8(61.34,70.69)
  IN1 w0.058: v8(61.34,70.69) 62.05,71.4 62.79,71.4 62.99,71.61 70.41,71.61 72.58,69.43 v8(73.28,69.43)
REMOTE1-: length 15.9
  TOP w0.081: v8(61.34,71.61) R184.1 ; Q2407.3 72.44,70.35 v8(73.28,70.35) 74.37,70.35 v2(74.45,70.42)
  IN1 w0.058: v8(61.34,71.61) 62.61,71.61 62.81,71.81 70.84,71.81 72.3,70.35 v8(73.28,70.35)
REMOTE2+: length 86.7
  TOP w0.081: U2407.4 59.63,69.81 59.11,70.34 59.11,71.15 v8(59.56,71.61)
  IN1 w0.058: v8(59.56,71.61) 60.17,71.61 60.86,72.29 71.44,72.29 72.26,71.47 80.45,71.47 81.43,70.49 81.43,67.69 81.94,67.19 83.22,67.19 84.8,65.61 84.8,64.24 84.86,64.18 v11(84.86,64.16)
  GND2 w0.081: v3(85.88,64.16) v11(84.86,64.16)
  GND4 w0.081: v4(86.55,64.16) v3(85.88,64.16)
  IN4 w0.058: v7(111.25,55.32) 111.3,55.32 113.69,57.71 118.2,57.71 118.63,58.14 118.63,59.67 119.25,60.29 v7(119.25,60.54)
  BOTTOM w0.081: Q2408.1 119.78,66.73 Q2408.2 119.78,64.53 C2505.1 119.25,64 v7(119.25,60.54) ; v4(86.55,64.16) 86.79,63.92 86.8,63.92 86.88,63.84 v2(86.88,58.96) 91.03,54.8 99.43,54.8 99.72,54.51 109.72,54.51 110.53,55.32 111.07,55.32 v7(111.25,55.32)
REMOTE2-: length 84.5
  TOP w0.081: v8(59.56,70.69) R184.2 60.45,70.26 60.13,69.94 U2407.3
  IN1 w0.058: v11(84.86,63.64) 84.56,63.94 84.56,65.56 83.39,66.73 81.99,66.73 81.1,67.62 81.1,70.32 80.2,71.23 72.04,71.23 71.18,72.09 60.99,72.09 59.59,70.69 v8(59.56,70.69)
  GND2 w0.081: v3(85.88,63.64) v11(84.86,63.64)
  GND4 w0.081: v3(85.88,63.64) 86.14,63.64 86.17,63.67 v4(86.54,63.67)
  IN4 w0.058: v7(118.85,60.54) 118.85,60.2 118.41,59.77 118.41,58.28 118.07,57.94 113.44,57.94 110.73,55.24 v7(110.73,54.93)
  BOTTOM w0.081: v7(110.73,54.93) 110.01,54.21 99.39,54.21 99.17,54.42 v2(90.86,54.42) 86.54,58.74 v4(86.54,63.67) ; v7(118.85,60.54) 118.85,64.16 C2505.2 118.48,64.53 Q2408.3
REMOTE3+: length 64.4
  TOP w0.081: U2407.5 59.13,69.8 58.61,70.32 v8(58.61,70.69)
  IN1 w0.058: v5(80.91,87.19) 81.29,86.81 81.29,72.84 80.08,71.63 72.55,71.63 71.6,72.57 65,72.57 64.19,73.38 60.33,73.38 59,72.06 59,71.3 58.61,70.91 v8(58.61,70.69)
  IN4 w0.058: v5(80.91,87.19) 80.95,87.23 80.95,98.91 79.22,100.64 79.12,100.64 v7(79.04,100.55)
  BOTTOM w0.081: v7(79.04,100.55) 79.11,100.62 79.39,100.62 81.01,102.25 81.01,103.13 C2511.1 81.03,103.8 81.03,104.22 Q2411.2 81.55,105.99 Q2411.1
REMOTE3-: length 60
  TOP w0.081: v8(58.61,71.61) R185.2
  IN1 w0.058: v5(80.91,86.57) 81.07,86.41 81.07,73 79.92,71.85 72.67,71.85 71.72,72.8 65.13,72.8 64.34,73.59 60.25,73.59 58.61,71.95 v8(58.61,71.61)
  IN4 w0.058: v5(80.91,86.57) 80.91,86.69 81.27,87.05 81.27,87.33 81.51,87.57 81.51,88.03 81.19,88.35 81.19,98.99 79.34,100.84 79.17,100.84 v7(79.04,100.97)
  BOTTOM w0.081: Q2411.3 80.77,104.22 80.77,103.8 C2511.2 80.77,103.14 80.77,102.56 v2(80.09,101.87) 79.17,100.95 79.05,100.95 v7(79.04,100.97)
RESET_N: length 2.7
  BOTTOM w0.081: RT102.1 100.97,141 100.84,141.12 UT4.F11
RF_+1VALWP: length 4
  TOP w0.081: PRH6.1 138.82,33.89 v2(138.6,34.11)
  TOP w0.254: PRH6.1 139.62,32.3 139.62,31.32 139.44,31.14 PUH1.5
ROM_CS#: length 30.8
  TOP w0.081: RG75.1 77.04,90.38 76.53,89.87 74.12,89.87 v10(73.15,88.9) 71.55,88.9 70.33,87.68 68.15,87.68 68.07,87.76 66.52,87.76 66.17,87.4 65.07,87.4 v8(64.69,87.02)
  IN1 w0.058: v8(64.69,87.02) 64.57,86.9 64.06,86.9 63.62,87.34 63.62,89.01 62.77,89.86 60.26,89.86 59.71,89.31 56.29,89.31 55.8,88.83 55.8,88.7 55.53,88.42 55.37,88.42 55.09,88.14 55.09,85.81 55.28,85.63 56.47,85.63 v8(56.85,85.25)
ROM_CS#_R: length 2.5
  TOP w0.081: UG34.1 75.03,90.58 75.16,90.45 RG75.2 RG74.2
ROM_SCLK: length 6.1
  TOP w0.081: RG100.1 59.88,81.24 59.18,81.94 59.18,82.96 58.56,83.58 58.56,83.98 58.32,84.22 57.88,84.22 UG1.BK3
ROM_SI: length 40.1
  TOP w0.081: v5(61.14,84.23) 61.14,83.78 62.48,82.43 62.48,77.96 62.74,77.7 66.95,77.7 v2(67.28,78.03) 68.1,78.03 68.23,77.89 68.23,77.22 67.73,76.71 66.6,76.71 65.91,76.02 65.91,74.73 66.39,74.25 RG87.2 RG84.1 ; v3(60.1,91.16) 60.1,91.63 61.28,92.82 61.75,92.82 61.87,92.94 61.87,93.22 61.97,93.32 62.81,93.32 63.27,93.77 63.27,94 63.5,94.23 63.85,94.23 64.57,94.95 65.23,94.95 66.01,95.72 RG77.2
  IN1 w0.058: v5(61.14,84.23) 60.73,84.64 59.16,84.64 58.37,83.85 v8(57.55,83.85)
  IN3 w0.058: v3(60.1,91.16) 60.1,89.99 59.84,89.74 59.84,85.52 v5(61.14,84.23)
ROM_SO: length 63.4
  IN1 w0.058: v3(67.3,82.29) 68.52,83.51 68.52,86.33 67.7,87.15 67.04,87.15 66.21,87.97 65.97,87.97 65.82,88.12 65.82,88.81 62.9,91.73 59.89,91.73 58.9,90.74 55.21,90.74 52.74,88.27 52.74,86.19 53.94,84.99 54.23,84.99 54.93,84.29 56.59,84.29 v8(57.55,85.25)
  IN2 w0.058: v3(67.3,82.29) 69.54,82.29 71.59,80.24 79.32,80.24 80.14,79.43 v4(80.55,79.43)
  GND4 w0.081: v4(66.91,82.29) v3(67.3,82.29)
  BOTTOM w0.081: v4(80.55,79.43) 81.75,80.63 81.75,87.67 80.6,88.82 v2(80.21,88.82) 77.04,91.99 v4(77.04,92.1) ; RG85.1 v4(66.91,82.29)
RPD_G1: length 2.1
  BOTTOM w0.081: RT64.1 97.19,144.61 97.45,144.36 97.45,143.37 97.7,143.12 UT4.K9
RPD_G2: length 2.4
  BOTTOM w0.081: UT4.K10 98.2,143.13 98.42,143.36 98.42,143.51 98.44,143.52 98.44,143.72 98.42,143.74 98.42,144.13 99,144.71 99.1,144.71 99.38,144.99 RT65.1
RTC_CELL: length 4.8
  BOTTOM w0.081: QE58.2 87.31,21.58 87.35,21.55 87.35,20.28 RE662.1 87.77,19.32 88.53,18.56 UE10.22
RTC_DET: length 23.1
  TOP w0.089: UH1.BE21 102.9,26.34 102.71,26.15 102.71,25.56 v3(102.4,25.25)
  IN3 w0.089: v4(88.27,23.29) 88.43,23.13 91.67,23.13 92.53,22.27 94.77,22.27 95.38,22.88 95.38,23.08 96.03,23.73 96.27,23.73 96.4,23.6 96.66,23.6 97.43,22.82 97.85,22.82 98.21,23.18 98.21,23.56 100.48,25.83 101.73,25.83 102.31,25.25 v3(102.4,25.25)
  BOTTOM w0.081: RE724.2 86.14,22.21 86.64,22.71 86.64,23.94 86.8,24.11 87.96,24.11 88.24,23.83 88.24,23.32 v4(88.27,23.29)
RTD3_CIO_PWR_EN: length 152.4
  GND2 w0.089: v1(113.41,36.22) v3(113.03,36.22)
  IN3 w0.058: v9(77.6,121.06) 77.55,121.11 77.55,122.33 76.82,123.06 76.82,129.82 72.12,134.51 72.12,136.79 72.58,137.25 82.73,137.25 84.07,137.25 84.12,137.3 84.77,137.3 85.07,137 88.04,137 89.34,138.3 89.34,139.75 88.55,140.54 88.55,140.98 87.63,141.9 87.63,142.14 87.53,142.24 87.07,142.24 86.88,142.44 86.88,142.87 v9(86.89,142.87)
  GND4 w0.081: v9(86.89,142.87) 87.21,143.19 v4(87.21,143.21) ; v9(77.6,121.06) 77.71,121.06 v4(77.84,120.93)
  GND4 w0.089: v3(113.03,36.22) v6(112.65,36.22)
  IN4 w0.058: 89.84,48.12 88.87,49.08 88.87,50.95 85.64,54.19 85.64,70.3 v7(86.39,71.05)
  IN4 w0.089: 89.84,48.12 90.64,47.31 91.4,47.31 91.72,47 95.5,47 95.65,47.14 97.36,47.14 97.62,46.88 97.86,46.88 100.22,44.52 103.78,44.52 106.13,42.17 107.54,42.17 107.96,41.75 107.96,41.42 111.06,38.32 111.57,38.32 111.63,38.25 111.63,37.24 v6(112.65,36.22)
  BOTTOM w0.081: v4(77.84,120.93) 77.84,118.15 v2(81.51,114.47) 82.27,113.72 83.36,113.72 83.59,113.49 83.59,112.93 83.26,112.6 83.26,111.24 83.26,111.09 87.52,106.83 87.52,98.96 87.08,98.52 87.08,98.37 87.08,98.37 87.08,71.74 v7(86.39,71.05)
RTD3_CIO_PWR_EN_R: length 4
  GND2 w0.081: v4(86.63,143.21) 86.63,142.81 86.64,142.79 v1(86.64,142.52)
  BOTTOM w0.081: UT1.F1 85.08,145.26 86.5,143.84 RT36.2 v4(86.63,143.21)
RTD3_USB_PWR_EN: length 163.1
  TOP w0.081: v6(88.54,138.5) 89.44,138.5 v2(89.57,138.37)
  TOP w0.089: v6(102.36,24.67) 102.81,25.12 102.81,25.32 102.88,25.4 102.88,25.94 UH1.BF21
  IN4 w0.058: v6(88.54,138.5) 87.66,139.38 87.01,139.38 86.64,139.75 78.85,139.75 78.66,139.95 74.47,139.95 74.01,139.49 73.05,139.49 72.53,138.97 72.53,137.83 70.05,135.34 66.81,135.34 66.01,134.54 66.01,122.35 66.87,121.49 66.87,116.91 64.71,114.75 64.71,111.74 63.25,110.28 63.25,96.62 63.14,96.5 63.14,93.26 65.13,91.27 65.13,76.93 75.76,66.3 75.76,58.45 76.61,57.6 76.61,55.53 78.22,53.91 78.22,50.25 77.89,49.91 77.89,44.65 79.93,42.61 79.93,42.04 80.82,41.15 81.38,41.15 85.65,36.89 85.65,34.7 87.87,32.48 87.87,29.95 89.05,28.77 90.32,28.77
  IN4 w0.089: v6(102.36,24.67) 101.32,25.71 100.13,25.71 99.82,26.01 96.39,26.01 95.91,25.53 94.54,25.53 94.16,25.91 93.75,25.91 92.01,27.65 91.44,27.65 90.32,28.77
RTD3_USB_PWR_EN_R: length 12.9
  TOP w0.081: v1(82.47,145.98) 82.47,146.54 RT37.1
  GND2 w0.081: v4(83.03,146.1) 82.56,146.1 82.47,146.02 v1(82.47,145.98)
  IN3 w0.058: v4(83.03,146.1) 83.67,145.47 83.67,144.33 83.34,144 83.34,143.43 83.96,142.81 84.9,142.81 86.34,141.37 86.34,139.31 86.97,138.69 87.77,138.69 v3(87.96,138.5)
  BOTTOM w0.081: v4(83.03,146.1) 83.33,146.4 UT1.D4
SA_SW: length 3.6
  TOP w0.081: v10(150.74,107.48) 150.24,107.98 PLG02.1
  BOTTOM w0.508: PRA2.1 145.33,105.16 v5(145.31,105.15)
SATA_GP1: length 39.2
  TOP w0.081: JSSD3.69 120.59,9.81 120.59,12.78 119.59,13.78 115.15,13.78 114.52,14.4 v2(114.52,16.11) v1(114.52,17.37)
  TOP w0.122: v5(113.18,33.97) 113.46,34.24 UH1.AJ43
  GND2 w0.081: v1(114.52,17.37) 114.34,17.55 v12(114.3,17.55)
  IN2 w0.058: 114.17,22.69 114.17,22.68 114.16,22.67 114.16,22 113.03,20.87 113.03,20.4 112.68,20.05 112.68,18.84 113.97,17.55 v12(114.3,17.55)
  IN2 w0.089: 114.17,22.69 114.17,25.5 113.39,26.29 113.39,27.38 112.29,28.47 112.29,29.49 111.68,30.1 111.68,31.09 112.8,32.21 112.8,33.59 v5(113.18,33.97)
  BOTTOM w0.081: JSSD3.69 120.33,9.55 122.17,9.55 122.87,10.25 R364.1
SATA_GP4: length 44.6
  TOP w0.089: UH1.AM46 114.9,32.78 114.73,32.62 v8(114.5,32.62)
  IN1 w0.089: v11(110.41,25.17) 110.41,25.83 111.21,26.63 111.21,27.9 111.96,28.65 111.96,29.7 111.71,29.95 111.71,30.43 112.83,31.55 114.05,31.55 114.5,32.01 v8(114.5,32.62)
  GND2 w0.089: v11(110.41,25.17) 110.41,24.89 v12(110.71,24.6)
  IN2 w0.058: v5(95.03,12) 95.03,11.93 95.63,11.33 96.5,11.33 96.77,11.6 97.19,11.6 97.78,11.6 99.1,12.92 99.1,17.71 99.7,18.3 100.89,18.3 101.3,18.71 101.87,18.71 103.32,17.26 105.77,17.26 106.13,17.62 106.13,18.67 106.4,18.94 109.78,18.94 110.8,19.95 110.8,21.24 111.07,21.51 111.07,22.69
  IN2 w0.089: v12(110.71,24.6) 110.71,24.09 111.07,23.73 111.07,22.69
  BOTTOM w0.081: JSSD1.69 95.03,9.05 v2(95.03,10.44) v5(95.03,12) R363.1
SCL_CHG: length 2.1
  BOTTOM w0.203: PUB1.4 48.45,17.87 48.96,17.36 PRB16.2
SCL_GPU: length 85.8
  TOP w0.081: PRV52.2 74.51,33.92 74.91,33.52 74.91,33.16 v5(74.74,32.98) 74.8,32.92 74.8,32.74 74.49,32.43 74.49,31.9 74.37,31.78 PUV1.35 ; QG7.3 61.65,92.03 61.65,91.24 v1(61.71,91.18)
  GND2 w0.081: v1(61.71,91.18) v12(61.71,91.46)
  IN2 w0.058: v5(80.92,40.34) 81.29,40.34 81.6,40.65 81.6,42.95 81.35,43.21 81.35,56.98 80.71,57.62 80.71,68.85 82.19,70.33 82.19,84.41 78.75,87.85 69.57,87.85 66.5,90.93 63.83,90.93 63.14,91.61 61.87,91.61 v12(61.71,91.46)
  IN4 w0.058: v5(74.74,32.98) 74.8,33.05 74.8,35.56 75.18,35.94 75.18,37.42 76.93,39.18 77.69,39.18 78.53,40.02 80.6,40.02 v5(80.92,40.34)
  BOTTOM w0.081: v5(74.74,32.98) 74.74,32.67 74.68,32.6 74.66,32.6 PRV37.1
SD_RCOMP_1P8: length 4.3
  TOP w0.254: UH1.BE5 94.83,26.92 v5(94.97,27.05)
  BOTTOM w0.203: v5(94.97,27.05) 94.18,26.27 v2(94.18,25.3) 93.92,25.03 93.92,23.91 RH214.1
SD_RCOMP_3P3: length 7.6
  TOP w0.254: v5(94.88,25.96) 94.76,25.96 UH1.BE4
  BOTTOM w0.089: RH215.1 93.22,24.16 93.57,24.16 93.66,24.25 93.66,26.43 v2(93.91,26.68) 93.91,26.72 94.61,27.41 95.23,27.41 95.38,27.27 95.38,26.46 v5(94.88,25.96)
SDA_CHG: length 1.9
  BOTTOM w0.203: PUB1.3 49.18,18.27 PRB20.2
SDA_GPU: length 91
  TOP w0.081: v1(60.53,91.24) 60.53,90.17 61.4,89.3 v2(62.32,89.3) 62.82,89.79 QG7.6 ; PRV53.2 75.54,33.92 75.12,33.51 75.12,33.24 v5(75.37,32.99) 75.04,32.66 75.01,32.66 74.74,32.39 74.74,31.78 74.77,31.75 PUV1.34
  GND2 w0.081: v1(60.53,91.24) 60.53,91.42 v12(60.71,91.59)
  IN2 w0.058: v12(60.71,91.59) 60.91,91.8 63.22,91.8 63.91,91.11 66.57,91.11 69.65,88.03 78.83,88.03 82.37,84.49 82.37,70.25 80.9,68.78 80.9,57.69 81.53,57.06 81.53,43.28 81.79,43.03 81.79,40.57 v5(80.92,39.7)
  IN4 w0.058: v5(75.37,32.99) 74.99,33.37 74.99,35.49 75.36,35.86 75.36,37.34 77.01,38.99 77.77,38.99 78.61,39.83 80.8,39.83 v5(80.92,39.7)
  BOTTOM w0.081: PRV31.1 75.06,32.43 75.06,32.68 v5(75.37,32.99)
SENSE_VCCIO: length 2.8
  TOP w0.081: v2(136.84,56.95) 136.68,56.78 PRH16.2
  TOP w0.254: PRH16.2 136.07,56.61 PRH12.1 136.02,55.86 PRH20.2
SH_IN_N3: length 2
  TOP w0.254: RG1571.2 7.24,30.06 6.87,30.43 UG37.13
SH_IN_N4: length 2.2
  TOP w0.254: UG37.16 8.07,30.5 8.89,29.68 RG1573.2
SH_IN_P3: length 1.9
  TOP w0.254: UG37.12 6.47,30.07 6.41,30.02 RG1570.2
SH_IN_P4: length 2
  TOP w0.254: RG1572.2 8.06,29.87 7.67,30.27 UG37.15
SH_O1: length 5.7
  TOP w0.254: RG1563.2 CG7120.1 4.56,38.64 4.56,36.73 4.93,36.36 v2(4.93,36.24) 5.27,35.91 UG37.32
SH_O2: length 3.2
  TOP w0.254: RG1564.2 2.55,30.63 2.55,31.33 CG7121.1 2.98,31.4 3.38,31.79 3.45,31.79 v2(3.52,31.86) 3.77,32.11 UG37.7
SKIP: length 6.7
  TOP w0.254: UG37.25 8.07,35.46 8.32,35.71 v2(9.75,35.71) 9.8,35.71 10.16,36.07 10.16,38.22 11.07,39.13 11.07,39.44 RG135.1
SLP_S3: length 4.6
  BOTTOM w0.081: QE1.3 129.49,16.54 128.29,16.54 128.21,16.62 RE15.2 127.4,18.08 UE1.12
SLP_S5: length 71.3
  TOP w0.081: v8(71.88,9.91) 71.22,9.91 70.71,10.42 70.71,11.71 71.24,12.23 QE4.3
  IN1 w0.058: v11(124,11) 123.73,11.27 120.08,11.27 119.77,11.58 111.19,11.58 110.36,10.75 108.64,10.75 107.05,12.34 106.42,12.34 105.93,11.85 103.78,11.85 103.44,12.19 98.45,12.19 97.68,11.43 90.9,11.43 86.92,7.45 86.11,7.45 85.53,6.87 83.84,6.87 83.27,6.87 82.88,7.27 82.06,7.27 81.76,7.57 79.78,7.57 79.2,8.16 76.11,8.16 75.15,9.12 72.67,9.12 v8(71.88,9.91)
  GND2 w0.081: v12(124,11.33) v11(124,11)
  IN2 w0.058: v12(124,11.33) 124,13.24 128.22,17.45 v4(128.22,18.03)
  BOTTOM w0.081: v4(128.22,18.03) RE16.2 127.66,18.58 UE1.11
SM_PG_CTRL: length 15.2
  TOP w0.081: UC2.4 141.18,50.27 141.29,50.38 141.29,51.03 v8(141.05,51.27) 141.05,52.16 v2(140.89,52.31)
  IN1 w0.058: v8(141.05,51.27) 141.05,49.51 142.71,47.84 142.71,44 145.55,41.16 v1(145.92,41.16)
SMBALERT#: length 6.8
  TOP w0.089: UH1.BE25 104.23,26.5 104.21,26.48 104.01,26.48 103.84,26.65 103.84,26.74 103.6,26.98 v5(103.6,27.23)
  BOTTOM w0.089: RH95.2 v2(104.23,30.2) 103.49,29.47 103.49,28.73 103.79,28.44 103.79,27.42 v5(103.6,27.23)
SML0ALERT#: length 11.7
  TOP w0.089: UH1.BF24 104.5,26.2 v8(104.55,26.24)
  IN1 w0.058: 103.25,22.69 102.97,22.41 102.97,21.01 102.51,20.55 102.51,20.45 v8(102.29,20.22)
  IN1 w0.089: 103.25,22.69 103.25,22.83 103.82,23.4 105.56,23.4 105.82,23.65 106.43,23.65 106.93,24.16 106.93,25.63 106.32,26.24 v8(104.55,26.24)
SML0CLK: length 28.2
  TOP w0.081: RH501.2 101.95,22.36 101.95,22.69
  TOP w0.089: 101.95,22.69 v13(101.95,23.19) 101.95,23.43 102.48,23.95 103.56,23.95 103.57,23.97 104.97,23.97 105.06,24.06 105.06,24.3 v5(104.86,24.5) 104.86,24.5 105,24.63 105,24.82 104.96,24.87 104.96,25.29 105.02,25.36 105.02,25.78 104.81,25.99 UH1.BF25
  IN4 w0.089: v7(92.87,27.54) 92.87,28.94 92.96,29.02 93.25,29.02 93.34,28.94 93.34,26.6 93.43,26.51 93.64,26.51 93.73,26.6 93.73,28.32 93.81,28.41 94.75,28.41 95.58,27.58 95.58,27.16 96.27,26.47 101.2,26.47 101.48,26.19 101.98,26.19 102.49,25.68 104.7,25.68 104.96,25.43 104.96,24.86 105.02,24.8 105.02,24.66 v5(104.86,24.5)
  BOTTOM w0.089: CH249.1 104.28,23.92 v5(104.86,24.5)
SML0DATA: length 28.5
  TOP w0.081: RH502.2 102.18,22.38 102.18,22.69
  TOP w0.089: UH1.BE24 104.6,26.74 104.63,26.77 104.9,26.77 105.04,26.63 105.04,26.02 105.2,25.86 105.2,25.28 105.13,25.22 105.13,24.94 105.18,24.9 105.18,24.77 v5(105.44,24.5) 105.24,24.3 105.24,23.99 105.04,23.79 103.64,23.79 103.63,23.78 102.55,23.78 102.18,23.41 102.18,22.69
  IN4 w0.089: v5(105.44,24.5) 105.19,24.75 105.19,24.87 105.13,24.93 105.13,25.5 104.78,25.86 102.56,25.86 102.05,26.37 101.55,26.37 101.27,26.65 96.34,26.65 95.76,27.23 95.76,27.65 94.74,28.67 v7(93.85,28.67)
  BOTTOM w0.089: v7(93.85,28.67) 93.85,29.23 92.87,30.21 UM4.10 ; v5(105.44,24.5) 105.14,24.2 CH248.1
SML1CLK: length 20
  TOP w0.081: QH5.6 107.9,15.27 CH251.1 108.97,15.08 108.88,14.99 108,14.99 106.98,13.97 105.99,13.97 v2(105.87,14.09) 105.33,14.63 105.33,15.22 104.69,15.86 104.69,18.3 v8(104.52,18.47) ; v8(104.24,22.1) 103.94,22.4 103.94,22.69
  TOP w0.089: UH1.BF27 106.1,26 106.1,23.94 105.38,23.22 105.11,23.22 105.07,23.18 104.48,23.18 104.44,23.22 104.27,23.22 103.94,22.89 103.94,22.69
  IN1 w0.058: v8(104.24,22.1) 104.3,22.04 104.3,20.95 104.96,20.29 104.96,18.76 104.67,18.47 v8(104.52,18.47)
SML1DATA: length 13.2
  TOP w0.081: QH5.3 105.43,17.36 CH250.1 105.14,17.44 104.9,17.68 104.9,18.6 v8(104.65,18.85) ; 103.73,22.69 103.73,22.46 v8(103.37,22.1)
  TOP w0.089: UH1.BE27 105.99,26.53 105.77,26.31 105.77,25.96 105.93,25.8 105.93,24.02 105.3,23.39 v13(104.78,23.39) 104.19,23.39 103.73,22.94 103.73,22.69
  IN1 w0.058: v8(103.37,22.1) 104.11,21.36 104.11,20.87 104.78,20.21 104.78,18.98 v8(104.65,18.85)
SMOD1: length 1.7
  GND2 w0.254: v1(24.59,42.42) v3(24.59,43.19)
  GND4 w0.254: v3(24.59,43.19) 24.55,43.23 v4(24.55,44.1)
SMOD2: length 1.6
  GND2 w0.254: v1(32.15,42.42) v3(32.15,43.32)
  GND4 w0.254: v3(32.15,43.32) 32.04,43.43 v4(32.04,44.02)
SMOD3: length 2.1
  GND2 w0.254: v3(39.57,43.09) 39.57,42.74 39.71,42.6 v1(39.71,42.42)
  GND4 w0.254: v3(39.57,43.09) 39.57,43.36 39.57,43.36 v4(39.57,43.88)
  BOTTOM w0.254: PRV151.1 39.57,44.26 v4(39.57,43.88)
SMOD4: length 2.3
  GND2 w0.254: v1(47.33,42.42) v3(47.33,43.09)
  GND4 w0.254: v3(47.33,43.09) 47.33,43.49 v4(47.63,43.79)
  BOTTOM w0.254: PRV139.1 47.12,44.25 47.52,43.84 47.54,43.84 47.59,43.79 v4(47.63,43.79)
SMOD5: length 1.7
  GND2 w0.254: v1(55.01,42.42) 55.01,42.64 55,42.65 v3(55,43.13)
  GND4 w0.254: v4(54.97,43.58) 55,43.54 v3(55,43.13)
  BOTTOM w0.254: PRV172.1 54.89,43.65 v4(54.97,43.58)
SMOD6: length 2.1
  GND2 w0.254: v1(62.76,42.42) 62.76,42.99 62.46,43.29 v3(62.46,43.4)
  GND4 w0.254: v4(62.46,43.88) v3(62.46,43.4)
  BOTTOM w0.254: PRV170.1 v4(62.46,43.88)
SMOD7: length 2
  GND2 w0.254: v1(70.31,42.42) 70.31,42.79 70.18,42.93 v3(70.18,43.23)
  GND4 w0.254: v4(70.17,43.79) 70.17,43.78 70.15,43.78 70.15,43.26 v3(70.18,43.23)
  BOTTOM w0.254: v4(70.17,43.79) 70.15,43.81 PRV193.1
SMOD8: length 1.7
  TOP w0.254: v5(71.61,78.42) 71.62,78.42 71.62,78.39 71.66,78.34 71.85,78.34 72.08,78.11 PUV11.2
  BOTTOM w0.254: v5(71.61,78.42) 71.78,78.59 PRV187.1
SNB1_NVVDD:
  vias: v2(29.54,49.7)
SNB2_NVVDD:
  vias: v2(37.08,49.84)
SNB3_NVVDD:
  vias: v2(44.72,49.8)
SNB4_NVVDD:
  vias: v2(52.5,49.94)
SNB5_NVVDD:
  vias: v2(60.13,49.86)
SNB6_NVVDD:
  vias: v2(68.02,49.89)
SNB7_NVVDD:
  vias: v2(75.23,49.2)
SNB8_NVVDD:
  vias: v2(76.76,89.16)
SNB_1.0VS_VGAP:
  vias: v2(68.1,108.08)
SNB_1.2V:
  vias: v10(149.83,60.95)
SNB_+1.8VGS:
  vias: v2(53.84,11.43)
SNB_+1VALWP: length 1.2
  BOTTOM w0.081: PCH8.1 v2(131.01,24.3)
SNB_VCCIO:
  vias: v2(129.86,51.16)
SPI_CLK: length 2.2
  BOTTOM w0.081: RE11.2 124.14,14.5 124.14,14.82 123.94,15.03 UE1.15
SPI_CS#: length 27.6
  IN3 w0.058: v9(136.91,16.34) 135.5,16.34 135.45,16.28 135.45,14.6 135.39,14.54 135.2,14.54 135.15,14.6 135.15,15.4 135.09,15.46 134.97,15.46 134.91,15.4 134.91,14.6 134.85,14.54 134.74,14.54 134.68,14.6 134.68,15.4 134.62,15.46 134.5,15.46 134.44,15.4 134.44,14.6 134.39,14.54 134.27,14.54 134.21,14.6 134.21,15.4 134.15,15.46 134.04,15.46 133.98,15.4 133.98,14.6 133.92,14.54 133.8,14.54 133.74,14.6 133.74,15.4 133.68,15.46 133.57,15.46 133.51,15.4 133.51,14.6 133.45,14.54 133.33,14.54 133.28,14.6 133.28,15.4 133.22,15.46 133.1,15.46 133.04,15.4 133.04,14.6 132.98,14.54 132.04,14.54 131.38,13.88 125.79,13.88 124.78,14.89 v9(124.46,14.89)
  GND4 w0.081: v9(124.46,14.89) 124.46,15.25 v4(124.44,15.27) ; v9(136.91,16.34) v4(137.23,16.34)
  BOTTOM w0.081: v4(137.23,16.34) RE12.2 137.86,16.97 UE2.1 ; UE1.14 v4(124.44,15.27)
SPI_MISO: length 2.1
  BOTTOM w0.081: RE10.2 123.44,14.45 UE1.16
SPI_MOSI: length 2.2
  BOTTOM w0.081: UE1.17 122.94,14.67 RE9.2
SPK_SEL: length 91
  TOP w0.076: 78.36,18.44 78.36,18.14 v8(78.38,18.11)
  TOP w0.081: RE201.2 78.36,18.44
  IN1 w0.076: v8(78.38,18.11) 78.38,18.09 78.52,17.95 78.77,17.95 79.22,17.5 79.86,17.5 80.25,17.11 80.27,17.11 80.41,16.97 80.41,16.95 80.42,16.94 80.42,15.97 81.02,15.36 v12(81.17,15.36) v11(81.17,15.03)
  GND2 w0.076: v11(81.17,15.03) v12(81.17,15.36)
  IN2 w0.058: 80.01,10.57 78.94,9.5 78.94,9.17 78.26,8.49 77.8,8.49 v3(77.55,8.23)
  IN2 w0.076: v12(81.17,15.36) 80.48,14.68 80.48,14.07 80.7,13.86 80.7,12.84 80.34,12.49 80.34,10.9 80.01,10.57
  IN3 w0.058: v3(77.55,8.23) 75.67,6.35 75.16,6.35 74.93,6.12 74.93,5.83 74.35,5.26 69.38,5.26 69.28,5.16 64.28,5.16 63.69,4.57 58.81,4.57 58.27,5.11 54.75,5.11 50.78,9.08 39.94,9.08 39.66,8.8 32.9,8.8 30.81,6.71 26.93,6.71 26.1,5.88 21.44,5.88 21.27,5.7 16.02,5.7 11.92,9.8 11.92,11.34 11.87,11.39 v9(11.18,11.39)
  GND4 w0.081: v9(11.18,11.39) v4(10.92,11.39)
  BOTTOM w0.081: JIO1.E2 10.06,11.88 10.54,11.39 v4(10.92,11.39)
STRAP0: length 43
  TOP w0.081: v8(66.88,74.73) 66.85,74.73 67.37,74.21 RG90.2 RG78.1
  IN1 w0.058: v8(66.88,74.73) 66.88,78.57 67.4,79.09 67.4,81.61 68.68,82.88 68.68,86.4 67.76,87.31 67.1,87.31 66.62,87.79 66.62,88.24 62.97,91.89 59.82,91.89 58.83,90.9 55.14,90.9 52.58,88.33 52.58,86.13 53.88,84.83 54.16,84.83 54.77,84.23 54.86,84.13 56.66,84.13 57.08,84.55 v8(58.25,84.55)
STRAP1: length 10.1
  BOTTOM w0.254: RG79.1 RG91.2 66.35,84.89 65.3,84.89 65.02,84.61 v2(63.5,84.61) 62.41,84.61 61.7,85.32 58.72,85.32 58.65,85.25 v4(58.25,85.25)
  vias: v1(58.25,85.25)
STRAP2: length 45.6
  TOP w0.081: v8(67.91,74.72) 67.95,74.72 68.42,74.25 RG92.2 RG80.1 ; UG1.BM4 v8(58.62,84.89)
  IN1 w0.058: v8(58.62,84.89) 58.62,84.56 58.36,84.29 58.14,84.29 58.05,84.39 57.14,84.39 56.73,83.97 54.26,83.97 52.26,85.97 52.26,88.47 55.01,91.22 57.56,91.22 58.2,91.85 59.15,91.85 59.34,92.05 63.04,92.05 66.78,88.31 66.78,87.86 67.17,87.47 67.83,87.47 68.84,86.46 68.84,82.78 67.56,81.51 67.56,79.02 67.33,78.79 67.33,75.3 v8(67.91,74.72)
STRAP3: length 94.9
  TOP w0.081: v8(83.21,66.22) 83.21,65.04 82.72,64.54 82.72,55.82 84.68,53.86 v2(85.16,53.86) 89.31,53.86 91.51,56.06 96.16,56.06 96.63,55.59 DG8.2 ; v8(71.26,70.14) 70.01,71.39 70.01,73.1 69.71,73.41 RG81.1 RG93.2 68.9,74.75 v8(68.92,74.75) ; UG1.BM5 59.36,85.54 59.36,85.09 v8(59.19,84.92)
  IN1 w0.058: v8(68.92,74.75) 68.9,74.75 67.49,76.15 67.49,78.73 67.72,78.96 67.72,81.42 69,82.69 69,86.54 63.15,92.38 61.86,92.38 61.66,92.58 59.23,92.58 58.82,92.17 58.06,92.17 57.43,91.54 54.88,91.54 51.69,88.35 51.69,85.84 51.84,85.69 52.32,85.69 54.24,83.77 56.75,83.77 57.21,84.23 57.98,84.23 58.08,84.13 58.42,84.13 59.19,84.9 59.19,84.92 v8(59.19,84.92) ; v8(83.21,66.22) 83.08,66.35 81.2,66.35 79.81,67.74 79.81,68.71 78.89,69.62 78.16,69.62 77.17,68.63 72.77,68.63 v8(71.26,70.14)
STRAP3_PCH: length 35.6
  TOP w0.081: v5(97.22,53.88) 98.33,54.99 DG8.1
  TOP w0.089: UH1.M45 114.78,42.67 116.36,42.67 116.71,42.32 v5(116.71,41.99)
  BOTTOM w0.081: v5(97.22,53.88) 98.34,52.76 111.63,52.76 114.15,50.24 114.16,50.24 114.17,50.22 ; 117.24,42.52 v2(117.37,42.65) 117.47,42.75 117.47,43.61 118.72,44.86 118.72,48.95 117.77,49.9 114.87,49.9 114.86,49.9 114.84,49.9
  BOTTOM w0.089: 117.24,42.52 v5(116.71,41.99) ; 114.17,50.22 114.5,49.9 114.84,49.9
STRAP4: length 12.1
  IN1 w0.058: v8(57.55,85.95) 57.81,86.21 59.08,86.21 60.17,85.12 63.76,85.12 64.13,85.49 65.21,85.49 66.91,83.79 v4(66.91,83.31)
  BOTTOM w0.254: RG82.1 v4(66.91,83.31)
STRAP5: length 95.6
  TOP w0.081: DG9.2 91.05,55.34 88.72,53.01 v1(85.6,53.01) 84.77,53.01 v2(83.6,54.19) 82.52,55.26 82.52,64.96 v4(82.89,65.33) ; RG1495.2 v1(86.07,28.26)
  IN1 w0.058: v4(66.91,81.28) 66.62,81.57 66.62,83.85 65.15,85.33 64.19,85.33 63.83,84.96 60.1,84.96 59.38,85.68 57.12,85.68 v8(56.85,85.95)
  GND2 w0.081: v1(86.07,28.26) 86.07,28.31 86.19,28.44 v12(86.25,28.44) ; v1(85.6,53.01) 85.6,52.99 85.36,52.75 v12(85.33,52.75)
  IN2 w0.058: v4(66.91,81.28) 67.98,81.28 70.15,79.1 71.97,79.1 72.16,78.91 73.32,78.91 73.39,78.84 79.07,78.84 79.46,78.46 79.46,73.96 79.63,73.79 v6(80.11,73.79) ; v12(85.33,52.75) 84.04,51.46 84.04,45.28 86.23,43.09 86.23,31.29 86.08,31.14 86.08,29.75 86.35,29.47 86.35,28.54 v12(86.25,28.44)
  BOTTOM w0.081: v6(80.11,73.79) 80.85,73.79 81.71,72.92 81.71,66.58 82.89,65.4 v4(82.89,65.33)
  BOTTOM w0.254: RG83.1 v4(66.91,81.28)
STRAP5_PCH: length 32.3
  TOP w0.081: DG9.1 96.16,53.64 v5(96.39,53.88)
  TOP w0.089: UH1.L48 116.25,43.07 v5(116.52,43.33)
  BOTTOM w0.081: 114.84,49.71 114.86,49.71 114.87,49.71 117.7,49.71 118.54,48.87 118.54,44.93 117.24,43.64 ; 114.04,50.09 114.02,50.1 114.02,50.11 111.56,52.58 v10(97.69,52.58) v5(96.39,53.88)
  BOTTOM w0.089: 114.84,49.71 114.42,49.71 114.04,50.09 ; 117.24,43.64 116.94,43.33 v5(116.52,43.33)
SUSACK#: length 9.7
  TOP w0.089: UH1.BE35 110.14,26.48 110.14,26.15
  TOP w0.122: v5(109.75,23.88) 109.37,24.25 109.37,25.38 110.14,26.15
  IN1 w0.058: 109.15,22.69 107.7,21.24 107.7,19.62 v8(108.06,19.25)
  IN1 w0.089: v5(109.75,23.88) 109.6,23.73 109.6,23.14 109.15,22.69
  BOTTOM w0.089: v5(109.75,23.88) 109.74,23.88 109.54,23.68 v2(109.21,23.68)
SUSCLK: length 87.4
  TOP w0.081: v8(95.38,9.88) 95.1,10.16 JSSD1.68 ; v8(119.9,10.92) 119.9,12.84 119.25,13.49 117.47,13.49 v2(116.85,12.86) 116.42,12.44 113.88,12.44 113.68,12.64 113.68,15.04 113.86,15.23 113.86,22.04 114.43,22.61 114.43,22.62 114.5,22.69
  TOP w0.089: v8(115.19,22.82) 114.64,22.82 114.5,22.69
  TOP w0.122: UH1.BE45 114.69,26.59 114.19,26.88 114.18,26.92 v5(114.18,26.95)
  IN1 w0.058: v8(95.38,9.88) 95.91,10.42 98.15,10.42 98.94,11.21 99.87,11.21 100.61,10.48 110.57,10.48 111.43,11.34 119.48,11.34 v8(119.9,10.92)
  IN1 w0.089: v8(115.19,22.82) 114.55,23.46 114.55,26.06 114.18,26.43 v5(114.18,26.95)
  IN3 w0.058: v9(142.34,28.73) 142.18,28.73 141.1,29.81 141.1,30.25 137.35,34 128.94,34 128.71,33.78 128.71,33.14 127.96,32.39 121.07,32.39 119.51,30.83 119.51,29.87 119.19,29.56 117.24,29.56
  IN3 w0.089: v5(114.18,26.95) 114.18,27.22 114.62,27.65 114.62,27.9 115.25,28.54 115.51,28.54 116.52,29.56 117.24,29.56
  GND4 w0.081: v9(142.34,28.73) v4(142.34,28.44)
SUSP#: length 449.5
  TOP w0.076: v12(80.17,12.86) 80.17,12.5 80.01,12.35 79.76,12.35 79.42,12.01 79.42,10.61 79.38,10.57
  TOP w0.081: UZ21.3 90.81,85.16 90.6,85.37 89.87,85.37 89.66,85.58 89.66,86.59 90.68,87.61 90.68,88.78 90.27,89.18 89.73,89.18 88.9,88.36 v2(87.55,88.36) v8(85.66,88.36) 85.16,88.36 84.3,89.22 84.3,101.77 80.33,105.74 80.33,113.4 v1(80.19,113.54) ; v8(81.23,3.96) 84.86,3.96 85.95,5.05 85.95,6.92 v8(85.06,7.8) ; v8(85.42,29.14) 83.6,29.14 83.26,29.48 83.26,29.87 83.14,29.98 Q8.3 82.31,29.98 81.98,30.32 81.98,31.24 82.3,31.56 82.3,32.57 81.99,32.88 81.99,35.51 81.57,35.92 81.57,37.2 83.23,38.86 83.23,42.96 81.37,44.81 81.37,45.12 81.37,52.38 79.5,54.26 79.5,67.34 80.14,67.97 80.14,72.75 83.27,75.89 v8(83.27,84.57) ; 79.38,10.57 v8(79.38,10.18) ; v1(84.71,111.97) 84.71,110.75 85.09,110.37 U20.4 ; v8(91.62,12.47) 91.16,12.47 88.9,14.73 88.9,17.41 88.98,17.49 89.66,17.49 89.79,17.36 U16.4
  IN1 w0.058: v6(139.95,29.54) 139.95,27.26 137.73,25.03 137.73,16.09 134.85,13.21 132.55,13.21 132.38,13.38 108.92,13.38 108.65,13.64 107.92,13.64 107.7,13.41 103.13,13.41 102.71,12.99 92.14,12.99 v8(91.62,12.47) 90.78,12.47 86.94,8.63 85.9,8.63 v8(85.06,7.8) 84.92,7.95 82.4,7.95 82.02,8.32 81.31,8.32 81.03,8.6 81.03,8.79 80.95,8.87 79.64,10.18 v8(79.38,10.18) 78.15,10.18 77.86,9.89 v11(77.5,9.89) ; v8(85.66,88.36) 83.27,85.97 v8(83.27,84.57) ; 81.99,18.44 85.52,21.97 85.52,29.03 v8(85.42,29.14) ; v8(81.23,3.96) 81.09,4.1 77.69,4.1 77.34,3.76 64.72,3.76 63.49,4.99 v3(63.49,5.07) ; v1(147.66,41.13) 147.4,41.13 147.39,41.11 146.88,41.11 146.3,41.68 v6(145.54,41.68) 145.26,41.68 142.88,44.07 142.88,47.91 141.73,49.05 141.73,51.59 141.48,51.84 139.2,51.84 v8(139.14,51.78)
  IN1 w0.076: v12(80.17,12.86) 80.17,12.63 v11(80.14,12.6) ; 81.99,18.44 81.72,18.44 v11(81.62,18.34)
  GND2 w0.076: 81.58,18.44 81.58,18.38 v11(81.62,18.34) ; v12(80.17,12.86) 80.14,12.84 v11(80.14,12.6)
  GND2 w0.081: v3(77.47,9.54) 77.5,9.57 v11(77.5,9.89) ; v1(80.19,113.54) 80.33,113.4 80.33,113.34 v3(80.52,113.16) ; v12(81.34,18.82) 81.58,18.58 81.58,18.44 ; v1(84.71,111.97) 84.53,111.79 v12(84.45,111.79)
  IN2 w0.058: v3(63.49,5.07) 63.41,5.07 62.97,5.51 60.68,5.51 58.67,7.52 58.67,14.63 60.71,16.66 60.71,21.43 61.14,21.87 66.67,21.87 68.2,20.35 68.2,16.04 v4(67.56,15.41) ; 80.68,18.44 80.68,18.61 80.9,18.82 v12(81.34,18.82) ; v3(80.52,113.16) 80.33,113.16 80.02,113.47 78.39,113.47 78.14,113.22 78.14,111.81 78.37,111.58 84.38,111.58 84.45,111.66 v12(84.45,111.79)
  IN2 w0.076: v12(80.17,12.86) 80.17,12.89 79.78,13.27 79.78,14.14 80.31,14.67 80.31,15.5 80.68,15.86 80.68,18.44
  IN3 w0.058: v9(10.4,13.88) 10.41,13.88 10.41,13.34 12.24,11.51 12.24,9.93 16.15,6.02 21.14,6.02 21.98,6.86 21.98,7.7 22.26,7.99 25.78,7.99 26.74,7.03 30.68,7.03 32.77,9.12 39.53,9.12 39.81,9.4 50.92,9.4 54.88,5.43 58.4,5.43 58.77,5.07 v3(63.49,5.07) ; v9(86.87,146.33) 86.61,146.33 86.21,145.93 86.21,142.47 87.35,141.33 87.75,141.33 88.23,140.84 88.23,140.41 89.02,139.62 89.02,138.44 87.91,137.32 85.21,137.32 84.91,137.62 83.99,137.62 83.94,137.57 82.86,137.57 82.59,137.57 72.45,137.57 71.8,136.92 71.8,134.38 76.35,129.83 76.35,117.63 80.31,113.67 80.31,113.36 v3(80.52,113.16)
  GND4 w0.081: v4(77.5,9.54) v3(77.47,9.54) ; v9(86.87,146.33) 87.17,146.33 v4(87.21,146.37) ; v4(10.22,14.19) 10.41,14 10.41,13.88 v9(10.4,13.88)
  IN4 w0.058: v6(145.54,41.68) 144.72,40.86 141.41,40.86 139.24,38.69 139.24,33 140.74,31.5 140.74,30.33 v6(139.95,29.54)
  BOTTOM w0.081: v4(77.5,9.54) 77.5,9.16 77.96,8.71 UZ45.3 ; v4(10.22,14.19) 10.22,13.12 JIO1.F2 ; R174.1 v4(67.56,15.41)
SUSP#_R: length 3.3
  BOTTOM w0.081: RT15.1 86.63,146.37 RT30.2 v2(85.78,145.75) 85.71,145.75 85.51,145.95 84.33,145.95 84.1,146.18 UT1.D2
SW1_2PH: length 34
  TOP w0.254: PLG01.2 v5(147.91,93.71)
  IN4 w0.152: v5(147.91,93.71) 147.91,93.71 147.91,94.4 142.66,99.66 142.66,119.19 142.81,119.35 142.81,120.09 v7(141.9,121.01)
  BOTTOM w0.081: PRZ59.2 v2(139.85,121.94)
  BOTTOM w0.254: PRZ59.2 PRZ15.2 v7(141.9,121.01)
SW1_FBVDDQ: length 11.4
  TOP w0.254: PRW2.2 7.07,56.37 7.28,56.57 10.54,56.57 10.88,56.91 v2(10.95,56.91) 11.21,56.91 11.71,57.41 15.18,57.41 v5(16.33,58.56)
  BOTTOM w0.254: PRW40.2 v5(16.33,58.56)
SW1_FBVDDQ_R: length 5.4
  TOP w0.254: PLW01.2 v5(15.37,60.83)
  BOTTOM w0.254: PRW58.1 15.18,57.64 PRW40.1 15.42,60.78 v5(15.37,60.83)
SW2_FBVDDQ: length 9.8
  IN4 w0.254: v6(12.05,55.72) 12.05,54.14 14.86,51.34 v7(18.02,51.34)
  BOTTOM w0.081: v7(18.02,51.34) 17.23,51.34 v2(17.02,51.55)
SW2_FBVDDQ_R: length 4.4
  TOP w0.254: v5(19.72,50.64) 19.99,50.37 PLW02.2
  BOTTOM w0.081: v5(19.72,50.64) 19.72,50.46 v2(20.2,49.98)
  BOTTOM w0.254: v5(19.72,50.64) 20.07,50.64 PRW59.1 20.13,51.34 PRW51.1
SW_1.2V: length 0.7
  TOP w0.081: 145.62,58.65 v10(144.87,58.65)
  vias: v5(146.11,60.99) v5(146.11,60.42) v5(146.11,59.84) v5(146.11,59.27) v5(148.65,50.32) v5(149.22,50.32)
SW_1PH: length 6.7
  TOP w0.152: PRZ11.2 150.75,109.12 150.11,109.76 147.15,109.76 147,109.6 147,108.13 147.15,107.98 PLG02.2
SW_+1VALWP: length 0.9
  TOP w0.254: PUH1.8 135.27,30.14 v5(135.13,30)
  vias: v5(129.22,33.62) v5(129.22,33.05) v5(129.22,32.48) v5(129.22,31.9) v5(129.22,31.33) v5(129.22,30.76) v5(129.41,28.54) v5(129.41,27.9) v5(129.86,33.62) v5(130.49,33.62) v5(131.06,33.62)
SWAPRDY_IN: length 10.3
  TOP w0.081: UG1.BB6 52.97,85.63 54.09,85.63 54.35,85.37 54.35,85.24 54.55,85.04 54.55,84.47 55.16,83.86 55.16,83.73 55.33,83.55 55.46,83.55 55.75,83.27 55.75,83.14 56.03,82.85 56.11,82.85 56.33,82.63 56.33,82.63 56.67,82.29 56.67,80.82 57.32,80.16 57.63,80.16 RG526.1
SWTRAP: length 2.7
  TOP w0.081: RE685.1 RE684.2 75.23,15.36 UE5.A9
SYS_PWROK: length 44.1
  TOP w0.076: 76.58,14.32 76.61,14.32 76.81,14.12 77.42,14.12 UE5.B7
  TOP w0.081: v3(73.43,12.75) 73.43,12.36 CE46.1 73.15,12.23 73.15,13.23 73.31,13.39 73.31,13.78 73.85,14.32 76.58,14.32
  TOP w0.122: UH1.AU3 93.86,30.5 93.77,30.41 93.76,30.41 93.65,30.31 93.39,30.31 93.11,30.03 92.33,30.03 v5(92.09,29.79)
  IN3 w0.058: v3(73.43,12.75) 73.53,12.75 73.74,12.96 73.75,12.96 73.99,13.2 73.99,15.48 73.72,15.75 73.72,16.37 72.96,17.13 72.96,19.32 74.78,21.14 78.05,21.14 78.86,21.94 79.9,21.94 79.96,22 80.72,22 81.23,21.49 82.78,21.49 83.46,22.18 83.46,22.49 83.79,22.82 85.15,22.82 87.57,25.24 87.57,26.79 88.6,27.82 89.86,27.82 90.32,28.27
  IN3 w0.089: v5(92.09,29.79) 90.57,28.27 90.32,28.27
  BOTTOM w0.089: v5(92.09,29.79) 92.36,29.79 v10(93.94,28.21)
SYS_RESET#: length 6.5
  TOP w0.081: RH571.1 CH175.1 89.48,28.61 RH5.2
  TOP w0.114: 90.37,29.59 89.93,30.04 RH571.1
  TOP w0.122: UH1.AU2 93.26,30.53 93.01,30.28 92.04,30.28 91.36,29.59 v2(90.92,29.59) 90.37,29.59
SYS_SWCLK: length 19.7
  TOP w0.081: v8(130.68,19.08) 130.68,17.61 129.86,16.79 129.06,16.79 JELC2.4 ; v5(124.39,19.33) 124.39,19.34 124.76,19.71 v2(125.02,19.71)
  IN1 w0.058: v5(124.39,19.33) 124.85,18.87 126.11,18.87 126.31,19.08 v8(130.68,19.08)
  BOTTOM w0.081: v5(124.39,19.33) 124.39,20.37 122.76,22 121.03,22 119.44,23.59 UE1.37
SYS_SWDIO: length 21.7
  TOP w0.081: JELC2.2 129.06,15.52 129.86,15.52 131.19,16.85 v8(131.19,19.08) ; v5(123.83,19.33) 123.83,19.94 v2(123.7,20.07)
  IN1 w0.058: v5(123.83,19.33) 124.59,18.57 125.98,18.57 126.24,18.32 130.43,18.32 v8(131.19,19.08)
  BOTTOM w0.081: UE1.34 120.19,22.58 120.96,21.82 122.35,21.82 123.83,20.34 v5(123.83,19.33)
SYSON: length 225.8
  TOP w0.076: v6(77.66,11.86) 77.41,11.61 76.67,11.61 76.58,11.52
  TOP w0.081: v8(80.47,69.93) 80.47,72.54 83.81,75.88 83.81,87.64 83.11,88.35 83.11,100.97 78.92,105.16 v1(78.92,108) ; v5(144.75,36.68) 145,36.92 146.82,36.92 148.32,38.42 148.32,40.91 148.07,41.16 148.07,42.46 PRM5.1 ; U19.4 v2(85.19,106.56) 85.04,106.56 v1(84.76,106.83) ; 76.58,11.52 75.69,10.63 CE191.2 ; v8(80.52,67.46) 80.33,67.46 79.88,67.02 79.88,54.39 81.74,52.54 81.74,44.97 83.59,43.11 83.59,38.7 81.94,37.05 81.94,36.08 82.31,35.7 Q9.3
  IN1 w0.058: v8(80.52,67.46) 80.09,67.9 80.09,69.55 v8(80.47,69.93) ; v3(80.33,21.31) 80.33,21.34 80.34,21.35 80.34,21.59 80.75,22 81.42,22 81.7,22.28 82.02,22.28 83.13,23.4 83.13,26.66 83.66,27.2 83.66,34.65 82.69,35.63 v8(82.69,35.64) ; 76.89,10.57 76.89,9.67 76.94,9.61 79.75,9.61 80.35,9.01 80.35,8.43 80.45,8.33 80.85,8.33 81.19,7.99 81.83,7.99 82.23,7.59 83.18,7.59 83.58,7.19 83.71,7.19 85.33,7.19 85.91,7.77 86.76,7.77 90.83,11.84 92.5,11.84 93.17,12.51 95.95,12.51 96.19,12.27 96.66,12.27 96.91,12.51 103.57,12.51 103.86,12.23 105.85,12.23 106.35,12.73 107.39,12.73 108.36,11.76 110.71,11.76 111.14,12.19 111.48,12.19 111.84,12.55 116.56,12.55 117.22,13.21 132.18,13.21 132.56,12.83 134.69,12.83 137.89,16.03 137.89,24.32 140.94,27.37 v6(140.94,32.31)
  IN1 w0.076: 76.89,10.57 76.89,11.08 v6(77.66,11.86)
  GND2 w0.081: v1(78.92,108) 79.27,107.65 v12(79.5,107.65) ; v12(84.48,107.11) v1(84.76,106.83)
  IN2 w0.058: v12(79.5,107.65) 83.95,107.65 84.48,107.12 v12(84.48,107.11)
  GND4 w0.081: v3(80.33,21.31) 80.08,21.31 v6(79.83,21.06)
  IN4 w0.058: 77.68,18.44 79.83,20.59 v6(79.83,21.06) ; v6(140.94,32.31) 140.94,32.49 140.36,33.07 140.36,37.05 141.52,38.2 143.26,38.2 144.75,36.71 v5(144.75,36.68)
  IN4 w0.076: 77.68,18.44 77.68,18.24 77.01,17.57 77.01,14.37 76.81,14.16 76.81,12.72 v6(77.66,11.86)
TBT_A_AUX_N: length 1.6
  TOP w0.081: v4(78.52,138.93) 78.26,138.67 78.26,138.19 CT44.2
  BOTTOM w0.081: v4(78.52,138.93) 78.2,139.25 UT1.W15
TBT_A_AUX_N_C: length 22.7
  IN1 w0.069: v4(92.18,143.41) 92.18,143.3 92.08,143.2 91.74,143.2 91.55,143.01 91.55,142.06 92,141.61 92,139.19 91.36,138.56 89.81,138.56 88.54,137.29 86.74,137.29 86.19,136.74 78.51,136.74 78.16,137.1 78.16,137.32 78.22,137.39 v8(78.47,137.39)
  BOTTOM w0.081: UT4.J2 93.76,142.87 93.13,142.87 92.68,143.31 92.28,143.31 v4(92.18,143.41)
TBT_A_AUX_P: length 1.6
  TOP w0.081: v4(77.86,138.94) 78.05,138.75 78.05,138.19 CT43.2
  BOTTOM w0.081: UT1.Y15 78.19,138.61 v4(77.86,138.94)
TBT_A_AUX_P_C: length 22.7
  IN1 w0.069: v8(77.84,137.39) 77.95,137.28 77.95,137.01 78.43,136.54 86.28,136.54 86.83,137.09 88.63,137.09 89.89,138.35 91.44,138.35 92.2,139.11 92.2,141.7 91.76,142.14 91.76,142.92 91.83,142.99 92.02,142.99 v4(92.18,142.84)
  BOTTOM w0.081: v4(92.18,142.84) 92.21,142.84 92.48,143.11 92.6,143.11 93.04,142.66 93.38,142.66 93.43,142.62 93.43,142.46 93.52,142.36 93.6,142.36 arc(93.64,142.37) 93.66,142.38 93.74,142.46 93.74,142.58 UT4.J1
TBT_A_CC1: length 21.3
  IN3 w0.381: v4(95.96,151.92) 97.03,151.92 97.57,152.47 101.84,152.47 103.04,151.27 103.04,149.68 102.87,149.52 102.87,149.09 103.01,148.95 103.01,147.52 102.95,147.46 102.95,147.23 102.76,147.04 101.62,145.9 98.84,145.9 v4(98.62,146.13)
  BOTTOM w0.254: UT4.L9 97.7,143.94 97.75,143.99 97.75,144.15 97.75,144.45 98.01,144.7 CT112.1 97.87,144.96 97.6,145.23 97.6,145.26 97.59,145.27 97.6,145.27 97.6,145.84 97.59,145.85 97.71,145.96 98.45,145.96 v4(98.62,146.13)
  BOTTOM w0.381: 96.03,151.4 JUSBC.B5
TBT_A_CC2: length 6.6
  TOP w0.381: JUSBC.A5 97.58,147.99 97.35,147.75
  IN3 w0.381: v3(97.15,147.22) 98.25,147.22 v4(98.95,146.52)
  BOTTOM w0.254: v4(98.95,146.52) 98.95,146.3 98.97,146.28 98.97,145.26 98.84,145.13 98.82,145.13 98.66,144.96 CT113.1 98.56,144.66 98.08,144.17 98.08,143.74 98.2,143.63 UT4.L10
TBT_A_SBU1: length 23
  TOP w0.081: v5(102.28,149.25) 102.72,149.25 103.02,148.95 v2(103.03,148.95)
  IN3 w0.058: v4(97.65,151.92) 98.22,151.92 98.37,152.07 101.75,152.07 102.63,151.2 102.63,150.17 102.28,149.82 v5(102.28,149.25) 102.28,149.02 102.63,148.67 102.63,147.36 101.68,146.42 99.61,146.42 98.42,147.6 v4(96.77,147.6)
  BOTTOM w0.081: v4(97.65,151.92) 97.6,151.87 97.6,150.83 JUSBC.B8 ; UT4.K8 96.94,143.38 96.94,144.11 96.67,144.38 96.67,147.5 v4(96.77,147.6)
TBT_A_SBU2: length 22.9
  TOP w0.081: v4(96.98,146.73) 96.94,146.76 96.38,146.76 96.16,146.97 96.16,147.12 DT14.1 95.96,147.12 95.96,146.55 95.87,146.46 95.75,146.46 95.67,146.54 95.67,147.54 95.49,147.71 95.49,147.87 95.66,148.03 95.77,148.03 96.05,147.76 96.87,147.76 96.95,147.84 96.95,148.01 96.89,148.08 96.17,148.08 96.08,148.17 JUSBC.A8
  BOTTOM w0.081: v4(96.98,146.73) 96.98,147.23 97.08,147.33 v2(97.46,147.33) 99.29,147.33 99.38,147.42 99.38,147.96 99.46,148.04 99.62,148.04 99.72,147.94 99.72,146.72 99.8,146.64 100.77,146.64 100.84,146.57 100.84,146.33 100.79,146.27 99.33,146.27 99.25,146.35 99.25,146.78 99.12,146.9 98.49,146.9 98.41,146.82 98.41,146.43 98.33,146.35 98.17,146.35 98.08,146.43 98.08,146.99 97.98,147.09 97.73,147.09 97.66,147.03 97.66,146.38 97.58,146.29 97.26,146.29 97.22,146.33 96.97,146.33 96.86,146.22 96.86,144.46 96.95,144.36 97.16,144.36 97.2,144.32 UT4.L8
TBT_A_TRX_DTX_N0: length 32.4
  TOP w0.081: v5(81.23,152.96) 81.1,153.08 arc(81.07,153.13) 81.06,153.17 81.06,153.53 arc(81.09,153.59) 81.15,153.61 82.03,153.61 arc(82.18,153.58) 82.31,153.49 arc(82.55,153.13) 82.64,152.7 82.64,152.58 arc(82.69,152.33) 82.83,152.11 83.47,151.48 arc(83.48,151.47) 83.48,151.45 arc(83.49,151.44) 83.49,151.42 arc(83.6,150.87) 83.91,150.39 85.21,149.1 arc(85.95,148.6) 86.84,148.43 90.19,148.43 arc(90.47,148.37) 90.69,148.22 90.81,148.1 arc(90.92,147.94) 90.96,147.75 90.96,146.52 arc(91,146.28) 91.14,146.08 91.54,145.68 arc(91.63,145.62) 91.74,145.6 93.85,145.6 arc(94.48,145.86) 94.74,146.49 94.74,146.9 arc(94.75,146.97) 94.79,147.02 DT5.1 94.73,147.48 arc(94.71,147.51) 94.7,147.54 arc(94.71,147.59) 94.74,147.63 94.8,147.69 arc(94.88,147.81) 94.91,147.94 94.91,148.17 arc(94.92,148.22) 94.94,148.26 94.95,148.26 arc(95.05,148.41) 95.08,148.59 JUSBC.A10
  BOTTOM w0.081: v5(81.23,152.96) 81.18,152.91 arc(81.08,152.75) 81.04,152.57 arc(81.03,152.54) 81.01,152.51 80.9,152.4 arc(80.81,152.34) 80.7,152.31 78.51,152.31 arc(78.49,152.31) 78.47,152.31 arc(78.47,152.3) 78.46,152.3 75.88,150.8 75.66,150.58 arc(75.47,150.29) 75.4,149.96 75.4,149.96 75.4,148.01 arc(75.42,147.91) 75.48,147.83 75.55,147.75 arc(75.57,147.73) 75.58,147.7 75.58,147.5 arc(75.57,147.46) 75.55,147.44 75.55,147.43 arc(75.46,147.4) 75.38,147.43 arc(75.36,147.47) 75.35,147.51 UT1.A21
