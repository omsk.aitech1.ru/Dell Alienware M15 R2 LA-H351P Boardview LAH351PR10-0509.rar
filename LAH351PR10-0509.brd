# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_C_DRX_N23: length 50
  TOP w0.089: v3(121.67,41.42) 121.52,41.57 121.25,41.57 121.03,41.79 121.03,43.85 v13(120.79,44.09) 120.57,44.31 119.39,44.31 CH214.2
  IN2 w0.076: JSSD1.23 106.35,10.33 107.02,11 108.81,11 110.85,13.05 116.38,13.05 121.21,17.88 121.21,21.29 122.32,22.39 122.32,31.71 121.77,32.26 121.77,40.65 121.22,41.2 121.22,41.43 121.31,41.52 121.57,41.52 v3(121.67,41.42)
PCIE_PTX_C_DRX_N24: length 47.7
  TOP w0.089: v3(120.52,43.63) 120.23,43.92 119.68,43.92 119.44,43.68 CH216.2
  IN2 w0.076: JSSD1.11 109.35,9.09 112.04,11.78 116.89,11.78 122.38,17.27 122.38,20.52 123.48,21.62 123.48,33.49 122.96,34.01 122.96,42.48 121.98,43.46 120.69,43.46 v3(120.52,43.63)
PCIE_PTX_C_DRX_P9: length 79.9
  TOP w0.089: v3(120.14,51) 119.95,51.19 v13(119.95,51.63) 119.95,52.58 116.23,56.3 115.68,56.3 115.66,56.31 115.12,56.31 115.11,56.3 110.72,56.3 107.56,53.13 107.56,52 107.47,51.91 107.1,51.91 107.02,51.82 107.02,51.59 107.1,51.5 CH203.1
  IN2 w0.076: v3(120.14,51) 120.07,51.07 120.07,51.18 120.15,51.26 121.33,51.26 121.91,50.68 124.92,50.68 130.69,44.91 132.38,44.91 132.96,44.33 132.96,39.94 135.14,37.75 137.68,37.75 142.66,32.77 142.66,27.42 138.1,22.86 138.1,16.62 135.64,14.16 135.64,11.75 133.95,10.06 133.95,8.95 133.88,8.87 JSSD3.13
PCIE_PTX_C_DRX_P10: length 77.4
  TOP w0.089: v3(119.51,49.62) 119.38,49.62 119.23,49.78 119.23,52.46 116.1,55.59 112.51,55.59 112.5,55.6 111.96,55.6 111.95,55.59 111.03,55.59 v13(109.28,53.84) 108.73,53.3 108.73,52 108.64,51.91 108.25,51.91 108.17,51.82 108.17,51.56 108.26,51.46 CH205.1
  IN2 w0.076: v3(119.51,49.62) 119.51,49.72 119.58,49.8 120.88,49.8 122.72,47.96 125.81,47.96 130.94,42.83 130.94,39.84 135.25,35.52 138.25,35.52 141.49,32.29 141.49,28.54 136.51,23.56 136.51,17.13 134.09,14.71 134.09,13.46 130.95,10.32 130.95,8.95 130.87,8.87 JSSD3.25
PCIE_PTX_C_DRX_P11: length 76.4
  TOP w0.089: CH206.2 109.5,50.83 109.41,50.92 109.41,51.15 109.5,51.24 109.91,51.24 110,51.33 110,52.21 109.99,52.22 109.99,52.76 110,52.77 110,53.42 111.55,54.97 115.87,54.97 118.63,52.21 v13(118.63,51.56) 118.63,48.25 118.72,48.16 v3(118.8,48.16)
  IN2 w0.076: JSSD3.37 127.88,8.87 127.96,8.95 127.96,11.66 135.24,18.95 135.24,24 140.32,29.08 140.32,31.21 137.29,34.24 134.44,34.24 129.77,38.92 129.77,42.15 125.48,46.45 122.45,46.45 120.46,48.43 118.82,48.43 118.79,48.4 118.79,48.17 v3(118.8,48.16)
PCIE_PTX_C_DRX_P12: length 75.4
  TOP w0.089: CH208.2 110.76,51.18 110.63,51.31 110.63,51.5 110.72,51.59 111.09,51.59 111.18,51.68 111.18,53.36 111.43,53.61 111.43,53.63 111.81,54.01 111.83,54.01 112.09,54.27 115.72,54.27 v13(116.36,53.63) 117.94,52.04 117.94,47.75 118.63,47.07 118.63,46.73 118.75,46.61 v3(118.86,46.61)
  IN2 w0.076: v3(118.86,46.61) 118.83,46.64 118.83,46.85 118.91,46.93 120.22,46.93 125.18,41.96 128.24,41.96 128.6,41.61 128.6,38.35 133.96,32.98 136.72,32.98 138.54,31.16 138.54,29.07 138.13,28.65 136.62,28.65 133.92,25.96 133.92,19.53 130.93,16.54 128.74,16.54 124.96,12.75 124.96,8.95 124.88,8.87 JSSD3.49
PCIE_PTX_C_DRX_P17: length 133.4
  TOP w0.089: v8(114.74,53.3) 114.57,53.13 114.57,52.12 CH219.1
  IN1 w0.076: v8(114.74,53.3) 114.75,53.3 114.8,53.26 114.8,53.15 114.69,53.05 114.58,53.05 114.47,53.17 114.47,55.08 113.74,55.8 100.67,55.8 100.11,56.35 93.03,56.35 90.46,58.92 90.46,70.86 88.63,72.69 88.63,83.1 90.47,84.94 90.47,85.64 92.7,87.87 92.7,99.01 89.19,102.52 87.01,102.52 79.37,110.16 79.04,110.16 73.32,115.88 73.32,120.06 73.13,120.25 73.13,122.69 70.93,124.89 70.93,124.89 70.83,124.98 68.9,124.98 66.34,127.54 66.34,130.53 66.88,131.07 66.98,131.07 68.88,132.97 69.42,132.97 70.65,134.2 70.65,138.65 72,140.01 73.16,140.01 73.28,139.89 73.28,138.79 v4(73.38,138.69)
  BOTTOM w0.081: v4(73.38,138.69) 73.41,138.66 73.41,138.56 73.58,138.38 73.99,138.38 UT1.Y23
PCIE_PTX_C_DRX_P18: length 134.2
  TOP w0.089: CH221.1 113,51.95 113.37,52.32 113.37,52.5 113.56,52.69 113.56,53.47 v8(113.35,53.69)
  IN1 w0.076: v8(113.35,53.69) 113.59,53.93 113.59,54.17 112.75,55.01 100.28,55.01 99.72,55.57 92.67,55.57 89.67,58.56 89.67,70.37 86.92,73.12 86.92,83.22 87.62,83.92 88.11,83.92 89.46,85.27 89.46,85.96 89.91,86.41 90.37,86.41 91.57,87.62 91.57,95.58 90.3,96.85 90.3,100.1 88.79,101.62 86.8,101.62 79.05,109.37 78.71,109.37 72.53,115.55 72.53,119.7 72.34,119.89 72.34,122.36 70.54,124.16 70.54,124.16 70.5,124.2 68.57,124.2 65.23,127.54 65.23,130.64 66.44,131.85 66.64,131.85 67.11,132.32 67.11,132.77 68.4,134.06 68.91,134.06 69.81,134.97 69.81,139.03 71.87,141.09 73.48,141.09 73.67,140.89 73.67,140.57 73.75,140.5 v4(73.92,140.5)
  BOTTOM w0.081: v4(73.92,140.5) 74.08,140.66 UT1.T23
PCIE_PTX_C_DRX_P19: length 136.5
  TOP w0.089: CH223.1 115.52,52.08 115.52,52.42 v8(115.38,52.56)
  IN1 w0.076: v8(115.38,52.56) 115.32,52.56 115.21,52.67 115.21,52.96 115.34,53.09 115.58,53.09 115.66,53.01 115.66,52.22 115.55,52.11 114.35,52.11 111.83,54.63 100.06,54.63 99.54,55.15 92.53,55.15 89.29,58.39 89.29,70.2 86.5,72.99 86.5,83.76 86.59,83.85 86.59,83.87 89.61,86.9 90.14,86.9 90.58,87.33 90.58,96.02 87.27,99.32 87.27,100.36 78.64,108.99 78.53,108.99 72.15,115.37 72.15,119.5 71.96,119.69 71.96,122.2 70.44,123.72 70.44,123.72 70.34,123.81 68.41,123.81 64.85,127.38 64.85,131.65 65.66,132.46 66.24,132.46 68.94,135.16 68.94,138.69 72.89,142.64 73.32,142.64 73.69,142.28 v4(73.69,142.14)
  BOTTOM w0.081: UT1.M23 74.07,142.14 v4(73.69,142.14)
PCIE_PTX_C_DRX_P20: length 139.2
  IN1 w0.076: v8(117.16,51.88) 117.15,51.88 117.07,51.8 117.07,51.55 116.84,51.32 113.96,51.32 111.44,53.84 102.71,53.84 101.92,53.05 96.54,53.05 96.41,53.18 94.99,53.18 93.9,54.27 92.22,54.27 88.51,57.98 88.51,69.69 85.65,72.54 85.65,84.38 89.53,88.27 89.53,95.94 71.36,114.12 71.36,119.08 71.17,119.27 71.17,121.88 70.06,122.99 70.06,122.99 70.02,123.03 68.09,123.03 63.84,127.27 63.84,131.76 66.79,134.71 66.79,135.28 68.05,136.54 68.05,139 70.93,141.89 70.93,142.57 71.81,143.44 72.77,143.44 73.39,144.07 v4(73.39,144.33)
  BOTTOM w0.081: v4(73.39,144.33) 73.39,144.41 73.6,144.62 74.15,144.62 UT1.H23
PCIE_PTX_C_DRX_P21: length 62.4
  IN2 w0.076: JSSD1.49 100.07,8.87 100.15,8.95 100.15,10.86 103.71,14.43 105.82,14.43 108.17,16.78 115.54,16.78 116.14,17.38 116.14,17.7 117.26,18.81 117.26,27.82 117.78,28.34 117.78,29.13 117.31,29.6 117.28,29.6 117.25,29.63 117.24,29.63 ; 117.24,45.3 117.26,45.3 117.28,45.32 117.96,45.32 118.34,45.7 119.99,45.7 120.31,46.02 v3(120.31,46.07)
  IN2 w0.089: 117.24,45.3 116.08,45.3 114.81,44.03 114.81,42.51 114.25,41.95 113.42,41.95 112.71,41.24 112.52,41.24 111.46,40.17 111.46,38.56 112.18,37.84 114.09,37.84 115.46,36.47 115.46,35.09 114.06,33.69 114.06,31.32 115.76,29.63 117.24,29.63
PCIE_PTX_C_DRX_P22: length 50.2
  TOP w0.089: CH213.1 119.56,42.22 119.98,42.22 v3(120.05,42.29)
  IN2 w0.076: 117.24,41.69 117.32,41.76 118.76,41.76 119.27,42.27 120.03,42.27 v3(120.05,42.29) ; 117.24,36.57 119.48,34.33 119.48,31.3 119.25,31.07 119.25,29.64 119.27,29.63 119.27,25.19 118.43,24.35 118.43,18.33 117.34,17.24 117.34,16.76 115.46,14.87 109.35,14.87 107,12.52 105.61,12.52 103.15,10.07 103.15,9.17 JSSD1.37
  IN2 w0.089: 117.24,36.57 117.24,36.59 115.75,38.08 115.75,40.19 117.24,41.69
PCIE_PTX_C_DRX_P23: length 50
  TOP w0.089: v3(121.67,41.96) 121.48,41.77 121.34,41.77 121.23,41.87 121.23,43.95 120.75,44.44 120.73,44.44 120.65,44.52 119.69,44.52 119.38,44.82 CH215.2
  IN2 w0.076: JSSD1.25 106.07,8.87 106.15,8.95 106.15,10.42 106.93,11.2 108.72,11.2 110.77,13.25 116.29,13.25 121.01,17.96 121.01,21.37 122.11,22.48 122.11,31.63 121.56,32.18 121.56,40.57 121.02,41.11 121.02,41.51 121.23,41.72 121.42,41.72 v3(121.67,41.96)
PCIE_PTX_C_DRX_P24: length 47.6
  TOP w0.089: CH217.2 119.39,43.04 119.84,43.04 119.99,43.19 119.99,43.51 v3(119.89,43.61)
  IN2 w0.076: v3(119.89,43.61) 119.96,43.68 120.07,43.68 120.14,43.61 120.14,43.35 120.23,43.26 121.9,43.26 122.76,42.4 122.76,33.93 123.28,33.41 123.28,21.71 122.17,20.6 122.17,17.35 116.8,11.98 111.96,11.98 109.15,9.17 109.15,8.83 109.07,8.76 108.96,8.76 JSSD1.13
PCIE_PTX_DRX_N9: length 5.4
  TOP w0.089: CH202.2 107.68,50.92 107.59,50.83 107.59,50.61 107.81,50.39 107.83,50.39 108.21,50.01 108.21,49.99 108.58,49.62
  TOP w0.107: UH1.C34 109.43,46.85 109.58,46.85 109.64,46.91 109.64,47.1 109.56,47.19 109.43,47.19 109.33,47.29 109.33,48.08 109.11,48.3 109.11,48.33 108.91,48.53 108.91,48.77 108.58,49.09 108.58,49.62
PCIE_PTX_DRX_N10: length 4.5
  TOP w0.089: 109.56,48.6 109.56,49.49 109.55,49.5 109.55,49.55 109.45,49.66 109.43,49.66 109.08,50.01 109.05,50.01 108.94,50.13 CH204.2
  TOP w0.107: UH1.C35 109.96,46.93 109.96,47.54 109.95,47.54 109.95,48.07 109.94,48.08 109.93,48.08 109.59,48.42 109.59,48.43 109.57,48.45 109.57,48.54 109.56,48.55 109.56,48.6
PCIE_PTX_DRX_N11: length 3.6
  TOP w0.089: 110.33,48.31 110.33,47.97 110.64,47.66 110.64,47.37 110.58,47.31 110.45,47.31 110.39,47.37 UH1.B36 ; 110.24,48.6 110.24,49.75 110.07,49.91 110.07,50.11 CH207.1
  TOP w0.107: 110.33,48.31 110.24,48.41 110.24,48.6
PCIE_PTX_DRX_N12: length 5.8
  TOP w0.089: v5(111.32,49.58) 111.21,49.7 111.21,50.43 CH209.1
  TOP w0.107: v6(111.25,46.12) 111.2,46.17 111.2,46.43 UH1.D38
  IN4 w0.089: v5(111.32,49.58) 111.19,49.45 111.19,49.18 111.63,48.73 111.63,47.08 111.05,46.5 111.05,46.19 111.12,46.12 v6(111.25,46.12)
PCIE_PTX_DRX_N15: length 160.6
  TOP w0.089: v8(112.15,52.2) 112.33,52.03 112.33,51.66 112.23,51.56 112.23,49.52 111.82,49.11 111.82,47.84 111.69,47.71 111.69,47.39 111.77,47.32 111.84,47.32 UH1.B40
  IN1 w0.076: 102,49.77 102.23,50.01 102.23,51.56 102.49,51.81 102.49,52.48 103.27,53.26 109.65,53.26 111.52,51.39 111.98,51.39 112.3,51.7 112.3,51.71 112.32,51.73 112.32,52.04 v8(112.15,52.2) ; v4(9.46,15.34) 9.52,15.4 9.69,15.4 9.77,15.32 9.77,15.03 9.68,14.95 9.47,14.95 8.4,16.02 6.81,16.02 6.73,16.09 6.73,17.06 8.99,19.32 9.55,19.32 10.19,19.95 10.19,21.96 10.9,22.67 10.9,25.97 12.64,27.71 12.64,29.24 12.37,29.5 12.37,33.96 12.2,34.13 12.2,38.67 13.56,40.03 13.56,48.48 13.14,48.89 13.14,52.48 20,59.34 32.58,59.34 33.48,58.44 76.09,58.44 82.75,51.77 87.8,51.77 90.2,49.37 94.51,49.37 94.52,49.38 94.54,49.38
  IN1 w0.089: 102,49.77 101.95,49.72 101.95,49.71 101.92,49.68 101.88,49.68 101.2,49 98.92,49 98.54,49.38 94.54,49.38
PCIE_PTX_DRX_N16: length 54.9
  TOP w0.089: UH1.B41 112.46,47.61 112.46,47.91 v8(112.2,48.16)
  IN1 w0.076: 117.24,48.28 117.26,48.28 117.27,48.29 117.27,48.3 117.3,48.3 117.31,48.3 117.31,48.3 117.31,48.3 117.54,48.3 118.11,48.87 119.38,48.87 119.84,48.41 120.79,48.41 121.98,47.22 130.55,47.22 137.82,39.94 139.9,39.94 140.63,39.22 141.87,39.22 143.19,37.9 146.28,37.9 147.64,36.54 147.64,29.2 146.57,28.14 146.57,27.09 145.94,26.46 145.94,25.78 145.85,25.7 145.85,25.23 v4(145.94,25.14)
  IN1 w0.089: 117.24,48.28 116.26,48.28 114.83,46.85 114.07,46.85 112.93,47.99 112.74,47.99 112.52,48.02 112.44,48.13 v8(112.2,48.16)
PCIE_PTX_DRX_N17: length 4.3
  TOP w0.089: CH218.2 114.16,51.32 114.07,51.23 114.07,51.04 114.16,50.95 114.49,50.95 114.58,50.87 114.58,50.68 114.36,50.47 114.36,49.59 113.13,48.37 113.13,48.15 UH1.A42
PCIE_PTX_DRX_N18: length 5.3
  TOP w0.089: UH1.C42 113.29,47.02 113.25,46.98 113.2,46.98 113.18,47 113.17,47 113.05,47.15 113.05,47.75 112.86,47.94 112.86,48.62 113.62,49.39 113.62,49.67 113.22,50.08 113.22,50.7 113.2,50.72 113.2,50.91 113.57,51.28 CH220.2
PCIE_PTX_DRX_N19: length 5.3
  TOP w0.089: CH222.2 115.92,50.92 115.86,50.85 115.63,50.85 115.55,50.77 115.55,50.46 115.37,50.28 115.37,49.81 113.85,48.29 113.85,48.16 113.92,48.09 113.92,48 113.83,47.9 113.83,47.74 113.93,47.64 113.93,47.46 113.83,47.37 113.83,47.22 UH1.C44
PCIE_PTX_DRX_N20: length 5.6
  TOP w0.089: UH1.A44 114.27,48.19 114.27,48.37 114.54,48.64 114.76,48.64 115.78,49.67 115.78,50.11 116.12,50.45 117.01,50.45 117.12,50.55 117.12,50.81 117.01,50.92 116.59,50.92 116.48,51.02 116.48,51.25 CH224.2
PCIE_PTX_DRX_N21: length 4.3
  TOP w0.089: UH1.G47 115.63,45.39 115.8,45.57 115.99,45.57 116.01,45.59 116.3,45.59 117.01,45.59 117.08,45.66 117.68,45.66 117.74,45.72 119.39,45.72 119.62,45.49 CH210.2
PCIE_PTX_DRX_N22: length 4.8
  TOP w0.089: UH1.H47 115.94,44.13 116.08,44.13 116.23,43.98 116.58,43.98 117.1,43.46 117.1,43.42 117.78,42.74 117.78,42.05 117.99,41.85 CH212.2
PCIE_PTX_DRX_N23: length 2.9
  TOP w0.089: CH214.1 118.74,44.17 118.65,44.09 118.45,44.09 118.36,44.17 118.36,44.53 118.28,44.62 117.97,44.62 117.52,45.06 116.67,45.06 UH1.G49
PCIE_PTX_DRX_N24: length 4.9
  TOP w0.089: UH1.G46 115.08,45.27 114.99,45.18 114.99,45.05 115.09,44.95 115.22,44.95 115.26,45 116.25,45 116.58,44.67 116.99,44.67 118.25,43.41 118.43,43.41 118.7,43.68 CH216.1
PCIE_PTX_DRX_P9: length 5.4
  TOP w0.089: CH203.2 107.39,50.72 107.39,50.53 v13(107.87,50.05) 108.05,49.87 108.08,49.87 108.39,49.56 108.39,49.55
  TOP w0.107: 108.39,49.55 108.39,49.01 108.51,48.89 108.51,48.88 108.71,48.68 108.71,48.44 108.77,48.38 108.77,48.38 108.91,48.25 108.91,48.22 109.13,47.99 109.13,47.25 109.13,47.25 109.13,46.98 109.13,46.98 109.13,46.54 UH1.D34
PCIE_PTX_DRX_P10: length 4.5
  TOP w0.089: CH205.2 108.27,50.78 108.27,50.57 108.36,50.48 108.68,50.48 108.73,50.43 108.73,50.04 108.94,49.84 109,49.84 109.37,49.47
  TOP w0.107: UH1.B35 109.66,47.4 109.55,47.51 109.55,47.67 109.73,47.85 109.73,48 109.39,48.34 109.39,48.35 109.37,48.37 109.37,48.62 109.37,49.47
PCIE_PTX_DRX_P11: length 3.6
  TOP w0.089: UH1.C36 110.39,47.12 110.15,47.36 110.15,48.21 ; 110.02,48.6 110.02,49.65 109.86,49.81 109.86,50.02 CH206.1
  TOP w0.107: 110.15,48.21 110.04,48.31 110.04,48.32 110.04,48.57 110.02,48.6
PCIE_PTX_DRX_P12: length 5.8
  TOP w0.089: CH208.1 111,50.4 111,49.85 v5(110.74,49.58) ; UH1.E37 110.8,45.84 v6(110.81,45.84)
  IN4 w0.076: v5(110.74,49.58) 110.92,49.4 110.92,49.39 111.01,49.3 111.01,49.1 111.03,49.08
  IN4 w0.089: 111.03,49.08 111.46,48.66 111.46,47.16 110.87,46.57 110.87,45.9 v6(110.81,45.84)
PCIE_PTX_DRX_P15: length 160.5
  TOP w0.089: v8(112.03,51.84) 112.03,50.12 112.05,50.09 112.05,49.6 111.64,49.19 111.64,47.92 111.51,47.78 111.51,47.32 111.97,46.86 UH1.C40
  IN1 w0.076: v4(10.06,15.34) 9.97,15.25 9.97,14.95 9.77,14.75 9.38,14.75 8.32,15.81 6.72,15.81 6.53,16.01 6.53,17.15 8.9,19.52 9.47,19.52 9.98,20.04 9.98,22.05 10.69,22.76 10.69,26.05 12.43,27.79 12.43,29.15 12.17,29.42 12.17,33.88 12,34.04 12,38.76 13.36,40.11 13.36,48.39 12.94,48.81 12.94,52.56 19.92,59.54 32.66,59.54 33.56,58.64 76.17,58.64 82.84,51.97 87.88,51.97 90.28,49.57 94.51,49.57 94.51,49.56 94.53,49.56 94.53,49.56 94.54,49.56 ; 101.72,49.77 101.8,49.85 101.8,49.86 102.03,50.09 102.03,51.64 102.29,51.89 102.29,52.56 103.18,53.46 109.73,53.46 111.6,51.59 111.9,51.59 112.03,51.72 v8(112.03,51.84)
  IN1 w0.089: 101.72,49.77 101.13,49.18 98.99,49.18 98.61,49.56 94.54,49.56
PCIE_PTX_DRX_P16: length 55
  TOP w0.089: UH1.C41 112.27,47.3 112.27,47.68 v8(112.15,47.79)
  IN1 w0.076: 117.24,48.1 117.62,48.1 118.19,48.67 119.3,48.67 119.75,48.21 120.71,48.21 121.9,47.02 130.46,47.02 137.74,39.74 139.82,39.74 140.54,39.02 141.79,39.02 143.11,37.7 146.19,37.7 147.43,36.46 147.43,29.29 146.37,28.22 146.37,27.18 145.73,26.54 145.73,25.87 145.65,25.78 145.65,25.22 145.57,25.14 v4(145.34,25.14)
  IN1 w0.089: 117.24,48.1 116.33,48.1 114.91,46.68 113.99,46.68 112.86,47.81 112.73,47.81 112.5,47.84 112.39,47.76 v8(112.15,47.79)
PCIE_PTX_DRX_P17: length 4.3
  TOP w0.089: CH219.2 114.78,50.6 114.57,50.38 114.57,50.09 114.54,50.06 114.54,49.52 113.34,48.32 113.34,47.99 UH1.B42
PCIE_PTX_DRX_P18: length 5.4
  TOP w0.089: UH1.D42 112.87,47.05 112.87,47.68 112.68,47.87 112.68,48.7 113.44,49.46 113.44,49.6 113,50.05 v13(113,50.43) CH221.2
PCIE_PTX_DRX_P19: length 5.4
  TOP w0.089: CH223.2 115.35,50.55 115.17,50.37 115.17,49.9 113.62,48.35 113.62,46.89 113.71,46.8 UH1.D43
PCIE_PTX_DRX_P20: length 5.7
  TOP w0.089: UH1.B44 114.2,47.74 114.48,48.02 114.48,48.29 114.63,48.44 114.84,48.44 115.98,49.58 115.98,50.03 116.2,50.24 117.09,50.24 117.35,50.5 117.35,51.09 117.16,51.29 CH225.2
PCIE_PTX_DRX_P21: length 4.3
  TOP w0.089: CH211.2 119.56,46.07 119.42,45.93 117.66,45.93 117.59,45.86 117.24,45.86 117.22,45.84 117.01,45.84 116.93,45.76 116.37,45.76 116.37,45.76 115.93,45.76 115.92,45.75 115.8,45.75 UH1.F46
PCIE_PTX_DRX_P22: length 4.7
  TOP w0.089: UH1.H48 115.92,44.52 115.92,44.4 116.01,44.31 116.15,44.31 116.31,44.15 116.66,44.15 117.98,42.83 117.98,42.14 118.07,42.05 118.29,42.05 118.36,42.12 118.36,42.38 118.46,42.48 CH213.2
PCIE_PTX_DRX_P23: length 2.9
  TOP w0.089: CH215.1 118.05,44.82 117.6,45.27 116.83,45.27 116.74,45.35 116.49,45.35 116.44,45.3 116.14,45.3 UH1.G48
PCIE_PTX_DRX_P24: length 4.9
  TOP w0.089: UH1.G45 114.8,44.99 114.83,44.97 115.02,44.77 115.29,44.77 115.34,44.82 116.17,44.82 116.5,44.49 116.91,44.49 117.1,44.3 117.1,44.3 117.1,44.29 117.11,44.29 117.11,44.29 117.11,44.25 118.16,43.2 118.64,43.2 CH217.1
PCIE_RBIAS: length 1
  TOP w0.203: RT3.1 77.19,141.53 v4(77.22,141.51)
  BOTTOM w0.081: UT1.N16 77.54,141.83 v4(77.22,141.51)
PCIE_RCOMPN: length 6
  TOP w0.081: v2(98.71,52.3) RH193.1
  TOP w0.152: UH1.B12 98.53,47.78 98.49,47.83
  TOP w0.254: RH193.1 98.25,51.31 97.37,50.43 97.37,49.3 98.28,48.39 98.28,48.04 98.49,47.83
PCIE_RCOMPP: length 3.6
  TOP w0.081: v2(97.78,50.23) 98.02,50.47 98.64,50.47 RH193.2
  TOP w0.254: UH1.A13 98.73,48.43 98.39,48.77 98.39,50.07 RH193.2
PCIE_WAKE#: length 131.1
  TOP w0.076: UE5.A13 76.58,17.37
  TOP w0.081: v8(76.2,17.39) 76.2,17.37 76.58,17.37
  IN1 w0.058: 76.2,17.37 76.2,16.54 76.58,16.16 ; 76.2,17.37 74.04,17.37 72.85,16.17 72.85,15.66 70.88,13.7 70.88,12.33 67.19,8.63 16.21,8.63 14.25,6.67 14.25,4.7 12.83,3.28 9.86,3.28 8.66,4.47 v5(7.69,4.47) ; 76.2,17.37 v8(76.2,17.39)
  IN1 w0.076: v11(77.34,15.85) 77.24,15.75 76.99,15.75 76.58,16.16
  GND2 w0.076: v12(77.71,15.68) 77.47,15.68 77.34,15.8 v11(77.34,15.85)
  IN2 w0.076: v3(78.25,15.22) 78.16,15.22 v12(77.71,15.68)
  IN3 w0.058: v3(113.03,19.26) 112.8,19.03 105.65,19.03 102.09,15.46 97.66,15.46 97.23,15.03 94.81,15.03 91.5,11.72 90.36,11.72 89.33,10.7 85.96,10.7 84.97,9.71 84.97,9.61 83.46,8.11 81.18,8.11 81.04,8.24 79.36,8.24 79.29,8.32 79.29,10.57 ; v5(7.69,4.47) 7.31,4.09 6.96,4.09 6.35,4.7 v9(6.35,6)
  IN3 w0.076: v3(78.25,15.22) 79.06,14.42 79.06,12.96 79.53,12.48 79.53,11.04 79.29,10.8 79.29,10.57
  GND4 w0.081: v4(6.46,6.36) 6.35,6.25 v9(6.35,6)
PCIRST#: length 334.9
  TOP w0.081: v8(95.38,13.25) 95.38,13.19 v2(95.89,12.68) 96.3,12.26 99.5,12.26 99.6,12.16 v8(99.6,10.92) ; v5(85.3,13.68) 85.23,13.68 RE681.1 ; UT3.1 89.55,143.08 89.92,142.71 89.92,142.18 v1(90.34,141.76)
  IN1 w0.058: v11(92.33,13.3) 95.33,13.3 v8(95.38,13.25) ; v8(99.6,10.92) 100.2,10.32 110.64,10.32 111.5,11.18 119.02,11.18 119.54,10.66 124.14,10.66 v8(124.4,10.92) 124.84,10.48 135.01,10.48 138.43,13.9 138.43,22.57 142.24,26.38 v5(142.24,27.59)
  GND2 w0.081: v12(92.08,13.49) 92.27,13.3 v11(92.33,13.3) ; v3(90.3,142.2) 90.34,142.17 v1(90.34,141.76)
  IN2 w0.058: v12(92.08,13.49) 91.92,13.64 85.35,13.64 85.31,13.68 v5(85.3,13.68)
  IN3 w0.058: v3(90.3,142.2) 89.14,142.2 88.95,142.01 88.95,140.59 89.66,139.88 89.66,138.17 88.12,136.63 86.14,136.63 85.82,136.31 73.2,136.31 72.65,135.76 72.65,134.44 77.21,129.89 77.21,124.12 78.28,123.04 78.28,115.92 81.42,112.79 81.57,112.79 81.91,112.45 81.91,107.61 86.7,102.82 86.7,88.87 87.62,87.95 87.62,87.03 87.74,86.91 87.98,86.67 87.98,85.87 86.93,84.81 86.93,84.16 84.65,81.89 84.65,81.75 84.65,81.75 84.65,81.62 84.65,68.44 82.35,66.14 82.35,58.82 82.35,58.69 82.12,58.46 82.12,56.58 81.86,56.31 81.86,45.35 82.93,44.27 82.93,43.87 82.93,39.13 83.03,39.03 83.22,38.84 v9(83.22,38.44) ; v9(76.1,8.59) 76.1,7.95 75.63,7.48 71.09,7.48 70.64,7.03 70.02,7.03 68.96,5.97 58.78,5.97 58.67,6.07 55.15,6.07 51.18,10.04 39.55,10.04 39.26,9.76 28.18,9.76 27.11,8.69 21.87,8.69 20.25,7.07 15.78,7.07 12.72,10.13 12.72,11.71 11.61,12.82 11.61,13.19 v5(11.98,13.55)
  GND4 w0.081: v9(76.1,8.59) 76.1,8.89 v6(76.12,8.92) ; v9(83.22,38.44) 83.19,38.44 82.98,38.23 v6(82.86,38.23)
  IN4 w0.058: v6(76.12,8.92) 76.15,8.89 80.09,8.89 81.67,10.48 82.92,10.48 83.01,10.57 ; 84.2,11.14 84.4,11.14 85.38,12.12 85.38,12.26 85.72,12.6 85.72,12.87 85.22,13.38 85.22,13.62 85.28,13.68 v5(85.3,13.68) 85.33,13.68 86.68,15.03 86.68,19.84 87.14,20.3 87.14,22.04 86.68,22.5 86.68,26.32 83.56,29.44 83.56,35.9 82.86,36.6 v6(82.86,38.23)
  IN4 w0.076: 84.2,11.14 83.58,11.14 83.01,10.57
  BOTTOM w0.081: UH3.4 13.59,15.19 13.27,14.87 13.08,14.87 RH199.1 12.64,14.21 v5(11.98,13.55) 11.58,13.16 11.58,8.87 12.12,8.33 12.12,8.21 10.77,6.86 9.65,6.86 9.46,6.67 JIO1.B3 ; v5(142.24,27.59) 142.88,27.59 143.54,28.25 JIO2.F3
PCIRST_R#: length 6.3
  TOP w0.076: UE5.M5 82.74,13.36 82.99,13.61 83.78,13.61 84.06,13.9 84.2,13.9
  TOP w0.081: 84.2,13.9 84.53,13.9 85.17,13.26 85.58,13.26 CE34.1 ; CE34.1 86.02,13.67 86.38,14.02 86.52,14.02 86.63,14.13 86.72,14.13 v2(86.93,14.34) ; CE34.1 85.34,14.32 RE681.2
PD_EE_CLK: length 1.5
  BOTTOM w0.081: UT4.A3 94.44,138.88 94.44,139.02 94.44,139.02 94.44,139.22 94.44,139.22 94.44,139.33 94.55,139.45 v4(94.55,139.94)
PD_EE_CS_N: length 44.6
  TOP w0.081: v2(76.86,116.87) 76.8,116.93 RT100.2 76.45,117.4 v1(76.45,118.06)
  GND2 w0.081: v12(76.07,118.06) v1(76.45,118.06)
  IN2 w0.058: v4(94.7,139.12) 93.78,138.2 91.04,138.2 88.92,136.09 85.71,136.09 85.45,135.82 83.41,135.82 83.36,135.87 74.18,135.87 73.75,135.45 73.75,134.85 76.94,131.66 76.94,120.33 75.62,119.01 75.62,118.52 v12(76.07,118.06)
PD_EE_DI: length 0.8
  BOTTOM w0.081: UT4.B4 95.19,139.13 v4(95.19,139.94)
PD_EE_DO: length 41
  GND2 w0.081: v1(75.98,118.84) 76.3,119.15 v12(76.33,119.15)
  IN2 w0.058: v12(76.33,119.15) 77.34,120.17 77.34,131.77 74.11,135 74.11,135.3 74.33,135.51 83.21,135.51 83.26,135.46 85.6,135.46 85.86,135.73 89.07,135.73 91.19,137.84 94.57,137.84 v4(94.98,138.25)
  BOTTOM w0.081: v4(94.98,138.25) 95.2,138.47 UT4.A4
PD_IRQ#: length 166.6
  TOP w0.076: v5(78.14,13.05) 78.04,13.05 77.86,12.86 v8(77.66,12.86)
  IN3 w0.058: v9(79.54,38.83) 79.54,41.37 79.79,41.62 79.79,42.9 79.56,43.13 79.56,43.69 79.56,43.69 79.56,43.8 79.29,44.06 79.29,53.23 78.6,53.92 78.6,59.63 79.33,60.36 79.33,66.58 82.07,69.32 82.07,88.91 79.69,91.3 79.69,95.78 77.09,98.38 v9(77.09,99.21) ; v4(96.2,139.12) 95.53,139.12 95.03,139.61 94.03,139.61 91.78,141.86 89.38,141.86 v9(89.28,141.76) 89.28,140.95 90.46,139.77 90.46,138.52 88.25,136.31 86.27,136.31 85.96,135.99 74.1,135.99 73.91,135.81 73.63,135.53 73.63,134.8 77.83,130.6 77.83,124.23 78.79,123.27 78.79,116.13 81.66,113.27 81.77,113.27 82.54,112.5 v9(82.54,112.47)
  GND4 w0.081: v9(89.28,141.76) 89.38,141.86 v4(89.66,141.86) ; v9(82.54,112.47) 82.7,112.31 v6(82.7,112.17) ; v6(79.35,38.64) v9(79.54,38.83) ; v4(77.34,99.21) v9(77.09,99.21)
  IN4 w0.058: v6(82.7,112.17) 82.7,105.53 v7(82.62,105.45) ; 77.91,18.44 80.26,20.79 80.26,24.89 79.92,25.23 79.92,34.48 79.38,35.03 79.38,38.61 v6(79.35,38.64)
  IN4 w0.076: 77.91,18.44 77.91,18.24 77.17,17.51 77.17,14.3 77.72,13.74 77.72,13.46 v5(78.14,13.05)
  BOTTOM w0.081: v4(77.34,99.21) 77.42,99.14 78.38,99.14 82.58,103.34 v2(82.58,104.76) 82.58,105.41 v7(82.62,105.45)
PD_RESET: length 162.2
  IN3 w0.058: v3(96.06,141.51) 97.03,140.54 97.03,138.81 96.16,137.95 95.12,137.95 95.11,137.95 94.86,137.95 94.85,137.95 90.12,137.95 88.32,136.15 86.34,136.15 86.02,135.83 74.16,135.83 73.79,135.46 73.79,134.86 77.99,130.67 77.99,124.3 78.95,123.34 78.95,116.2 81.69,113.46 81.94,113.46 83.19,112.21 83.19,107.1 87.18,103.11 87.18,89.07 88.1,88.15 88.1,87.22 88.22,87.11 88.46,86.87 88.46,85.67 87.41,84.62 87.41,83.95 85.22,81.77 85.13,81.67 85.13,66.64 82.9,64.41 82.9,58.8 82.9,58.54 82.82,58.45 82.6,58.24 82.6,56.38 82.34,56.12 82.34,45.55 83.41,44.47 83.41,43.68 83.41,39.33 84.33,38.42 84.33,37.64 v9(84.13,37.44)
  GND4 w0.081: v6(83.89,37.18) 83.89,37.21 v9(84.13,37.44)
  IN4 w0.058: v6(83.89,37.18) 83.88,37.17 83.88,36.49 84.2,36.17 84.2,29.71 88.3,25.61 88.3,24.51 90.14,22.66 90.14,22.46 89.24,21.55 89.24,20.48 88.73,19.98 88.73,18.86 88.84,18.76 88.84,14.27 v7(89.03,14.08)
PD_UART: length 5.1
  IN4 w0.058: v4(94.19,140.62) 93.95,140.87 92.48,140.87 91.69,140.08 91.33,140.08 v4(90.4,139.16)
  BOTTOM w0.081: UT4.F2 v4(94.19,140.62)
PEG_CRX_C_GTX_N0: length 10.9
  TOP w0.089: UG1.BH26 v3(56.5,100.3)
  IN2 w0.076: v3(64.91,102.83) 64.68,103.06 60.33,103.06 59.71,102.45
  IN2 w0.089: v3(56.5,100.3) 56.46,100.26 56.29,100.26 56.17,100.37 56.17,100.55 56.36,100.74 58.01,100.74 59.71,102.45
PEG_CRX_C_GTX_N1: length 10.8
  TOP w0.089: UG1.BE26 v3(54.4,100.3)
  IN2 w0.076: 59.71,101.6 60.09,101.97 63.05,101.97 v3(63.26,101.76)
  IN2 w0.089: 59.71,101.6 59.03,100.91 59.03,100.91 57.8,99.68 57.77,99.68 57.69,99.61 55.04,99.61 54.61,100.04 54.61,100.21 54.52,100.3 v3(54.4,100.3)
PEG_CRX_C_GTX_N2: length 10.1
  TOP w0.089: UG1.BG27 v3(55.8,101)
  IN2 w0.076: v3(63.26,103.87) 63.05,104.08 60.33,104.08 59.91,103.65 59.87,103.65 59.71,103.5
  IN2 w0.089: 59.71,103.5 57.58,101.36 55.66,101.36 55.46,101.16 55.46,101.03 55.58,100.91 55.71,100.91 55.8,101 v3(55.8,101)
PEG_CRX_C_GTX_N3: length 9.6
  TOP w0.089: UG1.BH29 v3(55.8,102.4)
  IN2 w0.076: 58.03,104.03 59.05,105.05 59.06,105.05 60.08,106.07 63.04,106.07 v3(63.26,105.85)
  IN2 w0.089: 58.03,104.03 56.69,102.68 56.08,102.68 v3(55.8,102.4)
PEG_CRX_C_GTX_N4: length 12.8
  TOP w0.089: UG1.BE29 v3(54.4,102.4)
  IN2 w0.076: v3(64.91,104.84) 64.73,105.02 60.4,105.02 59.41,104.02 59.41,104.01 59.28,103.87 59.26,103.87 59.21,103.82 59.17,103.82
  IN2 w0.089: 59.17,103.82 57.22,101.87 54.81,101.87 54.67,102.01 54.61,102.07 54.61,102.33 54.54,102.4 v3(54.4,102.4)
PEG_CRX_C_GTX_N5: length 12.1
  TOP w0.089: UG1.BG30 v3(55.1,103.1)
  IN2 w0.076: v3(64.91,106.82) 64.91,106.82 64.72,107.01 64.54,107.01 64.53,107.03 59.59,107.03 56.53,103.97 56.53,103.96 56.39,103.83 55.9,103.83
  IN2 w0.089: 55.9,103.83 55.84,103.83 55.66,103.65 55.66,103.65 55.36,103.35 55.18,103.35 55.1,103.27 v3(55.1,103.1)
PEG_CRX_C_GTX_N6: length 9.5
  TOP w0.089: UG1.BH32 v3(55.8,104.5)
  IN2 w0.076: v3(63.26,107.76) 63.04,107.98 59.61,107.98 56.39,104.76 56.06,104.76 v3(55.8,104.5)
PEG_CRX_C_GTX_N7: length 13.1
  TOP w0.089: UG1.BE32 v3(54.4,105.2)
  IN2 w0.076: v3(64.91,109.41) 64.69,109.2 59.41,109.2 57.6,107.38 57.6,107.38 56.08,105.85 55.64,105.85 54.74,104.95 54.47,104.95 54.4,105.02 v3(54.4,105.2)
PEG_CRX_C_GTX_P0: length 11
  TOP w0.089: UG1.BG26 v3(55.8,100.3)
  IN2 w0.076: 59.71,102.7 60.28,103.26 64.7,103.26 v3(64.91,103.47)
  IN2 w0.089: v3(55.8,100.3) 55.99,100.49 55.99,100.62 56.29,100.92 57.93,100.92 59.71,102.7
PEG_CRX_C_GTX_P1: length 10.8
  TOP w0.089: UG1.BF26 v3(55.1,100.3)
  IN2 w0.076: v3(63.26,102.4) 63.26,102.3 63.13,102.17 60,102.17 59.71,101.88
  IN2 w0.089: 59.71,101.88 59.62,101.79 59.62,101.79 57.62,99.79 55.12,99.79 54.79,100.12 54.79,100.3 54.88,100.39 55.01,100.39 v3(55.1,100.3)
PEG_CRX_C_GTX_P2: length 10.2
  TOP w0.089: UG1.BF27 v3(55.1,101)
  IN2 w0.076: v3(63.26,104.51) 63.03,104.28 60.25,104.28 59.71,103.75
  IN2 w0.089: v3(55.1,101) 55.19,101 55.28,101.09 55.28,101.23 55.59,101.54 57.51,101.54 59.71,103.75
PEG_CRX_C_GTX_P3: length 9.5
  TOP w0.089: UG1.BG29 v3(55.8,103.1)
  IN2 w0.076: v3(63.26,106.49) 63.04,106.27 59.99,106.27 57.75,104.03
  IN2 w0.089: v3(55.8,103.1) 56.02,102.88 56.08,102.88 56.08,102.88 56.6,102.88 57.75,104.03
PEG_CRX_C_GTX_P4: length 12.7
  TOP w0.089: UG1.BF29 v3(55.1,102.4)
  IN2 w0.076: v3(64.91,105.47) 64.91,105.36 64.77,105.22 60.32,105.22 59.21,104.11 59.21,104.09 59.19,104.08 59.17,104.08 59.12,104.03 59.12,104.02 59.06,103.96 59.05,103.96 59.04,103.95
  IN2 w0.089: 59.04,103.95 57.14,102.05 54.89,102.05 54.8,102.14 54.8,102.38 54.89,102.46 55.03,102.46 v3(55.1,102.4)
PEG_CRX_C_GTX_P5: length 12.1
  TOP w0.089: UG1.BF30 54.8,103.45 55.06,103.71 v3(55.09,103.71)
  IN2 w0.076: 55.75,104.03 55.76,104.03 56.31,104.03 56.38,104.11 56.38,104.11 59.53,107.25 59.69,107.25 59.72,107.23 64.62,107.23 64.63,107.22 64.82,107.22 64.91,107.3 v3(64.91,107.45)
  IN2 w0.089: v3(55.09,103.71) 55.09,103.63 55.17,103.55 55.28,103.55 55.75,104.03
PEG_CRX_C_GTX_P6: length 9.5
  TOP w0.089: UG1.BG32 v3(55.8,105.2)
  IN2 w0.076: v3(63.26,108.39) 63.04,108.18 59.52,108.18 56.31,104.97 56.31,104.96 56.03,104.96 v3(55.8,105.2)
PEG_CRX_C_GTX_P7: length 13.1
  TOP w0.089: UG1.BF32 v3(54.4,104.5)
  IN2 w0.076: v3(64.91,108.77) 64.69,108.99 59.5,108.99 57.84,107.34 57.84,107.33 56.16,105.65 55.73,105.65 55.34,105.26 55.33,105.26 54.82,104.75 54.48,104.75 54.4,104.67 v3(54.4,104.5)
PEG_CRX_C_RD_GTX_N8: length 1.9
  TOP w0.089: CM69.2 72.15,136.94 71.21,136.94 71.07,137.09 UM8.4
PEG_CRX_C_RD_GTX_N9: length 2.1
  TOP w0.089: UM8.8 71.07,139.09 71.22,138.94 71.4,138.94 71.96,139.5 72.17,139.5 CM66.2
PEG_CRX_C_RD_GTX_N10: length 2
  TOP w0.089: UM8.6 70.98,138.09 71.13,137.94 71.59,137.94 71.85,138.2 72.14,138.2 CM62.2
PEG_CRX_C_RD_GTX_N11: length 2
  TOP w0.089: UM8.2 71.05,136.09 71.2,135.94 71.51,135.94 71.84,135.61 72.15,135.61 CM65.2
PEG_CRX_C_RD_GTX_P8: length 1.9
  TOP w0.089: CM67.2 72.18,136.74 71.2,136.74 71.06,136.59 UM8.3
PEG_CRX_C_RD_GTX_P9: length 2.1
  TOP w0.089: CM63.2 72.16,139.3 72.04,139.3 71.49,138.74 71.15,138.74 71,138.59 UM8.7
PEG_CRX_C_RD_GTX_P10: length 2
  TOP w0.089: CM68.2 72.19,138 71.93,138 71.67,137.74 71.11,137.74 70.96,137.59 UM8.5
PEG_CRX_C_RD_GTX_P11: length 2
  TOP w0.089: UM8.1 70.97,135.59 71.12,135.74 71.43,135.74 71.75,135.41 72.18,135.41 CM64.2
PEG_CRX_GTX_N0: length 70.9
  TOP w0.081: UC1.E10 98.79,90.61 v5(99.11,90.29)
  IN2 w0.058: v5(99.11,90.29) 98.78,90.62 98.78,91.39 98.72,91.45 96.16,91.45 95.79,91.08 89.94,91.08 89.93,91.07 89.92,91.07
  IN2 w0.076: 89.92,91.07 89.64,91.07 87.48,93.23 86.25,93.23 86.17,93.16 86.17,92.55 85.98,92.36 85.58,92.36 85.39,92.55 85.39,93.16 85.31,93.23 85.08,93.23 85.01,93.16 85.01,92.55 84.81,92.36 84.41,92.36 84.22,92.55 84.22,93.16 84.14,93.23 81.58,93.23 81.5,93.16 81.5,92.55 81.3,92.36 80.91,92.36 80.71,92.55 80.71,93.16 80.64,93.23 80.41,93.23 80.33,93.16 80.33,92.55 80.14,92.36 79.74,92.36 79.54,92.55 79.54,93.16 79.47,93.23 79.24,93.23 79.16,93.16 79.16,92.55 78.97,92.36 78.57,92.36 78.38,92.55 78.38,93.16 78.3,93.23 78.07,93.23 77.99,93.16 77.99,92.55 77.8,92.36 77.4,92.36 77.21,92.55 77.21,93.16 77.13,93.23 76.9,93.23 76.83,93.16 76.83,92.55 76.63,92.36 76.23,92.36 76.04,92.55 76.04,92.61 75.96,92.69 75.73,92.69 75.66,92.61 75.66,92.55 75.46,92.36 75.07,92.36 74.87,92.55 74.87,93.16 74.79,93.23 74.57,93.23 74.49,93.16 74.49,92.55 74.29,92.36 73.9,92.36 73.7,92.55 73.7,93.16 73.63,93.23 73.4,93.23 73.32,93.16 73.32,92.55 73.13,92.36 72.73,92.36 72.53,92.55 72.53,93.16 72.46,93.23 70.91,93.23 70.69,93.45 70.69,94.02 70.93,94.26 70.93,94.37 70.77,94.53 70.66,94.53 70.27,94.14 70,94.14 69.72,94.43 69.72,94.7 70.11,95.09 70.11,95.2 69.94,95.36 69.84,95.36 69.45,94.97 69.17,94.97 68.4,95.74 68.4,96.29 68.26,96.43 68.26,96.9 68.4,97.04 68.4,97.13 68.33,97.21 67.76,97.21 67.56,97.4 67.56,97.8 67.76,97.99 68.33,97.99 68.4,98.07 68.4,98.3 68.33,98.38 66.81,98.38 66.61,98.57 66.61,98.97 66.81,99.16 68.33,99.16 68.4,99.24 68.4,99.47 68.33,99.54 66.81,99.54 66.61,99.74 66.61,100.14 66.81,100.33 68.33,100.33 68.4,100.41 68.4,100.64 68.33,100.71 66.81,100.71 66.61,100.91 66.61,101.3 66.81,101.5 68.19,101.5 68.27,101.58 68.27,102.42 67.7,102.99 65.65,102.99 v3(65.49,102.83)
PEG_CRX_GTX_N1: length 77.6
  TOP w0.097: v5(98.41,91.06) 98.44,91.06 98.45,91.07 98.46,91.07 98.79,91.4 UC1.E11
  IN2 w0.058: v5(98.41,91.06) 98.23,90.88 98.23,90.51 97.84,90.11 89.92,90.11
  IN2 w0.076: 89.92,90.11 88.84,90.11 88.64,90.3 88.64,91.19 88.56,91.26 88.34,91.26 88.26,91.19 88.26,90.3 88.06,90.11 87.61,90.11 87.42,90.3 87.42,92.47 87.34,92.55 87.11,92.55 87.04,92.47 87.04,90.3 86.84,90.11 86.22,90.11 86.02,90.3 86.02,91.44 85.95,91.52 85.72,91.52 85.64,91.44 85.64,90.3 85.45,90.11 85.05,90.11 84.86,90.3 84.86,91.44 84.78,91.52 84.55,91.52 84.47,91.44 84.47,90.3 84.28,90.11 83.88,90.11 83.69,90.3 83.69,91.44 83.61,91.52 83.38,91.52 83.31,91.44 83.31,90.3 83.11,90.11 82.71,90.11 82.52,90.3 82.52,91.44 82.44,91.52 82.21,91.52 82.14,91.44 82.14,90.3 81.94,90.11 81.55,90.11 81.35,90.3 81.35,91.44 81.27,91.52 81.05,91.52 80.97,91.44 80.97,90.3 80.77,90.11 80.38,90.11 80.18,90.3 80.18,91.44 80.11,91.52 79.88,91.52 79.8,91.44 79.8,90.3 79.61,90.11 79.21,90.11 79.01,90.3 79.01,91.44 78.94,91.52 78.71,91.52 78.63,91.44 78.63,90.3 78.44,90.11 78.04,90.11 77.85,90.3 77.85,91.44 77.77,91.52 77.54,91.52 77.46,91.44 77.46,90.3 77.27,90.11 76.87,90.11 76.68,90.3 76.68,91.44 76.6,91.52 76.37,91.52 76.3,91.44 76.3,90.3 76.1,90.11 75.7,90.11 75.51,90.3 75.51,91.44 75.43,91.52 75.2,91.52 75.13,91.44 75.13,90.3 74.93,90.11 74.54,90.11 74.34,90.3 74.34,91.44 74.26,91.52 74.04,91.52 73.96,91.44 73.96,90.3 73.76,90.11 72.7,90.11 69.13,93.68 68.71,93.68 67.97,94.43 67.97,95.22 65.84,97.35 65.84,101.26 65.13,101.97 64.05,101.97 v3(63.84,101.76)
PEG_CRX_GTX_N2: length 73.3
  TOP w0.097: v3(99.14,91.81) 98.79,92.16 UC1.E12
  IN2 w0.058: v3(99.14,91.81) 99.11,91.78 96.02,91.78 95.96,91.72 89.94,91.72 89.93,91.71 89.92,91.71
  IN2 w0.076: v3(63.84,103.87) 64.05,104.08 67.44,104.08 70.16,101.35 70.16,100.51 70.09,100.43 69.18,100.43 68.99,100.23 68.99,99.84 69.18,99.64 70.56,99.64 70.64,99.57 70.64,99.34 70.56,99.26 69.94,99.26 69.75,99.07 69.75,98.67 69.94,98.47 70.56,98.47 70.64,98.4 70.64,98.17 70.56,98.09 69.18,98.09 68.99,97.9 68.99,97.5 69.18,97.31 70.56,97.31 70.64,97.23 70.64,97 70.56,96.92 69.61,96.92 69.42,96.73 69.42,96.33 69.61,96.14 70.56,96.14 70.64,96.06 70.64,95.66 71.48,94.82 72.37,94.82 72.44,94.74 72.44,94.01 72.64,93.82 73.04,93.82 73.23,94.01 73.23,94.74 73.31,94.82 73.54,94.82 73.61,94.74 73.61,94.01 73.81,93.82 74.21,93.82 74.4,94.01 74.4,94.69 74.48,94.77 74.71,94.77 74.78,94.69 74.78,94.01 74.98,93.82 75.37,93.82 75.57,94.01 75.57,94.74 75.65,94.82 75.87,94.82 75.95,94.74 75.95,94.01 76.15,93.82 76.54,93.82 76.74,94.01 76.74,94.74 76.81,94.82 77.04,94.82 77.12,94.74 77.12,94.01 77.31,93.82 77.71,93.82 77.91,94.01 77.91,94.74 77.98,94.82 78.21,94.82 78.29,94.74 78.29,94.01 78.48,93.82 78.88,93.82 79.07,94.01 79.07,94.74 79.15,94.82 79.38,94.82 79.46,94.74 79.46,94.01 79.65,93.82 80.05,93.82 80.24,94.01 80.24,94.74 80.32,94.82 80.55,94.82 80.62,94.74 80.62,94.01 80.82,93.82 81.22,93.82 81.41,94.01 81.41,94.74 81.49,94.82 81.72,94.82 81.79,94.74 81.79,94.01 81.99,93.82 82.38,93.82 82.58,94.01 82.58,94.74 82.66,94.82 82.88,94.82 82.96,94.74 82.96,94.01 83.16,93.82 83.55,93.82 83.75,94.01 83.75,94.74 83.82,94.82 84.05,94.82 84.13,94.74 84.13,94.01 84.32,93.82 84.72,93.82 84.92,94.01 84.92,94.74 84.99,94.82 85.21,94.82 85.28,94.74 85.28,94.01 85.48,93.82 85.88,93.82 86.07,94.01 86.07,94.74 86.15,94.82 86.72,94.82 89.83,91.71 89.92,91.71
PEG_CRX_GTX_N3: length 77.7
  TOP w0.081: v5(98.43,92.67) 98.43,92.68 98.79,93.04 UC1.E13
  IN2 w0.058: 89.92,94.17 89.93,94.17 89.94,94.17 95.59,94.17 96.65,93.12 97.96,93.12 98.41,92.67 v5(98.43,92.67)
  IN2 w0.076: 89.92,94.17 89.44,94.17 85.99,97.61 85.99,99.35 85.89,99.46 85.03,99.46 84.96,99.38 84.96,97.76 84.76,97.56 84.37,97.56 84.17,97.76 84.17,99.32 84.03,99.46 83.87,99.46 83.79,99.38 83.79,97.76 83.59,97.56 83.2,97.56 83,97.76 83,99.32 82.86,99.46 82.7,99.46 82.62,99.38 82.62,97.76 82.43,97.56 82.03,97.56 81.83,97.76 81.83,99.32 81.69,99.46 81.53,99.46 81.45,99.38 81.45,97.76 81.26,97.56 80.86,97.56 80.66,97.76 80.66,99.32 80.53,99.46 80.36,99.46 80.28,99.38 80.28,97.76 80.09,97.56 79.69,97.56 79.5,97.76 79.5,99.32 79.36,99.46 79.19,99.46 79.12,99.38 79.12,97.76 78.92,97.56 78.52,97.56 78.33,97.76 78.33,99.32 78.19,99.46 78.02,99.46 77.95,99.38 77.95,97.76 77.75,97.56 77.35,97.56 77.16,97.76 77.16,98.05 77.08,98.12 76.85,98.12 76.78,98.05 76.78,97.76 76.58,97.56 76.19,97.56 75.99,97.76 75.99,99.32 75.85,99.46 75.69,99.46 75.61,99.38 75.61,97.76 75.42,97.56 75.02,97.56 74.82,97.76 74.82,99.32 74.68,99.46 74.52,99.46 74.44,99.38 74.44,97.76 74.25,97.56 73.85,97.56 73.65,97.76 73.65,99.32 73.51,99.46 73.35,99.46 73.27,99.38 73.27,97.76 73.08,97.56 72.68,97.56 71.81,98.44 71.81,101.38 67.12,106.07 64.01,106.07 63.84,105.91 v3(63.84,105.85)
PEG_CRX_GTX_N4: length 78.4
  TOP w0.097: v5(99.12,94.25) 99.12,94.16 UC1.E14
  IN2 w0.058: 89.92,92.95 89.93,92.96 95.33,92.96 96.18,92.12 98.63,92.12 99.75,93.24 99.75,93.75 99.45,94.05 99.32,94.05 v5(99.12,94.25)
  IN2 w0.076: v3(65.49,104.84) 65.71,105.05 67.31,105.05 71.23,101.14 71.23,95.9 71.72,95.4 72.57,95.4 72.76,95.6 72.76,96.9 72.84,96.98 73.07,96.98 73.14,96.9 73.14,95.6 73.34,95.4 73.73,95.4 73.93,95.6 73.93,96.9 74.01,96.98 74.23,96.98 74.31,96.9 74.31,95.6 74.51,95.4 74.9,95.4 75.1,95.6 75.1,96.9 75.17,96.98 75.4,96.98 75.48,96.9 75.48,95.6 75.67,95.4 76.07,95.4 76.27,95.6 76.27,96.9 76.34,96.98 76.57,96.98 76.65,96.9 76.65,95.6 76.84,95.4 77.24,95.4 77.43,95.6 77.43,96.9 77.51,96.98 77.74,96.98 77.82,96.9 77.82,95.6 78.01,95.4 78.41,95.4 78.6,95.6 78.6,96.9 78.68,96.98 78.91,96.98 78.98,96.9 78.98,95.6 79.18,95.4 79.58,95.4 79.77,95.6 79.77,96.9 79.85,96.98 80.08,96.98 80.15,96.9 80.15,95.6 80.35,95.4 80.75,95.4 80.94,95.6 80.94,96.9 81.02,96.98 81.24,96.98 81.32,96.9 81.32,95.6 81.52,95.4 81.91,95.4 82.11,95.6 82.11,96.9 82.18,96.98 82.41,96.98 82.49,96.9 82.49,95.6 82.68,95.4 83.08,95.4 83.28,95.6 83.28,96.9 83.35,96.98 83.58,96.98 83.66,96.9 83.66,95.6 83.85,95.4 84.25,95.4 84.45,95.6 84.45,96.9 84.52,96.98 84.75,96.98 84.83,96.9 84.83,95.6 85.02,95.4 85.64,95.4 85.84,95.6 85.84,96.56 85.92,96.63 86.14,96.63 86.22,96.56 86.22,95.6 86.42,95.4 87.37,95.4 89.82,92.95 89.92,92.95
PEG_CRX_GTX_N5: length 77.6
  TOP w0.097: 98.52,94.22 98.79,94.49 UC1.E15
  TOP w0.107: 98.52,94.22 v5(98.5,94.22)
  IN2 w0.058: 89.92,94.86 89.93,94.86 89.94,94.87 95.76,94.87 96.95,93.68 98.1,93.68 98.5,94.08 v5(98.5,94.22)
  IN2 w0.076: 89.92,94.86 89.57,94.86 86.58,97.86 86.58,101.56 86.27,101.87 84.94,101.87 84.86,101.79 84.86,100.24 84.67,100.04 84.27,100.04 84.08,100.24 84.08,101.79 84,101.87 83.77,101.87 83.7,101.79 83.7,100.24 83.5,100.04 83.1,100.04 82.91,100.24 82.91,101.79 82.83,101.87 82.6,101.87 82.53,101.79 82.53,100.55 82.33,100.36 81.94,100.36 81.74,100.55 81.74,101.79 81.66,101.87 81.44,101.87 81.36,101.79 81.36,100.24 81.16,100.04 80.77,100.04 80.57,100.24 80.57,101.79 80.5,101.87 80.27,101.87 80.19,101.79 80.19,100.24 80,100.04 79.6,100.04 79.4,100.24 79.4,101.79 79.33,101.87 79.1,101.87 79.02,101.79 79.02,100.24 78.83,100.04 78.43,100.04 78.24,100.24 78.24,101.79 78.16,101.87 77.93,101.87 77.85,101.79 77.85,100.24 77.66,100.04 77.26,100.04 77.07,100.24 77.07,101.79 76.99,101.87 76.76,101.87 76.69,101.79 76.69,100.24 76.49,100.04 76.09,100.04 75.9,100.24 75.9,101.79 75.82,101.87 75.59,101.87 75.52,101.79 75.52,100.24 75.32,100.04 74.93,100.04 74.73,100.24 74.73,101.79 74.65,101.87 74.43,101.87 74.35,101.79 74.35,100.24 74.15,100.04 73.76,100.04 73.56,100.24 73.56,101.79 73.49,101.87 73.26,101.87 73.18,101.79 73.18,100.24 72.99,100.04 72.59,100.04 72.39,100.24 72.39,101.63 66.98,107.04 65.71,107.04 v3(65.49,106.82)
PEG_CRX_GTX_N6: length 83.1
  TOP w0.097: UC1.E16 99.11,95.08 v5(99.11,95.01)
  IN2 w0.058: v5(99.11,95.01) 99.11,95.16 99.02,95.25 96.66,95.25 96.02,95.9 89.94,95.9 89.93,95.89 89.92,95.89
  IN2 w0.076: v3(63.84,107.76) 64.06,107.97 66.87,107.97 70.5,104.35 72.43,104.35 72.56,104.22 72.56,102.65 72.75,102.45 73.64,102.45 73.84,102.65 73.84,104.29 73.91,104.36 74.52,104.36 74.62,104.27 74.62,102.65 74.81,102.45 75.21,102.45 75.4,102.65 75.4,104.27 75.48,104.35 75.71,104.35 75.78,104.27 75.78,102.65 75.98,102.45 76.38,102.45 76.57,102.65 76.57,104.27 76.65,104.35 76.88,104.35 76.95,104.27 76.95,102.65 77.15,102.45 77.54,102.45 77.74,102.65 77.74,104.27 77.82,104.35 78.04,104.35 78.12,104.27 78.12,102.65 78.32,102.45 78.71,102.45 78.91,102.65 78.91,104.27 78.98,104.35 79.21,104.35 79.29,104.27 79.29,102.65 79.48,102.45 79.88,102.45 80.08,102.65 80.08,104.27 80.15,104.35 80.38,104.35 80.46,104.27 80.46,102.65 80.65,102.45 81.05,102.45 81.24,102.65 81.24,104.27 81.32,104.35 81.55,104.35 81.63,104.27 81.63,102.65 81.82,102.45 82.22,102.45 82.41,102.65 82.41,104.27 82.49,104.35 82.72,104.35 82.79,104.27 82.79,102.65 82.99,102.45 83.39,102.45 83.58,102.65 83.58,104.27 83.66,104.35 83.89,104.35 83.96,104.27 83.96,102.65 84.16,102.45 84.56,102.45 84.75,102.65 84.75,104.27 84.83,104.35 85.14,104.35 85.21,104.27 85.21,102.65 85.41,102.45 85.8,102.45 86,102.66 86,104.26 86.1,104.36 87.07,104.36 87.16,104.27 87.16,98.1 89.37,95.89 89.92,95.89
PEG_CRX_GTX_N7: length 80.4
  TOP w0.097: UC1.E17 98.52,95.87 98.53,95.83 v5(98.51,95.8)
  IN2 w0.058: 89.92,96.67 89.93,96.67 89.94,96.67 97.93,96.67 98.34,96.25 98.34,95.96 v5(98.51,95.8)
  IN2 w0.076: 89.92,96.67 87.95,98.64 87.95,106.08 87.75,106.28 85.98,106.28 85.79,106.08 85.79,105.4 85.71,105.32 85.48,105.32 85.41,105.4 85.41,106.18 85.21,106.38 84.81,106.38 84.62,106.18 84.62,105.4 84.54,105.32 84.31,105.32 84.24,105.4 84.24,106.78 84.04,106.97 83.65,106.97 83.45,106.78 83.45,105.4 83.37,105.32 83.15,105.32 83.07,105.4 83.07,106.78 82.88,106.97 82.48,106.97 82.28,106.78 82.28,105.4 82.21,105.32 81.98,105.32 81.9,105.4 81.9,106.78 81.71,106.97 81.31,106.97 81.11,106.78 81.11,105.4 81.04,105.32 80.81,105.32 80.73,105.4 80.73,106.78 80.54,106.97 80.14,106.97 79.95,106.78 79.95,105.4 79.87,105.32 79.64,105.32 79.56,105.4 79.56,106.78 79.37,106.97 78.97,106.97 78.78,106.78 78.78,105.4 78.7,105.32 78.47,105.32 78.4,105.4 78.4,106.78 78.2,106.97 77.8,106.97 77.61,106.78 77.61,105.4 77.53,105.32 77.3,105.32 77.23,105.4 77.23,106.78 77.03,106.97 76.64,106.97 76.44,106.78 76.44,105.4 76.36,105.32 76.14,105.32 76.06,105.4 76.06,106.78 75.86,106.97 75.47,106.97 75.27,106.78 75.27,105.4 75.2,105.32 74.97,105.32 74.89,105.4 74.89,106.78 74.7,106.97 74.3,106.97 74.1,106.78 74.1,105.4 74.03,105.32 73.8,105.32 73.72,105.4 73.72,106.78 73.53,106.97 73.13,106.97 72.94,106.78 72.94,105.4 72.86,105.32 72.63,105.32 72.55,105.4 72.55,106.78 72.36,106.97 71.96,106.97 71.77,106.78 71.77,105.4 71.69,105.32 71.46,105.32 71.39,105.4 71.39,106.78 71.19,106.97 69.05,106.97 66.83,109.19 65.56,109.19 65.49,109.26 v3(65.49,109.41)
PEG_CRX_GTX_N8: length 56.8
  TOP w0.081: v8(99.12,96.78) 99.24,96.78 UC1.F18
  IN1 w0.058: 98.42,98.08 98.43,98.08 98.44,98.08 98.49,98.03 98.58,98.03 98.67,97.95 98.67,97.3 98.63,97.26 98.63,96.95 98.8,96.78 v8(99.12,96.78)
  IN1 w0.076: 98.42,98.08 98.26,98.25 96.47,98.25 95.57,99.15 95.31,99.15 90.88,103.58 87.31,103.58 79.77,111.12 79.44,111.12 74.28,116.28 74.28,120.5 74.09,120.7 74.09,126.48 74.28,126.67 74.28,130.18 71.77,132.7 71.77,136.41 72.42,137.06 72.85,137.06 v8(72.96,137.17)
PEG_CRX_GTX_N9: length 64.2
  TOP w0.081: UC1.D19 v8(97.77,97.44)
  IN1 w0.058: 95.78,97.8 95.79,97.79 95.8,97.79 95.84,97.75 96,97.75 96.01,97.75 97.83,97.75 97.88,97.7 97.88,97.55 v8(97.77,97.44)
  IN1 w0.076: 95.78,97.8 95.76,97.82 95.25,97.82 94.36,98.71 94.36,99.21 90.63,102.95 87.12,102.95 79.53,110.54 79.19,110.54 73.7,116.03 73.7,120.26 73.51,120.45 73.51,123.05 71.13,125.43 68.99,125.43 66.98,127.44 66.98,130.24 67.26,130.52 67.26,130.74 69.09,132.57 70.43,132.57 71.09,133.23 71.09,138.34 72.24,139.49 72.74,139.49 v8(72.96,139.71)
PEG_CRX_GTX_N10: length 55.4
  IN1 w0.076: v8(99.44,98.55) 99.29,98.7 99.29,99.65 97.62,101.32 96.57,101.32 92.82,105.07 88.92,105.07 85.38,108.61 84.47,108.61 77.6,115.48 77.05,115.48 76.12,116.41 76.12,118.26 76.48,118.61 76.48,120.31 75.69,121.1 75.69,130.94 74.88,131.75 74.88,131.9 73.79,133 73.79,133.94 74.02,134.17 74.02,137.86 73.61,138.27 73.04,138.27 72.96,138.34 v8(72.96,138.44)
PEG_CRX_GTX_N11: length 51.6
  IN1 w0.076: v8(72.96,135.84) 72.96,135.77 72.81,135.61 72.6,135.61 72.4,135.42 72.4,133.17 74.09,131.49 74.09,131.42 74.87,130.65 74.87,126.28 74.68,126.09 74.68,121 75.13,120.54 75.13,116.28 76.72,114.7 77.27,114.7 84.31,107.66 85.12,107.66 88.55,104.23 91.44,104.23 95.05,100.62 95.55,100.62 96.38,99.79 98.18,99.79 98.27,99.7 98.27,99.48 v8(98.14,99.34)
PEG_CRX_GTX_P0: length 70.9
  TOP w0.081: UC1.F10 99.44,90.77 99.13,91.08 v5(99.13,91.09)
  IN2 w0.058: v5(99.13,91.09) 99.24,91.09 99.3,91.15 99.3,91.41 99.24,91.47 98.97,91.47 98.8,91.64 96.08,91.64 95.71,91.27 89.94,91.27 89.93,91.28 89.92,91.28
  IN2 w0.076: v3(65.49,103.47) 65.49,103.32 65.62,103.19 67.79,103.19 68.47,102.51 68.47,101.49 68.28,101.3 66.89,101.3 66.81,101.22 66.81,100.99 66.89,100.92 68.41,100.92 68.61,100.72 68.61,100.32 68.41,100.13 66.89,100.13 66.81,100.05 66.81,99.82 66.89,99.75 68.41,99.75 68.61,99.55 68.61,99.15 68.41,98.96 66.89,98.96 66.81,98.88 66.81,98.65 66.89,98.58 68.41,98.58 68.61,98.38 68.61,97.99 68.41,97.79 67.84,97.79 67.77,97.72 67.77,97.49 67.84,97.41 68.41,97.41 68.61,97.22 68.61,96.95 68.47,96.81 68.47,96.51 68.61,96.37 68.61,95.82 69.26,95.17 69.36,95.17 69.75,95.56 70.03,95.56 70.31,95.28 70.31,95.01 69.92,94.62 69.92,94.51 70.08,94.35 70.19,94.35 70.58,94.74 70.86,94.74 71.14,94.46 71.14,94.18 70.89,93.93 70.89,93.54 70.99,93.44 72.54,93.44 72.74,93.24 72.74,92.64 72.81,92.56 73.04,92.56 73.12,92.64 73.12,93.24 73.31,93.44 73.71,93.44 73.91,93.24 73.91,92.64 73.98,92.56 74.21,92.56 74.29,92.64 74.29,93.24 74.48,93.44 74.88,93.44 75.07,93.24 75.07,92.64 75.15,92.56 75.38,92.56 75.45,92.64 75.45,92.7 75.65,92.89 76.05,92.89 76.24,92.7 76.24,92.64 76.32,92.56 76.55,92.56 76.62,92.64 76.62,93.24 76.82,93.44 77.22,93.44 77.41,93.24 77.41,92.64 77.49,92.56 77.72,92.56 77.79,92.64 77.79,93.24 77.99,93.44 78.38,93.44 78.58,93.24 78.58,92.64 78.66,92.56 78.88,92.56 78.96,92.64 78.96,93.24 79.16,93.44 79.55,93.44 79.75,93.24 79.75,92.64 79.82,92.56 80.05,92.56 80.13,92.64 80.13,93.24 80.32,93.44 80.72,93.44 80.92,93.24 80.92,92.64 80.99,92.56 81.22,92.56 81.3,92.64 81.3,93.24 81.49,93.44 84.23,93.44 84.42,93.24 84.42,92.64 84.5,92.56 84.73,92.56 84.8,92.64 84.8,93.24 85,93.44 85.39,93.44 85.59,93.24 85.59,92.64 85.67,92.56 85.89,92.56 85.97,92.64 85.97,93.24 86.17,93.44 87.57,93.44 89.73,91.28 89.92,91.28
PEG_CRX_GTX_P1: length 77.5
  TOP w0.097: v5(97.76,91.08) 98.14,91.46 UC1.D11
  IN2 w0.058: 89.92,90.31 89.92,90.31 89.93,90.3 90,90.3 90.01,90.29 97.76,90.29 98.05,90.58 98.05,91.02 97.99,91.08 v5(97.76,91.08)
  IN2 w0.076: 89.92,90.31 88.92,90.31 88.84,90.39 88.84,91.27 88.65,91.47 88.25,91.47 88.06,91.27 88.06,90.39 87.98,90.31 87.7,90.31 87.62,90.39 87.62,92.56 87.43,92.75 87.03,92.75 86.83,92.56 86.83,90.39 86.76,90.31 86.3,90.31 86.23,90.39 86.23,91.53 86.03,91.72 85.64,91.72 85.44,91.53 85.44,90.39 85.36,90.31 85.14,90.31 85.06,90.39 85.06,91.53 84.86,91.72 84.47,91.72 84.27,91.53 84.27,90.39 84.2,90.31 83.97,90.31 83.89,90.39 83.89,91.53 83.7,91.72 83.3,91.72 83.1,91.53 83.1,90.39 83.03,90.31 82.8,90.31 82.72,90.39 82.72,91.53 82.53,91.72 82.13,91.72 81.93,91.53 81.93,90.39 81.86,90.31 81.63,90.31 81.55,90.39 81.55,91.53 81.36,91.72 80.96,91.72 80.77,91.53 80.77,90.39 80.69,90.31 80.46,90.31 80.39,90.39 80.39,91.53 80.19,91.72 79.79,91.72 79.6,91.53 79.6,90.39 79.52,90.31 79.29,90.31 79.22,90.39 79.22,91.53 79.02,91.72 78.62,91.72 78.43,91.53 78.43,90.39 78.35,90.31 78.12,90.31 78.05,90.39 78.05,91.53 77.85,91.72 77.46,91.72 77.26,91.53 77.26,90.39 77.19,90.31 76.96,90.31 76.88,90.39 76.88,91.53 76.69,91.72 76.29,91.72 76.09,91.53 76.09,90.39 76.02,90.31 75.79,90.31 75.71,90.39 75.71,91.53 75.52,91.72 75.12,91.72 74.92,91.53 74.92,90.39 74.85,90.31 74.62,90.31 74.54,90.39 74.54,91.53 74.35,91.72 73.95,91.72 73.76,91.53 73.76,90.39 73.68,90.31 72.78,90.31 69.22,93.88 68.8,93.88 68.17,94.51 68.17,95.31 66.04,97.43 66.04,101.34 65.21,102.17 63.92,102.17 63.84,102.25 v3(63.84,102.4)
PEG_CRX_GTX_P2: length 73.2
  IN2 w0.058: v3(99.44,92.25) 99.33,92.36 99.1,92.36 99,92.26 99,92.13 98.84,91.97 95.94,91.97 95.88,91.91 89.94,91.91 89.93,91.92 89.92,91.92
  IN2 w0.076: 89.92,91.92 86.81,95.02 86.06,95.02 85.87,94.83 85.87,94.1 85.79,94.02 85.56,94.02 85.49,94.1 85.49,94.83 85.29,95.02 84.91,95.02 84.71,94.83 84.71,94.1 84.64,94.02 84.41,94.02 84.33,94.1 84.33,94.83 84.14,95.02 83.74,95.02 83.54,94.83 83.54,94.1 83.47,94.02 83.24,94.02 83.16,94.1 83.16,94.83 82.97,95.02 82.57,95.02 82.38,94.83 82.38,94.1 82.3,94.02 82.07,94.02 82,94.1 82,94.83 81.8,95.02 81.4,95.02 81.21,94.83 81.21,94.1 81.13,94.02 80.9,94.02 80.83,94.1 80.83,94.83 80.63,95.02 80.23,95.02 80.04,94.83 80.04,94.1 79.96,94.02 79.73,94.02 79.66,94.1 79.66,94.83 79.46,95.02 79.07,95.02 78.87,94.83 78.87,94.1 78.79,94.02 78.57,94.02 78.49,94.1 78.49,94.83 78.29,95.02 77.9,95.02 77.7,94.83 77.7,94.1 77.63,94.02 77.4,94.02 77.32,94.1 77.32,94.83 77.13,95.02 76.73,95.02 76.53,94.83 76.53,94.1 76.46,94.02 76.23,94.02 76.15,94.1 76.15,94.83 75.96,95.02 75.56,95.02 75.37,94.83 75.37,94.1 75.29,94.02 75.06,94.02 74.98,94.1 74.98,94.78 74.79,94.97 74.4,94.97 74.2,94.77 74.2,94.1 74.12,94.02 73.89,94.02 73.82,94.1 73.82,94.83 73.62,95.02 73.22,95.02 73.03,94.83 73.03,94.1 72.95,94.02 72.72,94.02 72.65,94.1 72.65,94.83 72.45,95.02 71.56,95.02 70.84,95.74 70.84,96.15 70.65,96.34 69.7,96.34 69.62,96.42 69.62,96.64 69.7,96.72 70.65,96.72 70.84,96.92 70.84,97.31 70.65,97.51 69.27,97.51 69.19,97.58 69.19,97.81 69.27,97.89 70.65,97.89 70.84,98.08 70.84,98.48 70.65,98.68 70.03,98.68 69.95,98.75 69.95,98.98 70.03,99.06 70.65,99.06 70.84,99.25 70.84,99.65 70.65,99.85 69.27,99.85 69.19,99.92 69.19,100.15 69.27,100.23 70.17,100.23 70.37,100.42 70.37,101.43 67.52,104.28 64.07,104.28 v3(63.84,104.51)
PEG_CRX_GTX_P3: length 77.8
  TOP w0.081: UC1.D13 98.14,93.08 v5(98.5,93.45)
  IN2 w0.058: 89.92,94.37 89.93,94.37 89.94,94.36 95.67,94.36 96.72,93.3 98.36,93.3 v5(98.5,93.45)
  IN2 w0.076: v3(63.84,106.49) 63.84,106.35 63.92,106.27 67.04,106.27 67.21,106.27 72.01,101.47 72.01,98.52 72.77,97.77 72.99,97.77 73.07,97.84 73.07,99.46 73.27,99.66 73.6,99.66 73.86,99.4 73.86,97.84 73.93,97.77 74.16,97.77 74.24,97.84 74.24,99.46 74.43,99.66 74.77,99.66 75.03,99.4 75.03,97.84 75.1,97.77 75.33,97.77 75.41,97.84 75.41,99.46 75.6,99.66 75.94,99.66 76.19,99.4 76.19,97.84 76.27,97.77 76.5,97.77 76.58,97.84 76.58,98.13 76.77,98.33 77.17,98.33 77.36,98.13 77.36,97.84 77.44,97.77 77.67,97.77 77.74,97.84 77.74,99.46 77.94,99.66 78.27,99.66 78.53,99.4 78.53,97.84 78.61,97.77 78.84,97.77 78.91,97.84 78.91,99.46 79.11,99.66 79.44,99.66 79.7,99.4 79.7,97.84 79.78,97.77 80,97.77 80.08,97.84 80.08,99.46 80.28,99.66 80.61,99.66 80.87,99.4 80.87,97.84 80.94,97.77 81.17,97.77 81.25,97.84 81.25,99.46 81.44,99.66 81.78,99.66 82.04,99.4 82.04,97.84 82.11,97.77 82.34,97.77 82.42,97.84 82.42,99.46 82.61,99.66 82.95,99.66 83.2,99.4 83.2,97.84 83.28,97.77 83.51,97.77 83.59,97.84 83.59,99.46 83.78,99.66 84.11,99.66 84.37,99.4 84.37,97.84 84.45,97.77 84.68,97.77 84.75,97.84 84.75,99.46 84.95,99.66 85.97,99.66 86.19,99.44 86.19,97.7 89.52,94.37 89.92,94.37
