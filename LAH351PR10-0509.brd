# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CRX_GTX_P4: length 78.4
  TOP w0.097: v5(99.1,93.42) 99.11,93.44 99.11,93.6 99.34,93.83 UC1.F14
  IN2 w0.058: v5(99.1,93.42) 98.95,93.57 98.95,93.8 99.01,93.86 99.38,93.86 99.57,93.67 99.57,93.32 98.55,92.3 96.26,92.3 95.41,93.15 89.93,93.15 89.92,93.16 89.92,93.16
  IN2 w0.076: 89.92,93.16 89.91,93.16 87.46,95.61 86.5,95.61 86.42,95.68 86.42,96.64 86.23,96.84 85.83,96.84 85.64,96.64 85.64,95.68 85.56,95.61 85.11,95.61 85.03,95.68 85.03,96.99 84.83,97.18 84.44,97.18 84.24,96.99 84.24,95.68 84.17,95.61 83.94,95.61 83.86,95.68 83.86,96.99 83.67,97.18 83.27,97.18 83.07,96.99 83.07,95.68 83,95.61 82.77,95.61 82.69,95.68 82.69,96.99 82.5,97.18 82.1,97.18 81.91,96.99 81.91,95.68 81.83,95.61 81.6,95.61 81.52,95.68 81.52,96.99 81.33,97.18 80.93,97.18 80.74,96.99 80.74,95.68 80.66,95.61 80.43,95.61 80.36,95.68 80.36,96.99 80.16,97.18 79.76,97.18 79.57,96.99 79.57,95.68 79.49,95.61 79.26,95.61 79.19,95.68 79.19,96.99 78.99,97.18 78.6,97.18 78.4,96.99 78.4,95.68 78.32,95.61 78.1,95.61 78.02,95.68 78.02,96.99 77.82,97.18 77.43,97.18 77.23,96.99 77.23,95.68 77.16,95.61 76.93,95.61 76.85,95.68 76.85,96.99 76.66,97.18 76.26,97.18 76.06,96.99 76.06,95.68 75.99,95.61 75.76,95.61 75.68,95.68 75.68,96.99 75.49,97.18 75.09,97.18 74.89,96.99 74.89,95.68 74.82,95.61 74.59,95.61 74.51,95.68 74.51,96.99 74.32,97.18 73.92,97.18 73.73,96.99 73.73,95.68 73.65,95.61 73.42,95.61 73.35,95.68 73.35,96.99 73.15,97.18 72.75,97.18 72.56,96.99 72.56,95.68 72.48,95.61 71.81,95.61 71.43,95.99 71.43,101.23 67.4,105.26 65.71,105.26 v3(65.49,105.47)
PEG_CRX_GTX_P5: length 77.7
  TOP w0.097: v5(97.77,94.22) 97.77,94.25 UC1.D15
  IN2 w0.058: v5(97.77,94.22) 98.1,94.22 98.16,94.16 98.16,94 98.02,93.87 97.02,93.87 95.84,95.06 89.94,95.06 89.93,95.07 89.92,95.07
  IN2 w0.076: 89.92,95.07 89.65,95.07 86.78,97.94 86.78,101.65 86.36,102.07 84.86,102.07 84.66,101.88 84.66,100.32 84.59,100.24 84.36,100.24 84.28,100.32 84.28,101.88 84.09,102.07 83.69,102.07 83.49,101.88 83.49,100.32 83.42,100.24 83.19,100.24 83.11,100.32 83.11,101.88 82.92,102.07 82.52,102.07 82.32,101.88 82.32,100.64 82.25,100.56 82.02,100.56 81.94,100.64 81.94,101.88 81.75,102.07 81.35,102.07 81.16,101.88 81.16,100.32 81.08,100.24 80.85,100.24 80.78,100.32 80.78,101.88 80.58,102.07 80.18,102.07 79.99,101.88 79.99,100.32 79.91,100.24 79.68,100.24 79.61,100.32 79.61,101.88 79.41,102.07 79.01,102.07 78.82,101.88 78.82,100.32 78.74,100.24 78.51,100.24 78.44,100.32 78.44,101.88 78.24,102.07 77.85,102.07 77.65,101.88 77.65,100.32 77.58,100.24 77.35,100.24 77.27,100.32 77.27,101.88 77.08,102.07 76.68,102.07 76.48,101.88 76.48,100.32 76.41,100.24 76.18,100.24 76.1,100.32 76.1,101.88 75.91,102.07 75.51,102.07 75.31,101.88 75.31,100.32 75.24,100.24 75.01,100.24 74.93,100.32 74.93,101.88 74.74,102.07 74.34,102.07 74.15,101.88 74.15,100.32 74.07,100.24 73.84,100.24 73.77,100.32 73.77,101.88 73.57,102.07 73.17,102.07 72.98,101.88 72.98,100.32 72.9,100.24 72.67,100.24 72.6,100.32 72.6,101.71 67.07,107.24 65.56,107.24 65.49,107.3 v3(65.49,107.45)
PEG_CRX_GTX_P6: length 83.1
  TOP w0.097: UC1.F16 99.11,95.73 v5(99.11,95.8)
  IN2 w0.058: v5(99.11,95.8) 98.75,95.44 96.74,95.44 96.1,96.08 89.94,96.08 89.93,96.09 89.92,96.09
  IN2 w0.076: 89.92,96.09 89.45,96.09 87.36,98.18 87.36,104.35 87.16,104.56 86.02,104.56 85.8,104.34 85.8,102.74 85.71,102.66 85.5,102.66 85.41,102.74 85.41,104.35 85.22,104.55 84.74,104.55 84.55,104.35 84.55,102.73 84.47,102.66 84.24,102.66 84.17,102.73 84.17,104.35 83.97,104.55 83.57,104.55 83.38,104.35 83.38,102.73 83.3,102.66 83.07,102.66 83,102.73 83,104.35 82.8,104.55 82.41,104.55 82.21,104.35 82.21,102.73 82.13,102.66 81.91,102.66 81.83,102.73 81.83,104.35 81.63,104.55 81.24,104.55 81.04,104.35 81.04,102.73 80.97,102.66 80.74,102.66 80.66,102.73 80.66,104.35 80.47,104.55 80.07,104.55 79.87,104.35 79.87,102.73 79.8,102.66 79.57,102.66 79.49,102.73 79.49,104.35 79.3,104.55 78.9,104.55 78.7,104.35 78.7,102.73 78.63,102.66 78.4,102.66 78.32,102.73 78.32,104.35 78.13,104.55 77.73,104.55 77.54,104.35 77.54,102.73 77.46,102.66 77.23,102.66 77.16,102.73 77.16,104.35 76.96,104.55 76.56,104.55 76.37,104.35 76.37,102.73 76.29,102.66 76.06,102.66 75.99,102.73 75.99,104.35 75.79,104.55 75.39,104.55 75.2,104.35 75.2,102.73 75.12,102.66 74.89,102.66 74.82,102.73 74.82,104.35 74.61,104.56 73.83,104.56 73.63,104.37 73.63,102.73 73.56,102.66 72.83,102.66 72.76,102.73 72.76,104.31 72.52,104.55 70.59,104.55 66.96,108.18 63.91,108.18 63.84,108.24 v3(63.84,108.39)
PEG_CRX_GTX_P7: length 80.3
  TOP w0.097: UC1.D17 98.14,96.15 v5(97.77,95.79)
  IN2 w0.058: v5(97.77,95.79) 98.08,95.79 98.16,95.86 98.16,96.17 97.85,96.48 89.94,96.48 89.93,96.47 89.92,96.47
  IN2 w0.076: 89.92,96.47 89.83,96.47 87.74,98.56 87.74,106 87.67,106.07 86.07,106.07 85.99,106 85.99,105.32 85.8,105.12 85.4,105.12 85.2,105.32 85.2,106.1 85.13,106.17 84.9,106.17 84.82,106.1 84.82,105.32 84.63,105.12 84.23,105.12 84.04,105.32 84.04,106.7 83.96,106.77 83.73,106.77 83.65,106.7 83.65,105.32 83.46,105.12 83.06,105.12 82.87,105.32 82.87,106.7 82.79,106.77 82.56,106.77 82.49,106.7 82.49,105.32 82.29,105.12 81.89,105.12 81.7,105.32 81.7,106.7 81.62,106.77 81.39,106.77 81.32,106.7 81.32,105.32 81.12,105.12 80.73,105.12 80.53,105.32 80.53,106.7 80.45,106.77 80.23,106.77 80.15,106.7 80.15,105.32 79.95,105.12 79.56,105.12 79.36,105.32 79.36,106.7 79.29,106.77 79.06,106.77 78.98,106.7 78.98,105.32 78.79,105.12 78.39,105.12 78.19,105.32 78.19,106.7 78.12,106.77 77.89,106.77 77.81,106.7 77.81,105.32 77.62,105.12 77.22,105.12 77.02,105.32 77.02,106.7 76.95,106.77 76.72,106.77 76.64,106.7 76.64,105.32 76.45,105.12 76.05,105.12 75.86,105.32 75.86,106.7 75.78,106.77 75.55,106.77 75.48,106.7 75.48,105.32 75.28,105.12 74.88,105.12 74.69,105.32 74.69,106.7 74.61,106.77 74.38,106.77 74.31,106.7 74.31,105.32 74.11,105.12 73.71,105.12 73.52,105.32 73.52,106.7 73.44,106.77 73.21,106.77 73.14,106.7 73.14,105.32 72.94,105.12 72.55,105.12 72.35,105.32 72.35,106.7 72.28,106.77 72.05,106.77 71.97,106.7 71.97,105.32 71.78,105.12 71.38,105.12 71.18,105.32 71.18,106.7 71.11,106.77 68.96,106.77 66.74,108.99 65.71,108.99 v3(65.49,108.77)
PEG_CRX_GTX_P8: length 56.8
  TOP w0.081: v8(99.11,97.15) 99.08,97.18 98.9,97.18 98.79,97.07 UC1.E18
  IN1 w0.058: v8(99.11,97.15) 99.11,97.12 98.96,96.97 98.88,96.97 98.82,97.03 98.82,97.19 98.86,97.22 98.86,98.02 98.65,98.23 98.57,98.23
  IN1 w0.076: v8(72.96,136.54) 73.03,136.54 73.11,136.61 73.11,136.78 73.03,136.86 72.5,136.86 71.97,136.32 71.97,132.78 74.49,130.27 74.49,126.58 74.3,126.39 74.3,120.78 74.49,120.59 74.49,116.36 79.52,111.32 79.86,111.32 87.39,103.79 90.97,103.79 95.4,99.35 95.65,99.35 96.55,98.45 98.34,98.45 98.57,98.23
PEG_CRX_GTX_P9: length 64.1
  TOP w0.081: UC1.E19 v8(98.42,97.44)
  IN1 w0.058: v8(98.42,97.44) 98.37,97.39 98.13,97.39 98.07,97.44 98.07,97.77 97.9,97.94 95.92,97.94
  IN1 w0.076: v8(72.96,139.08) 72.76,139.28 72.33,139.28 71.3,138.25 71.3,133.14 70.52,132.36 69.17,132.36 67.46,130.65 67.46,130.43 67.18,130.15 67.18,127.53 69.08,125.63 71.22,125.63 73.71,123.14 73.71,120.53 73.9,120.34 73.9,116.12 79.28,110.74 79.61,110.74 87.2,103.15 90.71,103.15 94.56,99.3 94.56,98.79 95.33,98.02 95.84,98.02 95.92,97.94
PEG_CRX_GTX_P10: length 55.4
  IN1 w0.076: v8(72.96,137.81) 72.96,137.94 73.09,138.06 73.53,138.06 73.81,137.78 73.81,134.25 73.58,134.02 73.58,132.91 74.68,131.82 74.68,131.67 75.49,130.85 75.49,121.01 76.28,120.23 76.28,118.7 75.92,118.34 75.92,116.32 76.96,115.28 77.52,115.28 84.39,108.41 85.29,108.41 88.84,104.87 92.74,104.87 96.49,101.12 97.54,101.12 99.09,99.57 99.09,98.57 99.01,98.5 98.84,98.5 v8(98.79,98.55)
PEG_CRX_GTX_P11: length 51.6
  IN1 w0.076: v8(72.96,135.2) 72.96,135.33 72.89,135.41 72.68,135.41 72.61,135.33 72.61,133.26 74.3,131.57 74.3,131.51 75.07,130.73 75.07,126.19 74.88,126 74.88,121.08 75.34,120.63 75.34,116.37 76.81,114.9 77.36,114.9 84.39,107.86 85.2,107.86 88.63,104.43 91.52,104.43 95.14,100.82 95.64,100.82 96.47,99.99 98.27,99.99 98.48,99.78 98.48,99.35 98.55,99.28 98.72,99.28 v8(98.79,99.34)
PEG_CRX_RD_GTX_N8: length 25.6
  TOP w0.089: JCDRA.16 47.85,148.32 47.88,148.29 47.88,146.52 v8(47.79,146.44)
  IN1 w0.076: v8(65.05,137.09) 64.44,137.09 62.15,139.38 62.15,141.15 56.36,146.94 48.04,146.94 47.84,146.75 47.84,146.49 v8(47.79,146.44)
PEG_CRX_RD_GTX_N9: length 25.3
  TOP w0.089: JCDRA.19 46.65,148.39 46.72,148.31 46.72,148.1 v8(46.59,147.97)
  IN1 w0.076: v8(65.05,139.59) 64.53,139.59 64.45,139.67 64.45,141.65 63.91,142.19 62.81,142.19 56.31,148.69 46.88,148.69 46.59,148.41 v8(46.59,147.97)
PEG_CRX_RD_GTX_N10: length 27.7
  TOP w0.089: v8(44.19,147.79) 44.31,147.9 44.31,148.31 44.25,148.36 JCDRA.25
  IN1 w0.076: v8(44.19,147.79) 44.25,147.85 44.25,148.17 44.45,148.36 45.47,148.36 46.29,147.54 56.59,147.54 62.74,141.39 62.74,139.99 64.14,138.59 v8(65.05,138.59)
PEG_CRX_RD_GTX_N11: length 31.8
  TOP w0.089: v8(41.79,147.28) 41.8,147.28 41.88,147.36 41.88,148.26 41.85,148.3 JCDRA.31
  IN1 w0.076: v8(41.79,147.28) 41.85,147.33 41.85,147.66 42.04,147.86 42.8,147.86 44.6,146.05 56.42,146.05 61.57,140.9 61.57,138.81 64.31,136.07 65.03,136.07 v8(65.05,136.09)
PEG_CRX_RD_GTX_P8: length 25.6
  TOP w0.089: v8(48.22,146.44) 48.08,146.58 48.08,148.26 48.25,148.42 JCDRA.15
  IN1 w0.076: v8(48.22,146.44) 48.2,146.44 48.04,146.6 48.04,146.66 48.12,146.74 56.27,146.74 61.95,141.06 61.95,139.3 64.36,136.89 64.84,136.89 65.05,136.68 v8(65.05,136.59)
PEG_CRX_RD_GTX_P9: length 25.3
  TOP w0.089: JCDRA.18 47.05,148.42 46.93,148.3 46.93,148.06 v8(47.02,147.97)
  IN1 w0.076: v8(47.02,147.97) 46.79,148.19 46.79,148.33 46.96,148.49 56.23,148.49 62.73,141.99 63.82,141.99 64.25,141.56 64.25,139.58 64.44,139.39 64.84,139.39 65.05,139.18 v8(65.05,139.09)
PEG_CRX_RD_GTX_P10: length 27.6
  TOP w0.089: JCDRA.24 44.65,148.44 44.51,148.3 44.51,147.9 v8(44.62,147.79)
  IN1 w0.076: v8(44.62,147.79) 44.58,147.79 44.46,147.91 44.46,148.08 44.53,148.16 45.38,148.16 46.21,147.34 56.5,147.34 62.53,141.3 62.53,139.91 64.05,138.39 64.84,138.39 64.93,138.3 64.97,138.3 65.05,138.22 v8(65.05,138.09)
PEG_CRX_RD_GTX_P11: length 31.8
  TOP w0.089: JCDRA.30 42.25,148.35 42.09,148.19 42.09,147.41 v8(42.22,147.28)
  IN1 w0.076: v8(65.05,135.59) 65.05,135.68 64.85,135.87 64.23,135.87 61.37,138.73 61.37,140.82 56.34,145.85 44.52,145.85 42.71,147.65 42.13,147.65 42.05,147.58 42.05,147.41 42.18,147.28 v8(42.22,147.28)
PEG_CTX_C_GRX_N0: length 74.9
  TOP w0.089: v8(87.06,89.94) 87.15,89.85 87.72,89.85 87.89,89.68 v13(88.58,89.68) 89.24,89.68 89.41,89.85 91.31,89.85 91.49,90.03 CC1.2
  IN1 w0.076: v8(57.55,101.35) 57.63,101.35 57.72,101.44 57.72,101.63 57.98,101.88 58.63,101.88 59.08,101.43 59.08,100.78 58.79,100.49 58.79,99.94 59.13,99.6 59.44,99.6 60.32,98.71 66.94,98.71 72.32,93.32 72.54,93.32 75.66,90.21 75.92,90.21 77.01,91.3 77.01,91.41 76.43,91.99 76.43,92.26 79.07,94.9 79.34,94.9 79.62,94.62 79.62,94.34 77.55,92.26 77.55,92.15 77.71,91.99 77.82,91.99 79.89,94.07 80.17,94.07 80.45,93.79 80.45,93.51 77.1,90.16 77.1,90.06 77.27,89.89 77.37,89.89 80.72,93.24 81,93.24 81.28,92.96 81.28,92.69 78.72,90.13 78.72,90.02 78.89,89.86 78.99,89.86 81.55,92.42 81.83,92.42 82.11,92.14 82.11,91.86 80.85,90.61 80.85,90.5 81.01,90.34 81.12,90.34 82.38,91.59 82.65,91.59 82.93,91.31 82.93,91.03 82.41,90.51 82.41,90.4 82.57,90.24 82.68,90.24 83.2,90.76 83.48,90.76 83.89,90.35 85.14,90.35 85.65,89.84 86.96,89.84 v8(87.06,89.94)
PEG_CTX_C_GRX_N1: length 73.6
  TOP w0.089: CC2.2 89.58,90.4 89.42,90.4 89.33,90.49 89.33,90.63 89.18,90.78 88.76,90.78 88.75,90.77 88.21,90.77 88.2,90.78 87.76,90.78 87.62,90.64 87.62,90.51 v8(87.76,90.36)
  IN1 w0.076: v8(58.25,102.75) 58.23,102.77 58.05,102.77 57.98,102.69 57.98,102.54 58.04,102.48 58.86,102.48 59.13,102.21 59.77,102.21 60.78,101.2 60.78,100.16 60.4,99.78 60.4,99.46 60.57,99.29 67.19,99.29 72.3,94.18 72.41,94.18 75.24,97.01 75.51,97.01 75.85,96.68 75.85,96.4 73.12,93.68 73.12,93.57 73.28,93.41 73.39,93.41 77.42,97.44 77.7,97.44 77.98,97.15 77.98,96.88 73.95,92.85 73.95,92.74 75.68,91.01 75.79,91.01 76.11,91.33 76.11,91.43 74.85,92.69 74.85,93.22 78.25,96.61 78.52,96.61 78.8,96.33 78.8,96.05 76.49,93.74 76.49,93.63 76.65,93.47 76.76,93.47 79.07,95.78 79.35,95.78 84.12,91.01 87.41,91.01 87.65,90.77 87.65,90.47 v8(87.76,90.36)
PEG_CTX_C_GRX_N2: length 72.3
  TOP w0.089: CC3.2 91.32,91.76 v13(87.3,91.76) 86.08,91.76 v8(85.98,91.86)
  IN1 w0.076: v8(58.95,103.45) 59.14,103.26 59.25,103.26 59.63,103.26 61.42,101.48 61.42,100.87 62.41,99.88 67.43,99.88 69.7,97.61 69.82,97.61 71.06,98.84 71.33,98.84 71.62,98.56 71.62,98.29 70.38,97.05 70.38,96.94 70.54,96.78 70.65,96.78 74.79,100.92 75.07,100.92 75.35,100.64 75.35,100.36 71.21,96.22 71.21,96.11 71.37,95.95 71.48,95.95 75.62,100.09 75.89,100.09 76.17,99.81 76.17,99.54 72.03,95.4 72.03,95.29 72.2,95.13 72.3,95.13 76.44,99.27 76.72,99.27 77.13,98.85 77.13,98.58 76.02,97.47 76.02,97.36 76.19,97.2 76.29,97.2 77.4,98.31 77.68,98.31 84.22,91.77 85.89,91.77 v8(85.98,91.86)
PEG_CTX_C_GRX_N3: length 73.1
  TOP w0.089: v8(85.32,92.23) 85.18,92.38 85.18,92.56 85.44,92.83 v13(86.05,92.83) 86.68,92.83 86.85,92.66 89.21,92.66 89.3,92.57 89.3,92.4 89.38,92.32 CC4.2
  IN1 w0.076: v8(57.55,103.45) 57.62,103.52 57.62,103.69 57.83,103.89 58.49,103.89 58.75,104.15 59.57,104.15 60.59,103.13 61.02,103.13 61.21,102.93 61.21,102.55 62.04,101.72 62.04,101.29 62.87,100.46 67.68,100.46 68.05,100.08 68.16,100.08 72.31,104.23 72.58,104.23 72.87,103.95 72.87,103.67 69.18,99.98 69.18,99.87 69.34,99.71 69.45,99.71 73.14,103.41 73.41,103.41 73.69,103.12 73.69,102.84 69.55,98.7 69.55,98.59 69.71,98.43 69.82,98.43 73.96,102.57 74.24,102.57 74.52,102.29 74.52,102.02 71.81,99.3 71.81,99.2 71.97,99.03 72.08,99.03 74.79,101.75 75.07,101.75 83.85,92.97 85.12,92.97 85.32,92.76 v8(85.32,92.23)
PEG_CTX_C_GRX_N4: length 73.5
  TOP w0.089: v8(87.22,93.75) 87.31,93.65 v13(88.6,93.65) 90.13,93.65 90.14,93.66 91.32,93.66 CC5.2
  IN1 w0.076: v8(87.22,93.75) 86.87,93.75 86.79,93.82 86.79,96.1 85.16,97.73 82.45,97.73 79.84,100.34 79.84,100.51 81.12,101.79 81.12,102.07 80.83,102.35 80.56,102.35 79.22,101.01 79.11,101.01 78.95,101.17 78.95,101.28 80.29,102.62 80.29,102.89 80.01,103.17 79.73,103.17 78.39,101.83 78.28,101.83 78.12,102 78.12,102.1 79.46,103.44 79.46,103.72 79.18,104 78.9,104 77.56,102.66 77.46,102.66 77.29,102.82 77.29,102.93 78.63,104.27 78.63,104.55 78.35,104.83 78.08,104.83 76.74,103.49 76.63,103.49 76.47,103.65 76.47,103.76 77.81,105.1 77.81,105.37 77.53,105.65 77.25,105.65 75.91,104.32 75.8,104.32 75.64,104.48 75.64,104.59 76.98,105.92 76.98,106.2 73.29,109.9 71.68,109.9 70.15,111.42 59.67,111.42 58.2,109.95 57.47,109.95 57.21,109.69 57.21,107.63 57.11,107.53 57.11,104.51 57.35,104.27 57.88,104.27 58.19,104.58 58.19,104.79 v8(58.25,104.85)
PEG_CTX_C_GRX_N5: length 71.7
  TOP w0.089: CC6.2 89.38,94.22 89.3,94.31 89.3,94.47 89.18,94.59 87.01,94.59 87,94.58 86.44,94.58 86.42,94.59 85.33,94.59 85.3,94.56 85.3,94.56 85.17,94.43 85.17,94.27 85.35,94.09 v8(85.35,94.07)
  IN1 w0.076: v8(85.35,94.07) 85.24,94.18 85.24,94.37 85.05,94.56 83.08,94.56 71.21,106.43 69.33,106.43 69.14,106.23 69.14,105.84 69.33,105.64 70.72,105.64 70.79,105.56 70.79,105.34 70.72,105.26 66.44,105.26 66.24,105.07 66.24,104.67 66.44,104.47 71.35,104.47 71.42,104.4 71.42,104.17 71.35,104.09 66.44,104.09 66.24,103.9 66.24,103.5 66.44,103.3 70.18,103.3 70.25,103.23 70.25,103 70.18,102.92 66.49,102.92 66.29,102.73 66.29,101.73 66.54,101.49 68.3,101.49 68.37,101.41 68.37,101.12 68.3,101.04 65.74,101.04 65.66,101.12 65.66,102.26 65.4,102.52 64.9,102.52 64.66,102.27 64.66,101.12 64.58,101.04 63.14,101.04 62.96,101.23 62.96,101.63 61.8,102.79 61.8,103.3 59.75,105.35 59.15,105.35 v8(58.95,105.55)
PEG_CTX_C_GRX_N6: length 72.6
  TOP w0.089: v8(84.96,95.7) 85.06,95.61 v13(87.95,95.61) 91.35,95.61 CC7.2
  IN1 w0.076: v8(57.55,105.55) 57.66,105.66 57.66,105.76 58.18,106.28 60.56,106.28 60.75,106.08 60.75,105.17 60.83,105.1 61.06,105.1 61.13,105.17 61.13,106.02 61.33,106.21 61.73,106.21 61.92,106.02 61.92,104 62,103.93 62.22,103.93 62.3,104 62.3,109.32 62.5,109.51 63.21,109.51 63.41,109.32 63.41,109.03 63.48,108.96 63.71,108.96 63.79,109.03 63.79,110.04 64,110.25 64.4,110.25 64.62,110.04 64.62,108.2 64.74,108.07 66.18,108.07 66.31,108.19 66.31,110.01 66.5,110.2 66.9,110.2 67.1,110.01 67.1,105.96 67.17,105.88 67.4,105.88 67.48,105.96 67.48,110.01 67.67,110.2 68.07,110.2 68.27,110.01 68.27,106.57 68.34,106.49 68.57,106.49 68.65,106.57 68.65,110.01 68.84,110.2 69.24,110.2 69.43,110.01 69.43,107.16 69.58,107.01 71.45,107.01 82.86,95.61 84.87,95.61 v8(84.96,95.7)
PEG_CTX_C_GRX_N7: length 73.2
  TOP w0.089: v8(84.96,96.46) 85.05,96.55 85.51,96.55 85.76,96.29 v13(86.39,96.29) 89.42,96.29 CC8.2
  IN1 w0.076: v8(84.96,96.46) 84.93,96.46 84.77,96.62 82.38,96.62 73.81,105.19 73.81,105.47 74.62,106.28 74.62,106.38 74.46,106.55 74.35,106.55 73.54,105.74 73.27,105.74 72.98,106.02 72.98,106.3 74.32,107.64 74.32,107.74 74.16,107.91 74.05,107.91 72.71,106.57 72.44,106.57 72.16,106.85 72.16,107.12 73.24,108.21 73.24,108.31 73.08,108.48 72.97,108.48 71.89,107.39 71.44,107.39 71.24,107.59 71.24,108.33 71.16,108.41 70.94,108.41 70.86,108.33 70.86,107.59 70.67,107.39 70.03,107.39 69.84,107.59 69.84,110.33 69.54,110.63 65.91,110.63 65.83,110.56 65.83,109.95 65.64,109.76 65.24,109.76 65.04,109.95 65.04,110.56 64.97,110.63 63.48,110.63 63.4,110.56 63.4,110.13 63.21,109.93 62.81,109.93 62.62,110.13 62.62,110.56 62.54,110.63 62.31,110.63 62.24,110.56 62.24,109.89 62.04,109.69 61.64,109.69 61.45,109.89 61.45,110.56 61.37,110.63 61.14,110.63 61.07,110.56 61.07,109.24 61.14,109.17 61.65,109.17 61.85,108.97 61.85,108.57 61.65,108.38 61.14,108.38 61.07,108.3 61.07,108.07 61.14,108 61.65,108 61.85,107.8 61.85,107.41 61.65,107.21 61.14,107.21 61.07,107.13 61.07,106.89 60.87,106.7 60.47,106.7 60.28,106.89 60.28,110.51 60.2,110.58 59.97,110.58 59.9,110.51 59.9,106.89 59.7,106.7 59.31,106.7 59.11,106.89 59.11,109.17 59.03,109.25 58.8,109.25 58.72,109.17 58.72,108.02 57.92,107.22 57.92,107.03 57.99,106.95 v8(58.25,106.95)
PEG_CTX_C_GRX_N8: length 82.6
  TOP w0.089: v3(52.66,148.11) 52.65,148.11 JCDRA.4
  TOP w0.097: v3(90.92,97.06) 90.97,97.11 91.46,97.11 CC9.2
  IN2 w0.076: v3(90.92,97.06) 90.71,97.27 90.48,97.27 90.28,97.47 90.28,97.88 90.45,98.04 90.45,101.42 90.16,101.71 90.16,106.94 88.87,108.23 86.04,108.23 84.69,109.58 75.75,109.58 72.2,113.13 65.35,113.13 62.61,115.87 62.61,122.77 62.06,123.32 62.06,140.54 59.46,143.14 54.79,143.14 52.9,145.04 52.9,147.92 52.71,148.11 v3(52.66,148.11)
PEG_CTX_C_GRX_N9: length 83.2
  TOP w0.089: v3(89.36,98.69) 89.62,98.43 90.11,98.43 CC10.2 ; v3(51.38,148.11) 51.45,148.18 JCDRA.7
  IN2 w0.076: v3(51.38,148.11) 51.65,147.84 51.65,143.69 53.27,142.08 59.7,142.08 61.48,140.3 61.48,122.87 61.98,122.37 61.98,115.52 64.95,112.55 71.16,112.55 72.15,111.56 72.89,111.56 75.48,108.97 83.98,108.97 85.53,107.42 88.54,107.42 89.53,106.43 89.53,101.38 89.8,101.11 89.8,98.5 89.67,98.38 89.43,98.38 89.36,98.45 v3(89.36,98.69)
PEG_CTX_C_GRX_N10: length 86.3
  TOP w0.089: JCDRA.10 50.25,148.21 50.16,148.12 v3(50.16,148.12)
  TOP w0.097: CC11.2 91.38,99.1 91.16,99.1 91.06,99 v3(91.06,99)
  IN2 w0.076: v3(91.06,99) 91.19,99.13 91.43,99.13 91.67,99.36 91.67,101.53 91.07,102.13 91.07,107.49 88.78,109.78 85.62,109.78 85.01,110.39 76.34,110.39 72.8,113.92 65.75,113.92 63.45,116.22 63.45,123.05 62.85,123.65 62.85,140.87 59.75,143.97 56.08,143.97 54.94,145.11 54.94,148.14 53.44,149.63 50.62,149.63 50.16,149.18 v3(50.16,148.12)
PEG_CTX_C_GRX_N11: length 83.3
  TOP w0.081: CC12.2 90.08,100.33
  TOP w0.089: v3(48.91,148.12) 48.96,148.12 49.05,148.21 JCDRA.13 ; v5(88.59,100.51) 88.77,100.33 90.08,100.33
  IN2 w0.076: v3(48.91,148.12) 49.09,147.94 49.09,144.33 52.58,140.83 58.81,140.83 60.89,138.74 60.89,122.01 61.24,121.67 61.24,119.51 60.73,119 60.73,115.78 64.57,111.94 70.38,111.94 71.73,110.59 72.85,110.59 75.08,108.36 83.76,108.36 85.44,106.68 88.04,106.68 88.89,105.83 88.89,101.11 89.18,100.82 89.18,100.23 89.1,100.15 88.92,100.15 88.84,100.24 88.84,100.42 88.75,100.51 v5(88.59,100.51)
PEG_CTX_C_GRX_P0: length 74.9
  TOP w0.089: CC13.2 91.49,89.46 91.31,89.64 89.49,89.64 89.32,89.47 88.86,89.47 88.85,89.46 88.31,89.46 88.29,89.47 87.81,89.47 87.63,89.64 87.15,89.64 v8(87.06,89.56)
  IN1 w0.076: v8(87.06,89.56) 86.97,89.64 85.56,89.64 85.06,90.15 83.81,90.15 83.39,90.56 83.29,90.56 82.76,90.04 82.49,90.04 82.21,90.32 82.21,90.59 82.73,91.12 82.73,91.23 82.57,91.39 82.46,91.39 81.21,90.13 80.93,90.13 80.65,90.41 80.65,90.69 81.9,91.94 81.9,92.05 81.74,92.21 81.63,92.21 79.08,89.66 78.8,89.66 78.52,89.94 78.52,90.22 81.08,92.77 81.08,92.88 80.91,93.04 80.81,93.04 77.46,89.69 77.18,89.69 76.9,89.97 76.9,90.25 80.25,93.6 80.25,93.71 80.09,93.87 79.98,93.87 77.9,91.79 77.62,91.79 77.34,92.07 77.34,92.35 79.42,94.43 79.42,94.53 79.26,94.7 79.15,94.7 76.64,92.18 76.64,92.07 77.22,91.49 77.22,91.21 76,90 75.57,90 72.45,93.12 72.24,93.12 66.85,98.5 60.24,98.5 59.35,99.39 59.05,99.39 58.59,99.86 58.59,100.57 58.88,100.87 58.88,101.35 58.55,101.68 58.06,101.68 57.93,101.55 57.93,101.3 58.01,101.22 58.15,101.22 58.25,101.32 v8(58.25,101.35)
PEG_CTX_C_GRX_P1: length 73.6
  TOP w0.089: v8(87.35,90.36) 87.41,90.42 87.41,90.72 87.68,90.98 v13(88.48,90.98) CC14.2
  IN1 w0.076: v8(87.35,90.36) 87.45,90.46 87.45,90.69 87.33,90.81 84.03,90.81 79.27,95.58 79.16,95.58 76.84,93.26 76.57,93.26 76.29,93.55 76.29,93.82 78.6,96.14 78.6,96.24 78.44,96.41 78.33,96.41 75.06,93.13 75.06,92.77 76.31,91.52 76.31,91.24 75.87,90.8 75.6,90.8 73.74,92.66 73.74,92.93 77.77,96.96 77.77,97.07 77.61,97.23 77.5,97.23 73.47,93.2 73.2,93.2 72.92,93.48 72.92,93.76 75.64,96.49 75.64,96.6 75.43,96.81 75.32,96.81 72.49,93.98 72.21,93.98 67.11,99.09 60.49,99.09 60.2,99.38 60.2,99.86 60.58,100.24 60.58,101.12 59.69,102.01 59.05,102.01 58.78,102.28 57.95,102.28 57.77,102.46 57.77,102.67 57.7,102.75 v8(57.55,102.75)
PEG_CTX_C_GRX_P2: length 72.3
  TOP w0.089: v8(85.98,91.48) 86.06,91.56 87.02,91.56 87.03,91.54 87.57,91.54 87.58,91.56 91.3,91.56 CC15.2
  IN1 w0.076: v8(58.95,102.75) 59.26,103.06 59.55,103.06 61.21,101.39 61.21,100.79 62.33,99.67 67.35,99.67 69.62,97.4 69.91,97.4 71.14,98.64 71.25,98.64 71.41,98.48 71.41,98.37 70.18,97.13 70.18,96.86 70.46,96.58 70.73,96.58 74.87,100.72 74.98,100.72 75.14,100.56 75.14,100.45 71,96.31 71,96.03 71.28,95.75 71.56,95.75 75.7,99.89 75.81,99.89 75.97,99.73 75.97,99.62 71.83,95.48 71.83,95.2 72.11,94.92 72.39,94.92 76.53,99.06 76.64,99.06 76.93,98.77 76.93,98.66 75.82,97.55 75.82,97.28 76.1,96.99 76.38,96.99 77.49,98.1 77.6,98.1 84.13,91.57 85.89,91.57 v8(85.98,91.48)
PEG_CTX_C_GRX_P3: length 73.1
  TOP w0.089: CC16.2 89.56,92.86 86.93,92.86 86.76,93.03 86.33,93.03 86.32,93.04 85.78,93.04 85.77,93.03 85.35,93.03 84.97,92.65 84.97,92.29 v8(84.92,92.23)
  IN1 w0.076: v8(58.25,103.45) 58.14,103.34 57.97,103.34 57.83,103.48 57.83,103.65 57.9,103.72 58.61,103.72 58.83,103.95 59.48,103.95 60.51,102.92 60.93,102.92 61.01,102.85 61.01,102.47 61.84,101.64 61.84,101.21 62.79,100.26 67.59,100.26 67.97,99.88 68.25,99.88 72.4,104.03 72.5,104.03 72.66,103.86 72.66,103.76 68.97,100.06 68.97,99.79 69.25,99.51 69.53,99.51 73.23,103.2 73.32,103.2 73.49,103.04 73.49,102.93 69.34,98.78 69.34,98.51 69.62,98.22 69.9,98.22 74.05,102.37 74.15,102.37 74.32,102.21 74.32,102.1 71.6,99.39 71.6,99.11 71.89,98.83 72.16,98.83 74.87,101.54 74.98,101.54 83.76,92.76 85.03,92.76 85.12,92.68 85.12,92.44 84.92,92.24 v8(84.92,92.23)
PEG_CTX_C_GRX_P4: length 73.5
  TOP w0.089: CC17.2 91.3,93.46 90.23,93.46 90.21,93.44 88.88,93.44 88.87,93.43 88.33,93.43 88.31,93.44 87.35,93.44 87.27,93.37 v8(87.22,93.37)
  IN1 w0.076: v8(87.22,93.37) 87.18,93.37 87,93.54 86.78,93.54 86.59,93.74 86.59,96.02 85.08,97.53 82.36,97.53 79.63,100.26 79.63,100.6 80.91,101.87 80.91,101.98 80.75,102.14 80.64,102.14 79.3,100.8 79.03,100.8 78.75,101.09 78.75,101.36 80.09,102.7 80.09,102.81 79.92,102.97 79.82,102.97 78.48,101.63 78.2,101.63 77.92,101.91 77.92,102.19 79.26,103.53 79.26,103.64 79.1,103.8 78.99,103.8 77.65,102.46 77.37,102.46 77.09,102.74 77.09,103.02 78.43,104.35 78.43,104.46 78.27,104.62 78.16,104.62 76.82,103.29 76.55,103.29 76.26,103.57 76.26,103.84 77.6,105.18 77.6,105.29 77.44,105.45 77.33,105.45 76,104.11 75.72,104.11 75.44,104.39 75.44,104.67 76.78,106.01 76.78,106.12 73.2,109.69 71.59,109.69 70.07,111.22 59.75,111.22 58.28,109.74 57.55,109.74 57.42,109.61 57.42,107.55 57.28,107.41 57.28,104.63 57.44,104.47 57.79,104.47 57.98,104.66 57.98,104.86 57.82,105.02 57.78,105.02 57.66,105.14 57.55,105.14 57.47,105.05 57.47,104.93 v8(57.55,104.85)
PEG_CTX_C_GRX_P5: length 71.7
  TOP w0.089: v8(84.94,94.07) 84.94,94.49 85.24,94.79 v13(86.73,94.79) CC18.2
  IN1 w0.076: v8(84.94,94.07) 85.04,94.17 85.04,94.29 84.97,94.36 82.99,94.36 71.13,106.23 69.42,106.23 69.34,106.15 69.34,105.92 69.42,105.84 70.8,105.84 71,105.65 71,105.25 70.8,105.06 66.52,105.06 66.45,104.98 66.45,104.75 66.52,104.68 71.43,104.68 71.63,104.48 71.63,104.08 71.43,103.89 66.52,103.89 66.45,103.81 66.45,103.58 66.52,103.51 70.26,103.51 70.46,103.31 70.46,102.92 70.26,102.72 66.57,102.72 66.5,102.64 66.5,101.82 66.62,101.69 68.38,101.69 68.58,101.5 68.58,101.04 68.38,100.84 65.65,100.84 65.46,101.04 65.46,102.17 65.32,102.31 64.99,102.31 64.86,102.19 64.86,101.04 64.66,100.84 63.06,100.84 62.75,101.15 62.75,101.55 61.59,102.71 61.59,103.22 59.66,105.15 58.92,105.15 58.85,105.08 58.85,104.95 v8(58.95,104.85)
PEG_CTX_C_GRX_P6: length 72.5
  TOP w0.089: CC19.2 91.27,95.4 88.23,95.4 88.22,95.39 87.68,95.39 87.66,95.4 85.04,95.4 v8(84.96,95.32)
  IN1 w0.076: v8(84.96,95.32) 84.88,95.4 82.77,95.4 71.37,106.81 69.49,106.81 69.23,107.07 69.23,109.92 69.15,110 68.93,110 68.85,109.92 68.85,106.48 68.65,106.29 68.26,106.29 68.06,106.48 68.06,109.92 67.99,110 67.76,110 67.68,109.92 67.68,105.87 67.49,105.68 67.09,105.68 66.89,105.87 66.89,109.92 66.82,110 66.59,110 66.51,109.92 66.51,108.11 66.27,107.86 64.66,107.86 64.41,108.11 64.41,109.95 64.32,110.05 64.08,110.05 63.99,109.96 63.99,108.95 63.8,108.75 63.4,108.75 63.2,108.95 63.2,109.24 63.13,109.31 62.58,109.31 62.5,109.24 62.5,103.92 62.31,103.72 61.91,103.72 61.72,103.92 61.72,105.93 61.64,106.01 61.41,106.01 61.34,105.93 61.34,105.09 61.14,104.89 60.74,104.89 60.55,105.09 60.55,106 60.47,106.07 58.26,106.07 57.9,105.71 57.9,105.62 58.02,105.5 58.2,105.5 v8(58.25,105.55)
PEG_CTX_C_GRX_P7: length 73.2
  TOP w0.089: CC20.2 89.39,96.5 86.67,96.5 86.66,96.51 86.12,96.51 86.1,96.5 85.84,96.5 85.59,96.75 85.05,96.75 v8(84.96,96.84)
  IN1 w0.076: v8(57.55,106.95) 57.71,107.11 57.71,107.3 58.52,108.11 58.52,109.26 58.71,109.45 59.12,109.45 59.31,109.26 59.31,106.97 59.39,106.9 59.62,106.9 59.7,106.97 59.7,110.59 59.89,110.78 60.29,110.78 60.48,110.59 60.48,106.97 60.56,106.9 60.79,106.9 60.86,106.97 60.86,107.22 61.06,107.41 61.57,107.41 61.65,107.49 61.65,107.72 61.57,107.79 61.06,107.79 60.86,107.99 60.86,108.39 61.06,108.58 61.57,108.58 61.65,108.66 61.65,108.89 61.57,108.96 61.06,108.96 60.86,109.16 60.86,110.64 61.06,110.84 61.46,110.84 61.65,110.64 61.65,109.97 61.73,109.9 61.96,109.9 62.03,109.97 62.03,110.64 62.23,110.84 62.62,110.84 62.82,110.64 62.82,110.21 62.9,110.14 63.12,110.14 63.2,110.21 63.2,110.64 63.4,110.84 65.05,110.84 65.25,110.64 65.25,110.04 65.32,109.96 65.55,109.96 65.63,110.04 65.63,110.64 65.82,110.84 69.62,110.84 70.04,110.42 70.04,107.67 70.12,107.6 70.58,107.6 70.66,107.67 70.66,108.42 70.85,108.61 71.25,108.61 71.44,108.42 71.44,107.67 71.52,107.6 71.8,107.6 72.89,108.68 73.16,108.68 73.45,108.4 73.45,108.12 72.36,107.04 72.36,106.93 72.52,106.77 72.63,106.77 73.97,108.11 74.25,108.11 74.53,107.83 74.53,107.55 73.19,106.21 73.19,106.1 73.35,105.94 73.46,105.94 74.26,106.75 74.54,106.75 74.82,106.47 74.82,106.19 74.02,105.39 74.02,105.28 82.47,96.83 84.95,96.83 v8(84.96,96.84)
PEG_CTX_C_GRX_P8: length 82.6
  TOP w0.089: JCDRA.3 53.05,148.25 53.19,148.11 v3(53.21,148.11)
  TOP w0.097: v3(90.92,97.6) 90.89,97.58 90.89,97.41 90.98,97.32 91.16,97.32 CC21.2
  IN2 w0.076: v3(90.92,97.6) 90.79,97.48 90.56,97.48 90.49,97.55 90.49,97.79 90.65,97.96 90.65,101.5 90.36,101.79 90.36,107.03 88.95,108.44 86.13,108.44 84.77,109.79 75.84,109.79 72.29,113.34 65.43,113.34 62.81,115.96 62.81,122.86 62.27,123.41 62.27,140.63 59.55,143.35 54.88,143.35 53.1,145.12 53.1,147.99 v3(53.21,148.11)
PEG_CTX_C_GRX_P9: length 83.2
  TOP w0.089: CC22.2 90.1,98.22 89.57,98.22 v3(89.36,98.01) ; JCDRA.6 51.85,148.19 v3(51.93,148.11)
  IN2 w0.076: v3(51.93,148.11) 51.85,148.03 51.85,143.78 53.35,142.28 59.79,142.28 61.68,140.39 61.68,122.95 62.18,122.46 62.18,115.61 65.03,112.75 71.25,112.75 72.24,111.76 72.97,111.76 75.56,109.17 84.07,109.17 85.61,107.62 88.63,107.62 89.74,106.51 89.74,101.46 90,101.2 90,98.42 89.76,98.17 89.52,98.17 v3(89.36,98.01)
PEG_CTX_C_GRX_P10: length 86.3
  TOP w0.089: JCDRA.9 50.65,148.48 50.5,148.33 50.5,148.21 50.59,148.12 v3(50.7,148.12)
  TOP w0.097: CC23.2 91.49,99.51 91.3,99.31 91.16,99.31 91.06,99.41 v3(91.06,99.54)
  IN2 w0.076: v3(50.7,148.12) 50.73,148.12 50.83,148.21 50.83,148.32 50.71,148.44 50.44,148.44 50.37,148.52 50.37,149.09 50.71,149.43 53.36,149.43 54.74,148.05 54.74,145.03 56,143.77 59.67,143.77 62.65,140.79 62.65,123.56 63.25,122.96 63.25,116.14 65.66,113.72 72.72,113.72 76.25,110.19 84.93,110.19 85.54,109.58 88.7,109.58 90.87,107.41 90.87,102.05 91.47,101.45 91.47,99.44 91.35,99.33 91.11,99.33 91.03,99.41 91.03,99.51 v3(91.06,99.54)
PEG_CTX_C_GRX_P11: length 83.3
  TOP w0.081: CC24.2 90.15,100.13 90.1,100.13
  TOP w0.089: 90.1,100.13 88.79,100.13 v5(88.59,99.93) ; JCDRA.12 v3(49.45,148.12)
  IN2 w0.076: v3(49.45,148.12) 49.29,147.96 49.29,144.41 52.67,141.04 58.89,141.04 61.1,138.83 61.1,122.1 61.45,121.75 61.45,119.43 60.93,118.92 60.93,115.86 64.65,112.14 70.47,112.14 71.81,110.8 72.94,110.8 75.17,108.56 83.85,108.56 85.52,106.89 88.12,106.89 89.09,105.92 89.09,101.19 89.38,100.9 89.38,100.14 89.19,99.95 88.61,99.95 v5(88.59,99.93)
PEG_CTX_GRX_N0: length 6
  TOP w0.097: UC1.B10 96.86,90.71 97.07,90.71 97.17,90.6 97.17,90.48 97.07,90.39 95.93,90.39 95.76,90.22 v13(94.23,90.22) 93.21,90.22 92.77,89.78 92.27,89.78 92.08,89.97 CC1.1
PEG_CTX_GRX_N1: length 7.2
  TOP w0.097: UC1.B11 96.63,91.26 96.63,91.2 96.4,90.97 95.78,90.97 95.72,91.03 93.41,91.03 92.96,90.58 91.57,90.58 91.4,90.41 CC2.1
PEG_CTX_GRX_N2: length 5.9
  TOP w0.097: CC3.1 92.08,91.93 92.35,91.66 92.79,91.66 92.98,91.86 v13(94.08,91.86) 95.76,91.86 95.87,91.96 97.05,91.96 97.16,92.07 97.16,92.17 97.02,92.3 96.88,92.3 UC1.B12
PEG_CTX_GRX_N3: length 7.2
  TOP w0.097: CC4.1 90.34,92.48 91.63,92.48 91.78,92.64 92.63,92.64 92.64,92.63 93.17,92.63 93.18,92.64 95.78,92.64 95.87,92.54 96.58,92.54 96.77,92.74 96.77,92.98 UC1.B13
PEG_CTX_GRX_N4: length 5.8
  TOP w0.097: CC5.1 92.08,93.83 92.43,93.48 v13(94.04,93.48) 94.52,93.48 94.57,93.43 95.36,93.43 95.47,93.53 97.01,93.53 97.14,93.66 97.14,93.76 97.06,93.83 UC1.B14
PEG_CTX_GRX_N5: length 7.1
  TOP w0.097: UC1.B15 96.84,94.5 96.46,94.12 95.8,94.12 95.59,94.33 94.12,94.33 94.12,94.33 v13(93,94.33) 90.28,94.33 CC6.1
PEG_CTX_GRX_N6: length 6
  TOP w0.097: CC7.1 92.36,95.47 v13(93.8,95.47) 94.33,95.47 94.78,95.02 95.81,95.02 95.9,95.11 97.1,95.11 97.2,95.21 97.2,95.31 97.1,95.4 UC1.B16
PEG_CTX_GRX_N7: length 7.3
  TOP w0.097: CC8.1 90.32,96.27 92.58,96.27 92.59,96.26 93.11,96.26 93.12,96.27 94.09,96.27 94.56,95.8 95.71,95.8 95.82,95.69 96.55,95.69 96.84,95.97 UC1.B17
PEG_CTX_GRX_N8: length 6
  TOP w0.097: UC1.C18 97.41,96.9 97.41,96.74 97.15,96.48 95.11,96.48 94.59,97 v13(94.21,97) 93.39,97 93.22,97.16 92.16,97.16 CC9.1
PEG_CTX_GRX_N9: length 6.7
  TOP w0.097: CC10.1 91.09,98.39 93.11,98.39 93.57,97.93 94.43,97.93 94.64,97.72 95.82,97.72 96.06,97.47 96.44,97.47 96.54,97.57 96.54,97.67 96.44,97.77 UC1.A19
PEG_CTX_GRX_N10: length 6.2
  TOP w0.097: CC11.1 92.12,99.02 92.86,99.02 92.95,98.94 93.92,98.94 94.88,97.98 95.85,97.98 95.93,98.06 97.14,98.06 97.47,98.39 97.47,98.45 97.49,98.47 UC1.C20
PEG_CTX_GRX_N11: length 6.8
  TOP w0.097: UC1.A21 96.25,99.41 96.39,99.41 96.5,99.3 96.5,99.11 96.43,99.05 95.88,99.05 95.67,99.25 95.33,99.25 94.74,99.84 94.74,99.86 94.37,100.23 94.35,100.23 94.27,100.31 v13(92.57,100.31) 91.12,100.31 CC12.1
PEG_CTX_GRX_P0: length 6
  TOP w0.097: UC1.C10 97.49,90.53 97.14,90.18 96.01,90.18 95.86,90.03 94.55,90.03 94.52,90 93.95,90 93.93,90.02 93.32,90.02 v13(93.02,89.72) 92.87,89.57 92.19,89.57 CC13.1
PEG_CTX_GRX_P1: length 7.1
  TOP w0.097: UC1.A11 96.21,91.49 96.35,91.49 96.42,91.42 96.42,91.28 96.31,91.18 95.86,91.18 95.8,91.24 93.3,91.24 v13(93.1,91.04) 92.86,90.79 91.48,90.79 91.31,90.62 90.53,90.62 90.17,90.98 CC14.1
PEG_CTX_GRX_P2: length 5.9
  TOP w0.097: UC1.C12 97.49,92.1 97.14,91.76 95.96,91.76 95.85,91.65 94.36,91.65 94.35,91.64 93.81,91.64 93.8,91.65 93.07,91.65 92.87,91.45 92.16,91.45 CC15.1
PEG_CTX_GRX_P3: length 7.2
  TOP w0.097: CC16.1 90.37,92.69 91.54,92.69 91.69,92.85 v13(92.9,92.85) 95.86,92.85 95.97,92.73 96.48,92.73 96.56,92.81 96.56,92.95 96.46,93.04 UC1.A13
PEG_CTX_GRX_P4: length 5.8
  TOP w0.097: CC17.1 93.77,93.27 93.78,93.26 94.31,93.26 94.32,93.27 94.43,93.27 94.48,93.22 95.44,93.22 95.55,93.33 97.11,93.33 97.49,93.7 UC1.C14
PEG_CTX_GRX_P5: length 7.1
  TOP w0.097: UC1.A15 96.23,94.65 96.36,94.65 96.47,94.54 96.47,94.42 96.38,94.32 95.88,94.32 95.67,94.54 94.21,94.54 93.27,94.54 93.26,94.55 92.74,94.55 92.73,94.54 90.36,94.54 90.17,94.73 CC18.1
PEG_CTX_GRX_P6: length 6
  TOP w0.097: UC1.C16 97.41,95.33 97.41,95.15 97.4,95.15 97.16,94.91 95.98,94.91 95.89,94.81 94.69,94.81 94.25,95.26 94.07,95.26 94.07,95.25 93.54,95.25 93.53,95.26 92.16,95.26 CC19.1
PEG_CTX_GRX_P7: length 7.3
  TOP w0.097: UC1.A17 96.22,96.23 96.43,96.23 96.54,96.12 96.54,95.98 96.46,95.9 95.9,95.9 95.79,96.01 94.64,96.01 94.17,96.48 v13(92.85,96.48) 90.39,96.48 CC20.1
PEG_CTX_GRX_P8: length 6
  TOP w0.097: CC21.1 92.36,97.37 93.31,97.37 93.48,97.21 93.94,97.21 93.95,97.22 94.47,97.22 94.48,97.21 94.67,97.21 95.19,96.68 97.09,96.68 97.18,96.78 97.18,96.88 97.09,96.98 UC1.B18
PEG_CTX_GRX_P9: length 6.7
  TOP w0.097: CC22.1 91.02,98.18 93.01,98.18 v13(93.29,97.89) 93.47,97.72 94.35,97.72 94.55,97.51 95.73,97.51 95.98,97.27 96.48,97.27 96.71,97.5 96.71,97.64 UC1.B19
PEG_CTX_GRX_P10: length 6.2
  TOP w0.081: UC1.B20 97.1,98.55 97.16,98.5
  TOP w0.097: 97.16,98.5 97.16,98.36 97.06,98.26 95.85,98.26 95.78,98.19 94.97,98.19 93.92,99.24 v13(93.28,99.24) 92.5,99.24 92.18,99.56 CC23.1
PEG_CTX_GRX_P11: length 6.9
  TOP w0.097: CC24.1 91.01,100.1 92.3,100.1 92.31,100.1 92.83,100.1 92.84,100.1 94.18,100.1 v13(94.4,99.89) 95.24,99.04 95.6,99.04 95.79,98.84 96.53,98.84 96.84,99.15 UC1.B21
PEG_RCOMP: length 5.4
  TOP w0.254: 100.01,83.98 100.01,84.29 100.2,84.48 100.2,85.37 UC1.G2
  TOP w0.381: RC2.2 99.13,81.61 98.73,82.01 98.73,83.24 99.11,83.62 99.66,83.62 100.01,83.98
PEX_RST#: length 18.8
  TOP w0.081: v2(99.52,19.38) 100,19.87 v8(100.33,19.87) RG1522.1 ; UG10.1 94.35,21.3 94.84,20.81 v8(94.84,20.17)
  IN1 w0.058: v8(94.84,20.17) 97.43,20.17 98.02,19.59 99.95,19.59 100.23,19.87 v8(100.33,19.87) 100.36,19.87 100.65,20.16 100.65,21.3 99.95,22 99.95,22.69
  IN1 w0.089: v8(100.58,28) 100.58,25.8 99.5,24.73 99.5,23.84 99.95,23.4 99.95,22.69
PEX_TERMP: length 4.5
  TOP w0.081: v2(61.36,111.5) RG23.2
  TOP w0.117: UG1.BL44 58.92,112.58 RG23.2
PEX_VDD_ENP: length 199
  TOP w0.081: v10(2.35,2.44) 3,3.09 v5(3,3.27) 3.28,3.55 CG7107.1 RG1521.2 ; v5(76.58,70.07) 77.1,69.55 77.1,66.35 76.65,65.89 QG524.2
  IN2 w0.058: v3(70.86,1.91) 69.34,3.44 69.34,9.11 70.57,10.34 v3(71.03,10.34)
  IN3 w0.058: v5(3,3.27) 4.64,3.27 6.7,1.2 24.16,1.2 24.93,1.97 29.87,1.97 30.64,1.2 38.56,1.2 39.55,2.19 39.55,3.32 41.33,5.09 42.66,5.09 43.16,4.99 43.63,4.8 43.66,4.78 44.05,4.52 46.29,2.28 46.38,2.28 46.38,2.28 47.69,2.28 48.56,1.4 65.24,1.4 65.81,1.97 70.21,1.97 70.27,1.91 v3(70.86,1.91) ; v3(71.03,10.34) 70.87,10.51 70.87,11.97 72.06,13.16 72.06,16.06 71.88,16.24 71.88,20.12 73.15,21.39 73.15,22.25 73.96,23.07 79.52,23.07 82.57,26.12 82.57,29.36 80.49,31.44 80.49,33.33 77.89,35.93 77.89,35.94 78.2,36.25 78.2,43.23 77.89,43.54 77.89,51.97 76.32,53.54 76.32,69.81 v5(76.58,70.07)
  IN4 w0.058: v7(70.87,101.84) 70.87,101.36 69.9,100.4 69.9,98.09 71.27,96.72 71.27,90.4 69.87,88.99 69.87,85.03 69.32,84.49 69.32,83.81 69.31,83.79 69.31,83.14 70.32,82.13 70.32,81.54 72.4,79.46 72.4,73.56 72.86,73.1 72.86,72.81 74.5,71.17 75.17,71.17 76.28,70.07 v5(76.58,70.07)
PEX_VDD_RC_ENP: length 150.6
  TOP w0.081: v1(4.56,8.49) 3.78,8.49 CG7094.1 3.76,8.06 3.94,7.88 UG47.1
  GND2 w0.081: v3(4.88,8.39) 4.78,8.49 v1(4.56,8.49)
  IN3 w0.058: v9(84.04,18.58) 83.94,18.68 80.86,18.68 80.62,18.44 ; 79.07,10.57 79.07,8.12 79.68,7.51 79.89,7.51 80.34,7.06 80.34,5.92 79.73,5.31 79.73,4.35 78.75,3.37 78,3.37 77.56,3.82 69.97,3.82 69.88,3.72 65.11,3.72 64.53,3.13 50.01,3.13 48.47,4.68 46.34,4.68 45.16,5.86 44.63,6.21 44.45,6.33 43.66,6.66 42.82,6.82 40.15,6.82 40.05,6.73 40.05,6.73 38.68,5.35 31.53,5.35 31.35,5.53 27.35,5.53 26.59,4.78 22.13,4.78 21.23,3.88 15.55,3.88 14.83,4.59 12.82,4.59 11.56,5.86 11.56,6.36 11.26,6.66 9.65,6.66 8.54,7.77 6.25,7.77 5.77,8.26 5.01,8.26 v3(4.88,8.39)
  IN3 w0.076: 80.62,18.44 80.44,18.26 78.76,18.26 78.29,17.8 78.13,17.8 77.7,17.37 77.7,14.58 78.87,13.41 78.87,12.92 79.37,12.42 79.37,11.39 79.07,11.09 79.07,10.57
  GND4 w0.081: v4(84.04,18.84) v9(84.04,18.58)
  BOTTOM w0.081: DG10.1 73.24,56.39 75.7,53.93 75.7,48.66 76.35,48.01 80.94,48.01 82.07,46.87 82.07,39.76 82.11,39.72 82.11,39.46 82.07,39.42 82.07,37.89 v2(83.29,36.68) 82.44,35.83 82.44,34.8 82.91,34.33 82.91,25.06 84.04,23.93 v4(84.04,18.84)
PEX_WAKE#: length 4.1
  TOP w0.081: T14.1 61.13,113.59 57.89,113.59 UG1.BK44
PGOOD_1.2V: length 2.4
  TOP w0.203: PUM1.10 149.21,44.31 PRM10.2
PLTRST_CPU#: length 243.5
  TOP w0.081: v3(138.33,111.36) 139.4,112.42 139.89,112.42 140.08,112.61 CH195.1 138.12,112.79 137.79,112.47 137.79,111.25 137.01,110.47 136.63,110.47 136.53,110.37 135.99,110.37 135.51,109.89 UC1.BP35
  TOP w0.122: UH1.AG5 94.94,35 v5(95.22,34.72)
  IN2 w0.058: v6(70.47,114.86) 70.47,114.89 70.64,115.06 80.97,115.06 81.37,115.45 v3(81.37,115.57)
  IN3 w0.058: v3(81.37,115.57) 81.37,116.2 80.95,116.62 80.95,130.21 83.23,132.49 83.31,132.49 84.85,134.03 85.8,134.03 86.57,134.79 88.32,134.79 89.8,136.27 92.45,136.27 93.17,136.99 96.63,136.99 97.79,138.15 100.5,138.15 101.24,137.4 105.09,137.4 105.97,136.52 107.64,136.52 108.24,137.12 108.34,137.21 120.41,137.21 121.14,137.94 144.3,137.94 144.63,137.62 146.15,137.62 146.79,136.97 146.79,135.96 147.89,134.86 149.72,134.86 150.63,133.95 150.63,132.91 150.3,132.58 150.3,131.23 149.79,130.72 149.79,121.29 146.25,117.75 145.65,117.75 144.47,116.56 144.47,112.8 142.84,111.17 138.52,111.17 v3(138.33,111.36)
  IN4 w0.058: 90.32,36.53 88.6,38.25 86.71,38.25 79.59,45.36 79.59,49.2 79.93,49.54 79.93,57.42 79.38,57.97 79.38,64.65 70.9,73.13 70.9,75.31 70.63,75.58 70.63,79.04 68.95,80.73 68.95,82.15 68.35,82.75 68.35,87.98 68.06,88.27 68.06,92.89 67.73,93.21 67.73,97.52 64.5,100.75 64.5,109.47 66.12,111.08 66.12,112.82 67.37,114.07 69.68,114.07 v6(70.47,114.86)
  IN4 w0.089: 90.32,36.53 90.82,36.03 93,36.03 94.31,34.72 v5(95.22,34.72)
PM_SLP_S3#: length 187.7
  TOP w0.081: v8(85.24,26.29) v2(85.72,26.29) 87.68,26.29 87.76,26.37 v1(87.76,26.44) 87.76,26.62 86.37,28.01 86.37,29.27 86.12,29.52 83.52,29.52 83.44,29.6 83.44,30.44 83.25,30.63 Q8.2 ; v5(21.62,7.01) 21.77,7.16 21.77,8.83 21.16,9.44 PQB18.2 ; v8(81.53,4.24) 81.69,4.4 85.03,4.4 85.77,5.13 85.77,6.46 84,8.23 83.59,8.23 83.29,8.54 RE679.1
  TOP w0.122: v1(112.81,23.48) 113.99,24.66 113.99,24.84 113.61,25.22 113.61,25.41 113.26,25.76 UH1.BF42
  IN1 w0.058: 113.61,22.69 113.82,22.48 113.82,20.4 v6(113.41,19.99) ; v8(85.24,26.29) 85.24,21.92 81.97,18.65 v11(80.77,18.65) ; v8(81.53,4.24) 81.34,4.44 77.75,4.44 v11(77.72,4.41) v11(73.15,4.41)
  IN1 w0.089: v1(112.81,23.48) 113.61,22.69
  GND2 w0.081: v12(80.52,19.01) 80.52,18.77 80.64,18.65 v11(80.77,18.65) ; v11(77.72,4.41) v12(77.72,4.66) ; v1(87.76,26.44) 87.76,26.37 87.83,26.3 v12(87.83,26.13) ; v12(73.15,4.73) v11(73.15,4.41)
  GND2 w0.089: v1(112.81,23.48) 113.16,23.14 113.16,22.89 113,22.74 v12(112.52,22.74)
  IN2 w0.058: v12(87.83,26.13) 87.83,24.31 90.68,21.47 91.57,21.47 95.82,17.21 v3(95.82,17.05) ; v12(77.72,4.66) 77.72,5.44 77.04,6.12 77.04,8.23 77.65,8.84 78.39,8.84 78.74,9.2 78.74,9.58 79.73,10.57 ; v3(98.23,17.49) 98.23,17.85 100.13,19.74 101.52,19.74 103.14,18.12 104.45,18.12 105.59,19.26 109.17,19.26 109.72,19.81 109.72,21.49 109.29,21.92 109.29,22.69 ; v3(73.32,5.75) 73.25,5.68 73.25,5.53 73.15,5.43 v12(73.15,4.73) ; v12(80.52,19.01) 80.52,18.44
  IN2 w0.076: 79.73,10.57 80.09,10.93 80.09,11.68 79.18,12.59 79.18,13.85 80.11,14.77 80.11,15.85 80.52,16.26 80.52,18.44
  IN2 w0.089: v12(112.52,22.74) 112.42,22.74 112.06,23.09 112.06,25.3 111.63,25.73 110.54,25.73 109.29,24.48 109.29,22.69
  IN3 w0.058: v3(73.32,5.75) 73.15,5.58 69.25,5.58 69.16,5.49 58.58,5.49 58.47,5.59 54.95,5.59 50.98,9.56 39.74,9.56 39.46,9.28 32.7,9.28 30.61,7.19 27.03,7.19 26.01,8.21 22.21,8.21 21.62,7.61 v5(21.62,7.01) ; v3(95.82,17.05) 96.16,16.71 96.6,16.71 97.04,17.16 97.9,17.16 v3(98.23,17.49)
  IN4 w0.058: v7(131.82,15.47) 131.39,15.9 118.96,15.9 117.46,17.4 116.08,17.4 113.49,19.99 v6(113.41,19.99)
  BOTTOM w0.081: QE1.5 v7(131.82,15.47)
PM_SLP_S3_H: length 6.5
  TOP w0.081: R307.2 85.08,30.63 Q8.5 Q8.6 84.25,31.28 84.01,31.52 84.01,32.99 Q7.5 Q7.2
PM_SLP_S3_R#: length 7.1
  TOP w0.081: v8(84.05,9.69) 84.05,9.64 83.88,9.48 RE679.2
  IN1 w0.076: v8(81.17,13.36) 81.17,13.35 81.43,13.08 81.43,12.02 80.9,11.49 80.9,11.28 81.9,10.28 83.35,10.28 83.94,9.69 84.05,9.69 v8(84.05,9.69)
PM_SLP_S4#: length 120.6
  TOP w0.081: RE680.1 73.76,13.05 v3(73.56,13.25)
  TOP w0.122: v1(112.78,23.07) v2(113.18,23.07) 113.88,23.07 114.65,23.83 114.65,24.5 113.83,25.33 113.83,25.82 113.29,26.35 UH1.BE42
  IN1 w0.058: v1(82.62,36.35) 83.79,36.35 86.69,39.25 v11(87.71,39.25)
  GND2 w0.081: v1(85.92,58.36) v12(85.91,58.36) ; v1(82.62,36.35) v3(82.62,36.36) ; v11(87.71,39.25) 87.71,39.36 v12(87.59,39.47)
  GND2 w0.089: v1(112.78,23.07) 112.57,23.27 v12(112.39,23.27)
  IN2 w0.058: 109.03,22.67 109.03,22.66 109.05,22.64 109.05,21.93 109.56,21.42 109.56,19.87 109.1,19.42 105.52,19.42 104.39,18.28 103.21,18.28 101.59,19.9 100.06,19.9 97.73,17.56 v3(97.73,17.49) ; v3(96.46,17.05) 96.34,17.05 91.59,21.8 90.75,21.8 88.02,24.53 88.02,25.95 88.09,26.02 88.09,26.23 88.02,26.3 88.02,27.65 89.15,28.78 89.15,37.56 88.25,38.46 87.92,38.46 87.55,38.83 87.55,39.43 v12(87.59,39.47) 87.4,39.66 87.4,43.58 85.23,45.75 85.23,50.86 87.64,53.26 87.64,56.63 v12(85.91,58.36)
  IN2 w0.089: 109.03,22.67 109.03,24.48 110.47,25.91 111.71,25.91 112.24,25.37 112.24,23.42 v12(112.39,23.27)
  IN3 w0.058: v3(97.73,17.49) 97.68,17.44 96.85,17.44 v3(96.46,17.05) ; v3(73.56,13.25) 73.83,13.52 73.83,15.31 73.45,15.68 73.45,16.24 72.76,16.93 72.76,19.4 74.75,21.39 78,21.39 78.71,22.1 79.83,22.1 83.72,25.99 83.72,35.26 v3(82.62,36.36)
PM_SLP_S4_H: length 4.2
  TOP w0.081: R325.2 86.03,34.96 86.03,36.14 85.83,36.35 v2(85.57,36.35) Q9.5 Q9.6
PM_SLP_S4_R#: length 3.4
  TOP w0.081: v8(75.46,12.96) 75.32,12.81 75.2,12.81 74.97,13.05 RE680.2
  IN1 w0.058: v8(75.46,12.96) 75.74,12.96 76.28,13.49 76.58,13.49
  IN1 w0.076: 76.58,13.49 77.29,13.49 v8(77.66,13.86)
PM_SLP_S5#: length 61.9
  TOP w0.081: v8(72.87,12.78) 72.82,12.73 70.82,12.73 69.67,11.58 QE4.5 69.25,11.58 v2(68.34,12.5)
  TOP w0.089: v5(113.19,28.37) 113.13,28.31 113.13,27.92 112.99,27.79 UH1.BC42
  IN1 w0.058: v8(72.87,12.78) 73.33,12.32 74.33,12.32 74.47,12.46 74.76,12.46 74.9,12.6 75.11,12.6 75.45,12.27 75.45,9.5 76.27,8.68 78.17,8.68 78.24,8.75 v1(79.88,8.75)
  GND2 w0.081: v1(79.88,8.75) v3(79.88,9.17)
  IN3 w0.058: 82.94,10.57 82.05,9.68 80.39,9.68 v3(79.88,9.17) ; 110.07,22.69 108.29,20.91 104.29,20.91 102.25,18.87 102.25,17.29 101.59,16.62 97.18,16.62 96.75,16.18 94.24,16.18 91.44,13.38 87.21,13.38 85.1,11.26 84.51,11.26 84.2,10.95
  IN3 w0.076: 84.2,10.95 83.32,10.95 82.94,10.57
  IN3 w0.089: v5(113.19,28.37) 113.19,28.19 113.03,28.03 113.03,26.82 112.55,26.35 112.1,26.35 110.66,24.9 110.66,23.8 110.93,23.52 110.93,23.14 110.48,22.69 110.07,22.69
PM_SLP_S5_R#: length 4
  TOP w0.081: UE5.F1 79.67,9.55 RE678.2 80.2,9.02 80.2,7.92 CE45.1
POK: length 137.5
  TOP w0.081: DE2.1 v5(74.23,8.61)
  TOP w0.203: PU501.4 54.07,25.38 53.78,25.38 v5(53.67,25.26)
  TOP w0.254: DE3.1 DE2.1 ; v5(62.5,28.9) PR304.2 62.5,28.2 63.04,27.65 63.82,27.65 63.99,27.48 PU301.7
  IN1 w0.254: v5(62.5,28.9) 59.22,28.9 56.45,26.13 54.53,26.13 v5(53.67,25.26)
  IN2 w0.058: v5(53.67,25.26) 53.84,25.43 58.27,25.43 60.55,23.15 60.55,16.73 58.51,14.7 58.51,9.24 v6(58.29,9.02)
  IN3 w0.058: v9(76.55,2.87) 76.24,3.18 70.24,3.18 70.13,3.06 65.36,3.06 64.79,2.49 49.64,2.49 49.15,2.98 48.62,3.51 46.6,3.51 44.75,5.36 44.27,5.68 44.15,5.77 43.47,6.04 42.76,6.18 40.41,6.18 38.94,4.71 31.92,4.71 31.06,3.85 28.34,3.85 28.33,3.85 24.89,3.85 22.88,1.85 20.38,1.85 20.29,1.93 15.09,1.93 14.56,2.46 10.33,2.46 v5(10.3,2.43)
  GND4 w0.081: v9(76.55,2.87) v4(77.08,2.87)
  IN4 w0.058: v6(58.29,9.02) 58.39,8.92 68.07,8.92 68.58,8.41 69.85,8.41 70.74,9.3 72.9,9.3 73.58,8.61 v5(74.23,8.61)
  BOTTOM w0.081: v5(74.23,8.61) 74.42,8.61 74.65,8.38 76.42,8.38 76.86,7.95 76.86,2.95 76.94,2.87 v4(77.08,2.87) ; v2(53.63,24.35) 53.63,25.22 v5(53.67,25.26)
  BOTTOM w0.254: PR304.2 v5(62.5,28.9)
POWER_LED: length 17.9
  TOP w0.081: v8(71.88,7.75) 71.81,7.83 71.81,9.4 71.53,9.68 70.14,9.68 69.34,10.48 QE4.6 68.47,10.93 v2(68.39,11.01) ; v8(80.89,6.82) 81.25,6.45 81.95,6.45 QE8.2
  IN1 w0.058: v8(71.88,7.75) 72.05,7.58 75.44,7.58 76.4,6.62 78.64,6.62 78.75,6.52 80.83,6.52 80.89,6.58 v8(80.89,6.82)
PROC_DETECT#: length 169.7
  TOP w0.081: RH519.1 142.06,109.66 v1(141.66,110.06)
  TOP w0.089: v5(112.39,35.14) 112.39,34.44 112.75,34.09 112.75,33.9 112.24,33.39 112.24,32.31 UH1.AP41
  GND2 w0.081: v12(141.45,110.26) v1(141.66,110.06)
  IN2 w0.058: v4(83.22,113.27) 85.52,115.57 99.85,115.57 100.89,116.62 114,116.62 115.16,115.46 125.45,115.46 126.09,116.1 127.81,116.1 128.47,115.44 137.25,115.44 140.29,112.4 140.29,111.28 141.3,110.26 v12(141.45,110.26)
  IN4 w0.058: v7(86.39,71.43) 85.48,70.52 85.48,54.13 88.7,50.9 88.7,49.01 89.71,47.99
  IN4 w0.089: 89.71,47.99 90.57,47.14 91.33,47.14 91.64,46.82 95.58,46.82 95.72,46.97 97.28,46.97 98.18,46.07 98.41,46.07 100.15,44.34 103.71,44.34 105.2,42.85 105.2,41.42 105.66,40.95 108.18,40.95 109.41,39.72 109.41,39.02 109.22,38.83 109.22,37.62 109.54,37.3 111.32,37.3 111.82,36.8 111.82,35.46 112.14,35.14 v5(112.39,35.14)
  BOTTOM w0.081: v7(86.39,71.43) 86.9,71.94 86.9,98.29 86.9,98.29 86.9,98.59 87.34,99.03 87.34,106.75 82.93,111.15 v2(82.93,112.98) v4(83.22,113.27)
PROC_SELECT#: length 6.9
  TOP w0.081: v2(140.04,81.89) 139.89,82.04 RE716.2 136.73,82.86 UC1.BN1
PROCHOT#_CHG: length 3.6
  TOP w0.081: v5(48.32,17.3) 48.32,16.68 48.62,16.39 v10(48.62,15.84)
  TOP w0.254: v5(48.32,17.3) 48.39,17.36 PRB17.2
  BOTTOM w0.203: PUB1.5 48.15,17.47 v5(48.32,17.3)
PROG_CHG: length 2.7
  BOTTOM w0.203: PUB1.9 46.71,15.28 46.92,15.06 47.25,15.06 v2(47.74,14.57) 47.88,14.43 47.88,13.69 PRB37.1
PROG_ISL95338_1: length 3.6
  BOTTOM w0.203: PUV3.27 57,28.31 57.21,28.09 58.66,28.09 PRV104.2
PS_ID: length 103.5
  TOP w0.081: PR4.2 11.15,21.77 v10(11.47,21.45)
  TOP w0.254: v5(12.67,22.62) PR3.1 PR4.2
  IN1 w0.058: v3(74.23,18.11) 76.58,18.11
  IN1 w0.076: 76.58,18.11 76.94,18.11 77.43,17.61 78.27,17.61 78.55,17.33 79.55,17.33 79.91,16.97 79.91,15.72 80.86,14.77 81.32,14.77 81.52,14.57 81.52,14.01 v8(81.67,13.86)
  IN3 w0.058: v3(74.23,18.11) 75.22,18.11 75.97,17.36 75.97,13.9 74.87,12.8 74.87,9.82 73.2,8.16 70.67,8.16 70.22,7.71 69.74,7.71 68.68,6.64 63.74,6.64 62.32,8.07 58.15,8.07 54.99,11.23 44.38,11.23 43.94,11.68 40.15,11.68 38.99,10.52 27.99,10.52 26.83,9.36 13.94,9.36 13.04,10.26 13.04,18.57 12.36,19.26 11.86,19.26 11.51,19.61 11.51,20.3 12.11,20.9 12.11,21.95 12.67,22.52 v5(12.67,22.62)
PSI_FBVDDQ: length 81.3
  TOP w0.081: v2(57.72,74.01) 58.09,74.37 RG1596.1 60.79,74.37 v8(62.18,72.99)
  TOP w0.254: PUW1.3 3.81,52.67 3.62,52.48 PRW24.2 v1(2.81,53.3)
  IN1 w0.254: v11(59.52,72.21) 60.3,72.99 v8(62.18,72.99)
  GND2 w0.254: v12(59.7,72.03) 59.69,72.03 59.69,72.04 v11(59.52,72.21) ; v12(3.05,53.49) 3,53.49 v1(2.81,53.3)
  IN2 w0.254: v12(59.7,72.03) 59.79,71.94 59.79,63.55 55.89,59.65 34.75,59.65 34.41,59.99 28.82,59.99 28.48,59.65 18.88,59.65 16.67,57.45 13.07,57.45 11.32,55.7 5.2,55.7 3.05,53.55 v12(3.05,53.49)
PSI_GPU: length 5.3
  TOP w0.203: PRV20.1 v5(72.99,33.14) v2(73.37,32.75) 73.57,32.56 PUV1.37
  BOTTOM w0.254: PRV26.2 73.47,32.65 v5(72.99,33.14) 72.38,33.14 PRV18.2
PSID: length 13.1
  TOP w0.081: v2(19.75,23.21) 19.62,23.21 18.8,24.03 PL13.1
  TOP w0.254: v5(18.03,24.23) PL13.1
  BOTTOM w0.254: v5(18.03,24.23) 17.21,25.05 10.67,25.05 10.41,24.79 10.41,23.68 9.86,23.12 PJPDC1.11
PSID-1: length 5.1
  TOP w0.254: PR9.2 18.35,28.46 v2(17.2,28.46) 15.83,28.46 PQ1.2 15.73,28.47 14.59,27.33 PR6.1
PSID-2: length 8
  TOP w0.254: PR8.2 8.57,26.19 9.28,26.9 PQ4.2 11.71,26.9 v2(13.13,28.32) 13.17,28.36 13.17,28.82 13.48,29.12 PQ1.1
PSID-3: length 5
  TOP w0.081: PQ4.3 12.55,24.97 v2(13.09,24.42)
  TOP w0.254: PQ4.3 10.2,24.49 PR4.1
PSID-4: length 10
  TOP w0.254: PR6.2 12.28,26.48 PQ4.1 13.36,25.94 14.1,26.67 16.7,26.67 PD1.3 18.07,26.89 v2(18.64,26.32) 18.8,26.16 PL13.2
PSYS_CHG: length 4.4
  BOTTOM w0.081: PRB23.2 v2(49.26,12.98)
  BOTTOM w0.203: PUB1.8 47.76,16.27 49.15,14.89 PRB33.1 PRB23.2
PTP_LID_CLOSE#: length 32.4
  TOP w0.081: JTP17.6 65.31,5.74 66.45,4.6 67.62,4.6 68.46,5.44 71.31,5.44 v2(71.62,5.13) 72.89,3.86 76.9,3.86 77.16,4.11 JTP15.3 77.16,5.92 77.25,6 v1(78.49,6)
  GND2 w0.081: v1(78.49,6) 78.57,6 v12(78.74,6.17)
  IN2 w0.058: v12(78.74,6.17) 78.74,6.34 79.51,7.11 79.51,8.29 81.2,9.98 81.2,10.57 ; 84.2,16.13 84.7,16.63 v3(84.7,17.21)
  IN2 w0.076: 84.2,16.13 83.29,15.22 83.29,13.57 81.2,11.48 81.2,10.57
  GND4 w0.081: v4(84.7,17.21) v3(84.7,17.21)
  BOTTOM w0.081: UE10.17 85.83,16.62 85.34,17.11 84.8,17.11 v4(84.7,17.21)
