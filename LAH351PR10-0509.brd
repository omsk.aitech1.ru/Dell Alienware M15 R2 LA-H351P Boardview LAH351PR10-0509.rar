# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+0.6V_DDR_VREFCA: length 69.3
  TOP w0.254: v8(119.19,57.81) 119.19,57.62 120.29,56.52 122.81,56.52 v2(123.1,56.23) 123.38,55.95 127.1,55.95 127.19,56.03 128.71,56.03 129.07,56.39 CD263.1 129.57,56.92 130.76,55.73 131.87,55.73 132.52,56.39 132.52,56.99 132.78,57.24 v5(132.78,57.79) ; v5(132.33,62.08) 132.66,62.08 132.83,62.25 UD3.M1
  TOP w0.305: CD316.1 121.54,63.72 122.03,63.23 122.03,62.56 122.34,62.25 UD4.M1
  TOP w0.356: v1(118.87,60.29) 118.81,60.35 118.81,61.94 119.38,62.51 120.14,62.51 121.07,63.44 CD316.1
  IN1 w0.254: v5(143.76,70.45) 144.36,69.85 144.36,67.97 142.62,66.23 142.62,63.65 142.87,63.4 v11(142.87,60.92) 143.24,60.55 143.24,58.06 142.17,56.99 141.87,56.99 133.58,56.99 v5(132.78,57.79)
  IN1 w0.356: v1(118.87,60.29) 118.87,60.23 118.55,59.91 118.55,58.89 118.94,58.51 118.94,58.07 v8(119.19,57.81)
  GND2 w0.254: v3(142.32,61) 142.8,61 v11(142.87,60.92)
  GND4 w0.254: v4(141.99,61) v3(142.32,61)
  BOTTOM w0.254: CD264.1 131.5,61.74 130.81,61.05 130.81,59.65 131,59.46 131,58.26 131.32,57.94 132.63,57.94 v5(132.78,57.79) ; RD161.2 142.88,72.17 RD162.1 RD160.2 143.76,70.45 v5(143.76,70.45)
  BOTTOM w0.305: UD2.M1 131.15,62.25 CD264.1 132.15,61.9 v5(132.33,62.08) ; UD1.M1 140.3,61.85 140.55,61.85 141.4,61 v4(141.99,61)
+0.6V_VREFCA: length 28.7
  TOP w0.081: v8(139.24,90.77) 139.24,91.43 v2(138.87,91.8)
  IN1 w0.381: v5(143.74,72.85) 144.08,73.19 144.08,75.78 141.15,78.72 141.15,83.87 139.24,85.78 v8(139.24,90.77) 137.2,92.81 v8(134.86,92.81)
  BOTTOM w0.381: v5(143.74,72.85) 142.24,72.85 141.91,72.52 RD161.1
+0.6VS: length 5.3
  TOP w0.254: CD296.1 v5(131.07,56.21)
  IN3 w0.254: v9(142.13,65.32) 143.15,64.29 v5(144.34,64.29)
  GND4 w0.254: v9(142.13,65.32) v4(141.88,65.56)
  BOTTOM w0.254: CD288.1 141.88,66.41 CD287.1 141.88,66.23 v4(141.88,65.56)
  vias: v5(92.94,64.04) v5(131.7,56.21) v5(140.08,55.91) v5(140.72,55.91) v5(144.34,63.65) v10(108.12,55.16)
+0.6VSP: length 0.8
  BOTTOM w0.508: PCM8.1 v5(144.72,50)
  vias: v2(145.44,50.04)
+0.9V_CIO: length 0.8
  BOTTOM w0.081: UT1.R9 v4(80.48,141.47) ; UT1.R8 v4(81.18,141.47)
  vias: v1(80.64,141.12)
+0.9V_DP: length 9.5
  TOP w0.254: v1(88.54,141.69) CT57.1
  GND2 w0.254: v12(88.14,141.69) v1(88.54,141.69)
  IN2 w0.254: v12(88.14,141.69) 86.51,141.69 86.13,141.3 83.55,141.3 82.89,140.64 82.58,140.64 82.48,140.55 v4(80.14,140.55)
  vias: v1(79.49,140.55) v1(80.14,143.15) v2(79.82,141.06) v3(79.49,140.55) v3(80.14,143.15) v4(79.49,140.55) v4(80.14,143.15)
+0.9V_LVR_OUT: length 0.4
  BOTTOM w0.081: UT1.H18 v4(77.15,144.81)
  vias: v1(80.14,144.45) v2(78.02,145.1) v3(80.14,144.45) v4(80.14,144.45)
+0.9V_PCIE: length 0.4
  TOP w0.081: v2(75.79,142.98) 75.9,142.88 76.17,142.88
  vias: v1(76.89,142.5) v1(78.84,142.5) v3(76.89,142.5) v3(77.54,142.5) v3(78.19,142.5) v3(78.84,142.5) v4(76.89,142.5) v4(77.54,142.5) v4(78.19,142.5) v4(78.84,142.5)
+0.9V_SVR:
  vias: v1(78.84,145.75) v1(79.49,145.75) v2(78.88,146.43) v3(78.84,145.75) v3(79.49,145.75) v4(78.19,145.1) v4(78.84,145.75) v4(78.84,145.1) v4(79.49,145.75) v4(79.49,145.1) v4(80.14,145.1)
+0.9V_USB: length 2.4
  TOP w0.081: v2(75.62,140.03) 75.86,139.79 CT77.1
  BOTTOM w0.081: UT1.R16 v4(77.79,141.51) ; UT1.R15 v4(78.49,141.51)
+1.0VS_VGA_PGOOD: length 49.4
  IN4 w0.254: v7(77.95,74.2) 78.23,74.2 79.76,75.72 79.76,79.68 80.68,80.61 80.68,85.27 78.52,87.43 78.52,92.34 73.85,97.02 v7(73.85,100.8)
  BOTTOM w0.254: v7(73.85,100.8) 73.6,101.05 73.6,101.13 72.89,101.84 PR1108.2 71.58,101.96 71.58,102.1 71.15,102.53 PU1101.7 ; v7(77.95,74.2) 77.53,73.78 77.53,72.86 v2(76.28,71.61) 75.27,70.6 75.27,69.38 74.43,68.54 73.21,68.54 72.77,68.1 72.77,65.94 73.34,65.37 v18(73.34,63.14)
+1.0VS_VGAP: length 7.6
  IN4 w0.254: v7(66.6,104.87) v7(66.6,111.58)
  BOTTOM w0.254: PC1111.1 v7(66.6,104.87)
  vias: v2(71.16,114.62)
+1.2V_DDR: length 91.3
  TOP w0.203: v3(101.77,88.04) v3(102.61,88.04)
  TOP w0.254: UD8.J8 102.8,64.66 v5(103.19,65.05) ; UD7.T9 114.54,59.05 v5(114.55,59.04) ; v5(139.95,57.88) 140.61,57.22 CD307.1 ; v14(123.1,66.25) 123.1,66.59 ; v3(110.15,88.04) v3(109.32,88.04) ; v5(113.88,92.24) 113.59,91.95 UC1.AE12 ; UC1.AY6 125.18,88.04 v5(124.84,87.7) 124.5,88.04 UC1.AW6 ; UD4.J1 v4(123.9,64.65) ; v5(96.67,64.65) v4(97.2,64.65) v4(98,64.65) ; v5(96.8,59.45) UD8.R1 ; v18(139.9,63.05) 139.91,63.05 140.3,63.45 v5(140.3,64.25) v4(139.9,64.65) v4(139.1,64.65) ; CD390.1 131.07,59.05 v5(130.43,59.05) 129.51,59.05 UD4.T9 ; v5(129.92,65.05) 129.9,65.05 v1(129.5,64.65) v4(128.7,64.65) ; UD8.J9 v5(104.12,64.65) ; v1(103.6,59.05) 104.36,59.05 104.75,58.66 CD346.1 ; v5(102.93,91.72) 102.71,91.95 UC1.L12 UC1.K12 ; v4(103.6,68.65) 103.59,68.65 v5(103.19,69.05) ; v4(133.5,64.65) v4(134.3,64.65) ; v3(101.77,88.04) UC1.J6 100.87,88.04 100.53,87.7 100.85,87.39 UC1.J5 ; UC1.AP7 121.05,88.44 UC1.AP6 UC1.AR6 121.89,87.93 122.14,87.67 v5(122.33,87.67) ; UD8.G9 v5(104.14,66.25) ; v4(97.2,63.05) v5(96.84,63.41)
  TOP w0.305: CD311.1 121.17,59.11 v1(122.2,59.11) 122.94,59.85 UD4.R1 ; v3(105.96,88.04) v3(106.8,88.04)
  TOP w0.356: v5(118.05,60.23) 117.82,60 RD202.1 ; CD381.1 99.93,73 v5(99.93,72.63) ; 105.09,65.94 v5(105.03,65.94) 105.04,65.93 CD355.1 ; v5(96.8,59.45) 95.69,58.34 CD360.1
  TOP w0.381: UC2.5 139.25,48.97 v6(139.2,48.92)
  GND2 w0.254: v1(108.4,67.05) 108.4,67.08 v3(108.08,67.4) ; v18(129.5,68.65) 129.5,68.65 v3(129.16,68.99) ; v18(129.5,71.05) 129.5,71.06 v3(129.16,71.4) ; v1(102,66.25) 102,66.3 v3(101.66,66.64) ; v1(97.2,69.45) 97.2,69.45 v3(96.84,69.81) ; v3(128.27,65.05) 128.67,64.65 v4(128.7,64.65) ; v1(112.4,66.25) 112.4,66.25 v3(112.08,66.58) ; v1(114,66.25) 113.99,66.25 v3(113.67,66.58) ; v3(112.84,67.4) 113.19,67.05 v18(113.2,67.05) ; v1(139.9,59.05) 139.9,59.22 v3(140.22,59.53) ; v3(108.01,68.23) 108.39,67.85 v1(108.4,67.85) ; v3(96.84,68.99) 97.18,68.65 v18(97.2,68.65) ; v1(129.5,70.25) 129.48,70.25 v3(129.16,70.58) ; v18(107.6,66.25) 107.6,66.29 v3(107.25,66.64) ; v1(107.6,64.65) 107.6,64.7 v3(107.95,65.05) 108.35,64.65 v1(108.4,64.65) ; v1(129.5,64.65) 129.52,64.65 v5(129.92,65.05) ; v1(109.2,70.25) 109.2,70.28 v3(108.84,70.64) ; v1(103.6,59.05) 103.6,59.05 v3(104.01,59.46) ; v1(142.53,59.59) v3(142.05,59.59) ; v3(112.05,68.2) 112.39,67.85 v1(112.4,67.85) ; v3(133.1,60.23) 133.47,59.85 v1(133.5,59.85) ; v1(102.8,67.05) 102.8,67.09 v3(102.49,67.4) ; v4(139.1,67.05) 139.1,67.05 v3(138.78,67.37) ; v1(114,64.65) 114,64.65 v3(113.6,65.05) ; v1(102,67.85) 102,67.89 v3(101.66,68.23) ; v18(103.6,71.05) 103.6,71.05 v3(103.19,71.47) ; v1(123.1,63.05) v3(122.59,63.05) ; v3(107.19,69.05) 107.59,68.65 v18(107.6,68.65) ; v1(122.2,59.11) v3(122.2,58.6) ; v1(114,68.65) 114,68.65 v3(113.6,69.05) ; v4(133.5,68.65) 133.5,68.65 v3(133.16,68.99) ; v1(131.5,71.3) v3(131.06,71.3) ; v1(107.6,59.85) 107.6,59.88 v3(107.25,60.23) ; v4(98,67.05) 98,67.06 v3(97.6,67.46) ; v1(138.3,66.26) v3(137.99,66.58) ; v3(127.57,66.58) 127.9,66.25 v1(127.9,66.25) ; v1(103.6,70.25) 103.58,70.25 v3(103.19,70.64) ; v3(139.57,71.4) 139.9,71.07 v18(139.9,71.05) ; v1(105.6,72.65) 105.6,72.67 v3(105.22,73.05) ; v3(96.84,71.4) 97.19,71.05 v18(97.2,71.05) ; v3(98.49,70.58) 98.8,70.27 v1(98.8,70.25) ; v3(129.16,66.58) 129.48,66.25 v4(129.5,66.25) ; v3(112.84,64.99) 113.18,64.65 v1(113.2,64.65) ; v3(139.57,70.58) 139.9,70.25 v1(139.9,70.25)
  GND4 w0.254: v3(134.75,68.23) 135.1,67.87 v4(135.1,67.85) ; v4(139.9,66.25) 139.9,66.25 v3(139.57,66.58) ; v4(129.5,66.25) 129.48,66.25 v3(129.16,66.58) ; v3(128.27,65.05) 128.67,64.65 v4(128.7,64.65) ; v3(133.1,66.64) 133.49,66.25 v4(133.5,66.25) ; v4(98,64.65) 98,64.65 v3(97.6,65.05) ; v3(133.92,65.05) 133.52,64.65 v4(133.5,64.65) ; v4(139.1,67.05) 139.1,67.05 v3(138.78,67.37) ; v4(97.2,63.05) v5(96.84,63.41) ; v3(128.33,67.4) 128.68,67.05 v4(128.7,67.05) ; v4(98,67.05) 98,67.06 v3(97.6,67.46) ; v3(98.42,66.64) 98.8,66.26 v4(98.8,66.25) ; v3(137.92,70.64) 138.3,70.26 v4(138.3,70.25) ; v3(134.68,64.99) 134.34,64.65 v4(134.3,64.65) ; v4(97.2,64.65) v5(96.67,64.65) ; v5(108.84,66.7) 109.2,66.34 v4(109.2,66.25) ; v4(135.1,66.25) 135.1,66.35 v3(134.81,66.64) ; v4(133.5,59.05) 133.45,59.05 v3(133.1,59.4) ; v4(134.3,67.05) 134.3,67.09 v3(133.99,67.4) ; v4(131.5,64.91) v3(131.06,64.91) ; v4(139.1,64.65) 139.1,64.7 v3(138.75,65.05) ; v3(139.57,64.99) 139.9,64.66 v4(139.9,64.65) ; v4(139.9,59.85) v3(140.22,59.53)
  IN4 w0.254: v6(139.2,48.92) 141.35,51.07 141.35,56.54 140.02,57.88 v5(139.95,57.88)
  BOTTOM w0.254: UD8.J9 v5(104.12,64.65) 104.14,64.67 ; v5(129.92,65.05) 129.52,64.65 v1(129.5,64.65) ; v1(114,64.65) v1(113.2,64.65) ; UD8.G9 v5(104.14,66.25) ; UD7.L9 114.4,63.45 ; v5(108.84,66.7) 108.49,67.05 v1(108.4,67.05) ; v5(132.91,64.67) 132.93,64.65 v4(133.5,64.65) ; UD8.J8 102.8,64.66 v5(103.19,65.05) ; v4(97.2,64.65) v4(98,64.65) ; UD6.T9 v5(96.8,59.45)
  BOTTOM w0.508: v5(101.7,74.03) 101.82,73.92 CD353.1 ; v5(109.47,72.61) 109.3,72.78 CD340.1 ; v5(127.22,73.5) 127.13,73.41 CD298.1 ; v5(99.93,72.63) 99.84,72.72 CD358.1 ; v5(97.28,72.74) 97.05,72.96 CD357.1 ; CD278.1 123.79,73.91 123.95,74.07
  vias: v1(91.76,85.44) v1(92.27,85.44) v1(92.27,84.93) v1(92.77,85.44) v1(109.82,91.95) v1(122.62,91.95) v1(123.19,90.96) v1(123.19,90.39) v1(124.7,70.25) v1(143.36,65.04) v3(91.76,85.44) v3(92.27,85.44) v3(92.27,84.93) v3(92.77,85.44) v3(109.82,91.95) v3(122.62,91.95) v3(123.19,90.96) v3(123.19,90.39) v3(143.32,65.04) v4(91.76,85.44) v4(92.27,85.44) v4(92.27,84.93) v4(92.77,85.44) v4(95.05,67.13) v4(95.06,65.38) v4(102,70.25) v4(112.4,70.25) v4(123.9,67.05) v4(124.7,67.85) v4(124.7,66.25) v4(127.9,70.25) v5(100.01,66.51) v5(100.01,65.88) v5(101.86,78.4) v5(102.04,76.93) v5(102.04,76.29) v5(110.17,66.32) v5(110.17,65.69) v5(111.12,70.77) v5(111.12,70.13) v5(126.24,69.94) v5(126.24,69.31) v5(126.81,66.32) v5(135.92,72.77) v5(136.59,69.81) v5(136.59,69.18) v5(136.78,66.51) v5(136.78,65.88) v5(141.22,64.86) v5(143.51,74.83) v5(143.51,74.26) v5(143.51,73.69) v5(143.57,72.29) v5(143.57,71.72) v5(143.57,71.15) v5(143.57,69.83) v5(143.57,69.26) v5(143.57,68.68) v5(143.57,68.11) v10(118.88,80.65) v14(97.2,66.25) v14(98,67.85) v14(107.6,71.05) v14(107.6,69.45) v14(114,71.05) v14(114,70.25) v14(116.01,72) v14(116.01,70.73) v14(116.07,66.32) v14(116.08,65.04) v14(121.02,68.89) v14(120.97,68.14) v14(123.1,71.05) v14(123.1,69.45) v14(123.1,68.65) v14(123.9,67.85) v14(123.9,67.05) v14(127.9,67.85) v14(133.5,71.05) v14(133.5,69.45) v14(134.3,67.85) v14(135.1,70.25) v14(138.3,67.85) v14(139.9,68.65) v18(97.2,70.25) v18(97.2,66.25) v18(98.8,67.85) v18(103.6,69.45) v18(103.6,63.05) v18(103.6,59.85) v18(107.6,71.05) v18(107.6,70.25) v18(109.2,67.85) v18(113.2,67.85) v18(116.07,72.4) v18(116.08,69.42) v18(116.07,67.3) v18(117.02,65.74) v18(117.85,62.81) v18(128.7,67.85) v18(129.5,69.45) v18(133.5,71.05) v18(133.5,70.25) v18(139.1,67.85) v18(139.9,69.45) v18(139.9,68.65)
+1.2V_VCCPLL_OC: length 7.9
  TOP w0.254: UC1.BJ13 132.31,92.49 v5(132.26,92.44) 131.93,92.44 UC1.BH13
  TOP w0.305: v5(100.41,91.07) 100.09,91.41 UC1.G11
  BOTTOM w0.508: v5(132.26,92.44) 133,93.18 v10(134.07,93.18) 136.14,93.18 136.95,93.99 v5(137.92,93.99)
  vias: v1(91.95,81.69) v1(91.95,81.18) v1(91.95,80.67) v1(92.52,81.18) v1(92.52,80.67) v3(91.95,81.69) v3(91.95,81.18) v3(91.95,80.67) v3(92.52,81.18) v3(92.52,80.67)
+1.2VP: length 39.7
  TOP w0.203: PUM1.5 144.35,46.48 144.15,46.27 PRM14.2
  TOP w0.254: PRM14.2 144.18,45.49 145.66,45.49 v8(145.71,45.54)
  IN1 w0.254: v5(146.18,65.31) 146.18,63.99 144.45,62.26 144.45,54.69 143.99,54.23 143.99,51.4 145.48,49.91 145.48,45.77 v8(145.71,45.54)
  IN1 w0.762: 146.43,51.72 146.28,51.87 145.39,51.87 144.62,52.64 144.62,53.72 145.16,54.26 145.16,61.5 147.52,63.86
  vias: v5(146.09,50.52) v5(146.09,49.95) v5(146.18,66.13) v5(148.53,64.54) v5(148.53,63.91) v5(149.29,64.54) v5(149.29,63.91) v5(149.99,64.54) v5(149.99,63.91) v10(150.77,64.26)
+1.8V_PRIM: length 16.8
  TOP w0.254: UH1.AN15 v5(99.88,31.9) ; UH1.BB11 v5(97.39,28) ; UH1.AR15 v5(99.88,30.81)
  GND2 w0.254: v1(108.06,32.41) v12(108.06,32.78)
  IN2 w0.254: v12(108.06,32.78) 107.76,33.07 101.64,33.07 v5(100.94,32.37)
  BOTTOM w0.508: v5(102.13,35.62) 101.92,35.41 RH598.2 ; 98.62,32.54 96.98,32.54 96.18,31.74 96.18,31.64 94.6,30.07 RH595.2 ; RH599.1 v5(98.03,29.25)
  vias: v5(98.84,35.04) v5(99.09,31.93) v5(99.24,35.67) v5(99.22,34.28) v5(99.86,34.28) v5(100,35.67) v5(100.01,32.92) v10(98.63,33.47)
+1.8V_RUN: length 16.5
  TOP w0.081: v5(12.26,7.65) v2(11.88,7.27)
  IN2 w0.508: v3(70.5,6.54) 70.71,6.76 v5(70.71,8.69) v5(71.3,8.69)
  IN3 w0.508: v5(12.26,7.65) 12.26,8.35 11.3,9.3 11.3,9.81 9.65,11.46 9.65,12.85 9.14,13.36 6.41,13.36 5.26,14.52 v9(5.26,15.9)
  GND4 w0.508: v9(5.26,15.9) v4(5.26,16.26)
+1.8V_RUN_PWR: length 15.5
  IN1 w0.254: v4(80.25,5.36) 79.9,5.01 72.14,5.01 71.59,5.55 67.73,5.55 67.18,6.1 v3(67.18,7.9)
  vias: v2(67.02,8.46)
+1.8VA_TBTA_LDO: length 2.7
  BOTTOM w0.203: UT4.K1 93.22,143.59
  BOTTOM w0.508: 93.22,143.59 92.58,144.24 CT100.1
+1.8VALW: length 378
  TOP w0.254: RH518.2 110.44,20.91 v4(110.11,20.58) ; UX2.5 126.61,140.9 125.68,140.9 v8(124.87,140.08) 124.87,138.76 CV1056.1
  TOP w0.356: CV20.1 123.44,139.23 UX1.5
  TOP w0.381: v8(70.71,115.42) 65.56,115.42 v3(65.29,115.15)
  TOP w0.508: CV20.1 CV1056.1 ; v5(87.07,31.02) 87.17,30.91 87.17,28.35 88.06,27.46 RH603.1 v1(88.95,26.63) RH181.1
  IN1 w0.381: v8(70.71,115.42) 70.62,115.51 70.62,121.67 70.57,121.72 70.57,121.72 69.89,122.4 69.89,122.4 69.8,122.49 67.87,122.49 63.27,127.09 63.27,131.94 66.26,134.93 66.26,135.38 66.26,135.5 66.98,136.22 66.98,139.83 67.87,140.72 68.66,140.72 70.4,142.46 70.4,142.79 72.42,144.81 74.78,144.81 75.21,144.38 77.72,144.38 79.98,142.12 81.69,142.12 81.87,142.29 82.75,142.29 83.03,142.01 84.01,142.01 84.26,142.27 85.03,142.27 85.34,141.95 87.38,141.95 89.83,144.4 91.05,144.4 91.3,144.65 92.86,144.65 95.02,142.48 101,142.48 101.36,142.84 102.84,142.84 104.95,140.73 120.08,140.73 120.73,140.08 v8(124.87,140.08)
  GND2 w0.254: v1(81.67,19.78) v3(81.67,21.03) ; v1(88.95,26.63) v3(88.56,26.63) ; v12(81.47,13.17) v1(81.17,12.86)
  GND2 w0.508: v1(1.89,52.48) v3(1.89,52.1)
  IN2 w0.254: v3(88.56,26.63) 88.56,24.72 90.82,22.46 91.54,22.46 95.58,18.42 v6(96.32,18.42) ; v3(14.15,9.86) 14,9.86 12.57,11.28 12.57,15.39 11.99,15.98 11.75,15.98 11.52,16.21 10.62,16.21 10.25,16.58 10.25,22.37 10.62,22.73 10.62,27.47 12.28,29.14 v3(13,29.14) ; v3(81.67,21.03) 81.99,20.72 81.99,17.17 82.23,16.93 82.23,16.19 81.64,15.59 81.64,15.27 81.3,14.93 81.3,14.13 81.61,13.82 81.61,13.31 v12(81.47,13.17)
  IN3 w0.254: v3(13,29.14) 13.74,29.87 13.74,36.91 11.73,38.92 11.73,40.47 10.46,41.73 5.59,41.73 3.33,44 3.33,47.81 1.89,49.24 v3(1.89,52.1) ; v9(73.89,16.69) 73.22,17.36 73.22,18.82 75.28,20.88 78.41,20.88 79.21,21.68 80.01,21.68 80.06,21.74 80.61,21.74 81.32,21.03 v3(81.67,21.03) 81.81,21.17 84.1,21.17 88.56,25.63 v3(88.56,26.63) 90.82,26.63 94.96,30.77 v5(96.18,30.77) ; v3(14.15,9.86) 17.21,9.86 18.83,11.48 21.39,11.48 22.61,10.26 26.84,10.26 27.77,11.19 38.29,11.19 39.56,12.46 49.62,12.46 50.23,11.85 55.8,11.85 56.55,11.1 58.19,11.1 58.45,10.85 58.45,10.29 59.66,9.07 62.46,9.07 62.97,8.56 64.39,8.56
  IN3 w0.381: v3(65.29,115.15) 66.61,113.83 66.61,102.17 67.61,101.17 69.8,101.17 71.37,99.6 71.37,97.34 68.45,94.41 v5(68.45,93.31)
  GND4 w0.254: v9(68.33,15.9) 68.33,15.6 v6(68.38,15.55) ; v4(69.04,35.87) 69.09,35.92 v9(69.09,36.35) ; v6(73.53,16.69) v9(73.89,16.69)
  IN4 w0.254: v6(96.32,18.42) 99.82,18.42 100.1,18.7 102.29,18.7 103.15,17.83 104.2,17.83 105.59,19.22 105.59,20.14 106.16,20.71 106.52,20.71 108.28,18.95 109.17,18.95 110.11,19.89 v4(110.11,20.58) ; v6(68.38,15.55) 68.55,15.73 71.26,15.73 71.4,15.86 72.5,15.86 73.33,16.69 v6(73.53,16.69)
  IN4 w0.508: v5(78.02,7.71) 76.86,7.71 76.65,7.51 72.87,7.51 72.2,6.83 66.98,6.83
  BOTTOM w0.254: UZ45.2 78.27,8.21 78.02,7.96 v5(78.02,7.71) UZ45.1 ; v4(69.04,35.87) 71.48,35.87 72.07,35.27 72.07,34.78 71.45,34.15 PRV18.1 ; RH111.2 107.74,25.28 108.08,24.95 108.08,22.99 110.11,20.96 v4(110.11,20.58)
  BOTTOM w0.356: RG1615.1 85.09,44.67 85.79,43.97 86.17,43.97 86.75,43.39 RH1039.2
  BOTTOM w0.381: 87.3,39.02 RG1616.1 87.3,37.29 ; RH599.2 96.18,29.56 v5(96.18,30.77)
  BOTTOM w0.508: RH1039.2 88.76,42.78 89.76,41.77 89.76,40.58 88.87,39.69 RH1040.2 87.97,39.69 v10(87.34,39.05) 87.3,39.02 ; v5(87.07,31.02) 85.45,32.64 85.45,36.01 86.5,37.06 87.07,37.06 87.3,37.29
  vias: v5(65.27,7.89) v5(65.27,7.32) v5(65.84,7.89) v5(65.84,7.32) v5(66.41,7.89) v5(66.41,7.32) v5(69.02,93.18) v5(69.02,92.61) v5(69.02,92.04) v5(69.02,91.4)
+1.8VD_TBTA_LDO: length 3.1
  BOTTOM w0.081: v2(95.68,137.19) 95.68,137.03 95.6,136.95 CT99.1
  BOTTOM w0.203: UT4.A2 94.55,138.26 CT99.1
+1.8VSP: length 12.4
  TOP w0.203: PR1816.1 50.83,1.98 PC1819.1
  TOP w0.254: PC1819.1 51.68,1.42 v2(54.42,1.42) 55.21,1.42 55.88,2.1 55.88,2.94 57.66,4.71 PC1808.1
+1.35VS_VGA: length 358.2
  TOP w0.254: v1(39.52,133.87) UG11.H13 ; UG14.F11 v4(12.62,127.17) ; UG11.K13 v4(38.77,133.12) ; 23.53,71.43 23.53,76 v3(27.43,79.9) ; UG14.C11 v4(14.87,127.17) ; UG16.J13 v4(10.37,90.76) ; v4(8.13,124.92) UG14.K13 UG14.J13 ; UG11.E1 v3(30.16,136.36) ; UG11.H2 v1(29.78,133.87) ; RG1491.1 48.3,77.14 49.15,76.29 49.15,75.35 v4(48.58,74.77) ; CG6529.1 42.91,136.19 v5(43.05,136.04) ; RG1492.1 v4(30.59,77.01) ; UG17.J2 v4(54.57,69.52) ; CG6528.1 42.91,134.99 v5(43.05,134.84) ; UG15.J2 v4(9.62,73.68) ; UG17.P5 52.32,72.37 v4(52.63,72.06) ; v4(58.18,135.22) 58.84,135.22 59.1,135.48 v1(59.63,135.48) 60.01,135.48 60.33,135.79 60.33,137 59.95,137.37 v3(59.63,137.37) 60.18,137.92 60.18,138.38 59.84,138.72 CG6586.1 ; CG516.1 58.76,134.58 v4(58.18,134) ; v4(36.92,74.02) v4(36.17,74.77) ; v5(43.05,137.25) 42.91,137.4 CG6530.1 ; UG12.K13 v4(48.13,132.38) ; UG17.J13 v4(46.33,69.52) ; UG15.J13 v4(8.13,81.92) ; UG13.K2 v4(9.97,107.52)
  IN1 w0.254: v1(8.88,107.84) v4(8.13,107.84) ; v1(47.38,131.63) v4(48.13,131.63) ; 57.19,62.94 61.19,62.94 63.04,61.09 71.65,61.09 v8(72.16,61.6)
  GND2 w0.203: v3(29.91,94.71) 29.57,95.05 v1(29.55,95.05) ; v3(29.91,94.71) 29.55,94.35 v1(29.55,94.35) ; v3(29.91,94.71) 30.25,95.05 v1(30.25,95.05) ; v1(36.55,112.55) 36.55,112.51 v3(36.89,112.17) ; v3(43.18,112.17) 42.85,112.5 v1(42.85,112.55) ; v3(43.18,112.17) 43.5,111.85 v1(43.55,111.85) ; v3(43.18,112.17) 43.55,112.54 v1(43.55,112.55) ; v3(43.18,112.17) 42.86,111.85 v1(42.85,111.85) ; v1(30.25,100.65) 30.25,100.64 v3(29.91,100.29) 29.55,100.65 v1(29.55,100.65) ; v1(40.75,89.45) 40.78,89.45 v3(41.15,89.82) ; v1(32.35,111.85) 32.38,111.85 v3(32.7,112.17) ; v1(42.85,90.15) 42.91,90.15 v3(43.24,89.82) ; v1(41.45,90.15) 41.45,90.12 v3(41.15,89.82) ; v1(33.05,112.55) 33.05,112.52 v3(32.7,112.17) ; v3(36.89,112.17) 36.57,111.85 v1(36.55,111.85) ; v3(36.89,112.17) 37.21,111.85 v1(37.25,111.85) ; v3(36.89,112.17) 37.25,112.52 v1(37.25,112.55) ; v1(43.55,90.15) 43.55,90.12 v3(43.24,89.82) ; v1(30.25,96.45) 30.25,96.46 v3(29.91,96.8) ; v3(34.8,112.17) 35.12,111.85 v1(35.15,111.85) ; v3(34.8,112.17) 35.15,112.52 v1(35.15,112.55) ; v3(34.8,112.17) 34.45,112.52 v1(34.45,112.55) ; v3(34.02,89.97) 34.27,89.97 v1(34.45,90.15) ; v3(45.28,112.17) 44.96,111.85 v1(44.95,111.85) ; v3(45.28,112.17) 44.95,112.5 v1(44.95,112.55) ; v3(45.28,112.17) 45.65,112.54 v1(45.65,112.55) ; v1(33.05,111.85) 33.02,111.85 v3(32.7,112.17) ; v3(32.7,112.17) 32.35,112.52 v1(32.35,112.55) ; v1(40.75,112.55) 40.75,112.5 v3(41.08,112.17) ; v1(41.45,112.55) 41.45,112.53 v3(41.08,112.17) ; v1(30.25,99.25) 30.19,99.25 v3(29.9,99.54) 29.61,99.25 v1(29.55,99.25) ; v1(29.55,96.45) 29.56,96.45 v3(29.91,96.8) ; v3(29.91,96.8) 29.56,97.15 v1(29.55,97.15) ; v3(29.91,96.8) 30.25,97.14 v1(30.25,97.15) ; v1(29.55,101.35) 29.55,101.29 v3(29.84,100.99) 29.89,100.99 v1(30.25,101.35) ; v3(41.08,112.17) 41.4,111.85 v1(41.45,111.85) ; v3(42.52,89.1) 42.52,89.12 v1(42.85,89.45) v3(43.17,89.13) 43.19,89.13 43.19,89.15 43.49,89.45 v1(43.55,89.45) 43.55,89.51 v3(43.24,89.82) ; v1(38.65,112.55) 38.65,112.51 v3(38.99,112.17) ; v3(47.43,112.17) 47.12,111.85 v1(47.05,111.85) ; v3(47.43,112.17) 47.75,112.48 v1(47.75,112.55) ; v3(47.43,112.17) 47.05,112.55 v1(47.05,112.55) ; v1(39.35,112.55) 39.35,112.53 v3(38.99,112.17) ; v3(29.84,103.15) 29.55,103.45 v1(29.55,103.45) ; v1(30.25,98.55) 30.19,98.55 v3(29.84,98.9) 29.55,98.6 v1(29.55,98.55) ; v3(41.15,89.82) 41.45,89.52 v1(41.45,89.45) ; v1(38.65,111.85) 38.67,111.85 v3(38.99,112.17) ; v3(38.99,112.17) 39.31,111.85 v1(39.35,111.85)
  GND2 w0.254: v3(30.29,108.04) 30.25,108 v1(30.25,107.65) ; v1(58.8,123.04) 58.8,123.47 v3(58.93,123.6) ; v1(29.55,92.95) v3(29.92,92.59) ; v3(29.92,92.59) v1(29.55,92.25) ; v3(29.92,92.59) v1(30.25,92.25) ; v3(29.92,92.59) v1(30.25,92.95) ; v1(29.55,109.75) 29.6,109.75 v3(29.91,109.44) 29.55,109.08 v1(29.55,109.05) ; v1(51.93,123.36) v3(51.63,123.06) ; v1(2.33,121.58) v3(2.33,121.12) ; v3(59.56,123.6) 59.63,123.54 v1(59.63,123.04) ; v3(30.29,110.14) 30.25,110.1 v1(30.25,109.75) ; v1(33.05,89.45) 32.7,89.8 v3(32.7,89.82) 33.03,90.15 v1(33.05,90.15) ; v3(29.91,105.18) 29.55,105.54 v1(29.55,105.55) ; v3(29.91,105.18) 29.57,104.85 v1(29.55,104.85) ; v3(29.91,105.18) 30.25,105.52 v1(30.25,105.55) ; v3(29.91,105.18) 30.24,104.85 v1(30.25,104.85) ; v3(29.91,107.28) 29.58,106.95 v1(29.55,106.95) ; v3(29.91,107.28) 29.55,107.64 v1(29.55,107.65) ; v3(29.91,107.28) 30.24,106.95 v1(30.25,106.95) ; v12(4.19,48.54) v1(4.75,48.54) ; v3(38.99,89.82) 38.66,90.15 v1(38.65,90.15) ; v3(38.99,89.82) 39.35,89.46 v1(39.35,89.45) ; v3(38.99,89.82) 39.32,90.15 v1(39.35,90.15) ; v3(38.99,89.82) 38.65,89.48 v1(38.65,89.45) ; v1(30.95,112.55) v3(30.95,112.2) ; v1(3.58,121.58) v3(3.58,121.12) ; v3(35.15,89.45) v3(34.45,89.45) 34.02,89.88 v3(34.02,89.97) ; v1(3.53,104.58) v3(3.53,104.23) ; v1(2.33,104.59) v3(2.33,104.23) ; v3(36.96,89.75) 37.25,90.05 v1(37.25,90.15) ; v3(36.96,89.75) 36.56,90.15 v1(36.55,90.15) ; v3(36.96,89.75) 37.25,89.46 v1(37.25,89.45) ; v3(36.96,89.75) 36.65,89.45 v1(36.55,89.45) ; v1(26.86,137.91) 27.13,137.91 v3(27.26,138.03) ; v1(6.09,121.58) v3(6.09,121.12) ; v1(26.86,138.72) v3(27.23,138.72) ; v3(26.61,136.7) 26.92,136.7 v1(26.95,136.67) ; v1(30.95,89.45) 31.11,89.62 v3(31.11,89.82) ; v3(29.78,133.46) v1(29.78,133.87) ; v1(4.78,121.58) v3(4.78,121.08) ; v1(29.55,102.75) 29.55,102.86 v3(29.84,103.15) ; v1(32.35,90.15) 32.34,90.15 v3(32,89.82) 32,89.8 v1(32.35,89.45) ; v1(39.52,133.87) 39.31,133.66 v4(39.05,133.66) ; v3(29.55,111.56) v1(29.55,111.15) ; v1(21.83,79.78) v3(21.83,79.33) ; v1(3.51,136.41) v3(3.11,136.41) ; v1(5.03,136.41) v3(4.59,136.41) ; v1(17.76,81.26) v3(18.23,81.26)
  IN2 w0.254: v12(4.19,48.54) 3.96,48.54 1.46,51.04 1.46,68.62 2.5,69.66 5.09,69.66 5.47,70.04 18.24,70.04 18.49,69.79 v5(19.68,69.79)
  GND4 w0.203: v4(38.38,90.26) 38.38,89.85 38.37,89.83 v3(38.37,89.82) ; v3(38.99,89.82) 38.96,89.85 v4(38.96,90.26) ; v4(41.75,90.26) v3(41.75,89.82) ; v4(42.32,90.29) 42.32,89.85 v3(42.33,89.84) ; v3(41.15,89.82) 41.18,89.85 v4(41.18,90.26) ; v4(42.89,90.29) 42.89,90.17 v3(43.24,89.82) ; v4(36.67,90.26) 36.67,90.04 v3(36.96,89.75) 37.24,90.04 v4(37.24,90.26) ; v3(43.18,112.17) 42.93,111.92 v4(42.89,111.92)
  GND4 w0.254: v4(30.05,90.23) 30.05,90.12 v3(30.34,89.83) 30.63,90.11 v4(30.63,90.23) ; v4(5,72.37) v3(5.46,72.37) ; v4(30.63,102.07) 30.54,102.07 v3(30.23,102.39) 30.54,102.71 v4(30.63,102.71) ; v4(7.85,78) v3(7.37,78) ; v4(44.73,111.92) 44.44,111.92 v3(44.26,112.11) 44.07,111.91 v4(43.81,111.91) ; v3(29.92,92.59) 29.54,92.96 v4(29.46,92.96) ; v4(34.51,66.85) 34.72,66.64 v3(35.31,66.64) 35.43,66.77 v4(35.43,67.24) ; v4(32.34,90.23) 32.34,90.15 v3(32,89.82) 31.77,90.05 v4(31.77,90.23) ; v3(7.24,111.03) 7.33,110.94 v4(7.85,110.94) ; v4(4.35,104.69) 4.43,104.69 v3(4.76,104.36) ; v4(5.32,119.12) v3(4.89,119.12) ; v4(28.45,127.49) 28.85,127.09 v3(29.14,127.09) 29.14,127.37 v4(29.02,127.49) ; v4(30.63,105.25) 29.97,105.25 v3(29.91,105.18) ; v4(29.57,99.55) 29.89,99.55 v3(29.9,99.54) ; v4(4.25,122.33) v3(4.25,122.77) ; v4(3.13,85.49) 3.13,85.9 v3(3.17,85.94) ; v3(30.23,106.01) 30.35,105.88 v4(30.63,105.88) ; v3(42.55,112.17) 42.32,111.95 v4(42.32,111.92) ; v4(30.63,108.42) 30.29,108.08 v3(30.29,108.04) 30.54,107.79 v4(30.63,107.79) ; v4(33.3,66.85) v3(32.75,66.85) ; 29.68,94.93 v3(29.91,94.71) ; 29.68,94.93 29.46,95.16 v4(29.46,95.5) ; 29.68,94.93 v4(29.46,94.93) ; v4(30.63,109.69) 30.63,109.73 30.29,110.07 v3(30.29,110.14) 30.48,110.33 v4(30.63,110.33) ; v4(13.18,118.38) 13.54,118.38 v3(13.65,118.26) ; v3(16.13,118.26) 16.01,118.38 v4(15.63,118.38) ; v3(36.89,112.17) 36.61,111.88 v4(36.61,111.8) ; v4(7.85,79.23) v3(8.32,79.23) ; v4(25.12,60.36) v3(25.12,60.71) ; v4(32.29,111.8) 32.29,111.88 v3(32,112.17) 31.72,111.88 v4(31.72,111.8) ; v4(29.46,97.34) 29.46,97.32 29.91,96.87 v3(29.91,96.8) 29.88,96.77 v4(29.46,96.77) ; v4(39.3,111.7) 39.3,111.86 v3(38.99,112.17) ; v4(33.24,89.4) 33.12,89.4 v3(32.7,89.82) ; v3(38.35,112.17) 38.41,112.11 v4(38.41,111.73) ; v4(29.57,98.28) 29.57,98.62 v3(29.84,98.9) ; v4(7.85,76.78) v3(7.37,76.78) ; v4(8,102.59) v3(8,102.96) ; v4(29.46,96.14) 29.88,96.14 v3(29.91,96.17) ; v4(23.89,60.36) v3(23.89,60.73) ; v4(7.85,96.31) v3(7.43,96.31) ; v4(30.45,111.8) 30.85,112.2 v3(30.95,112.2) 31.15,112 v4(31.15,111.8) ; v4(5.56,85.48) v3(5.91,85.13) ; v4(37.81,90.26) v3(37.81,89.88) ; v4(41.75,111.92) 41.33,111.92 v3(41.08,112.17) ; v4(30.63,106.52) v3(30.23,106.52) 30.23,106.75 v4(30.63,107.15) ; v4(3.13,102.57) v3(3.13,102.98) ; v4(11.87,112.15) v3(12.38,112.15) ; v4(5.56,102.56) v3(5.56,102.97) ; v4(7.85,113.39) 7.67,113.39 v3(7.43,113.63) ; v4(22.67,60.36) v3(22.67,60.73) ; v4(31.2,90.23) 31.2,89.9 v3(31.11,89.82) ; v4(7.85,112.16) v3(7.3,112.16) ; v4(3.15,122.34) v3(3.15,122.77) ; v3(7.43,93.12) 7.43,93.44 v4(7.85,93.86) ; v4(4.35,85.48) 4.15,85.48 v3(3.81,85.82) ; v4(9.24,102.59) v3(9.24,102.99) ; v4(30.63,104.61) 30.46,104.61 v3(30.25,104.41) ; v4(2.57,72.38) 2.57,72.35 v3(3,71.92) 3.43,72.36 3.44,72.36 3.45,72.37 v4(3.79,72.37) ; v4(11.87,95.07) v3(12.32,95.07) ; v4(6.79,102.59) v3(6.79,102.95) ; v4(7.85,95.08) v3(7.37,95.08) ; v4(11.87,77.99) v3(12.38,77.99) ; v3(14.99,118.26) 14.87,118.38 v4(14.41,118.38) ; v4(35.46,111.8) 35.46,111.82 v3(35.75,112.11) 36.04,111.82 v4(36.04,111.8)
  BOTTOM w0.254: CG6789.1 39.56,72.14 v4(39.17,72.52) 39.45,72.8 CG6780.1 ; v4(29.43,70.27) 29.29,70.41 CG6772.1 ; CG6683.1 6.09,76.14 v4(5.88,75.93) 5.77,75.82 CG6675.1 ; v4(6.63,109.34) 6.83,109.54 CG6624.1 ; CG6787.1 29.32,64.38 v4(29.43,64.28) 29.44,64.29 29.59,64.29 29.78,64.48 CG6785.1 ; v4(31.68,66.53) 31.69,66.54 CG6765.1 ; RG155.1 44.54,72.02 CG6731.1 45.54,72.56 v4(45.58,72.52) 45.87,72.23 CG792.1 ; v4(12.62,116.83) 12.68,116.89 CG6621.1 ; CG6702.1 12.66,92.97 v4(12.62,93.01) ; v4(15.62,90.01) 15.54,89.92 CG6715.1 ; v4(29.43,68.03) 29.41,68.01 CG6788.1 ; v4(37.27,135.37) 37.34,135.31 CG6548.1 ; CG6769.1 36.83,66.62 v4(36.92,66.53) ; CG6607.1 4.38,107.08 v4(4.38,107.09) ; CG684.2 5.91,82.64 v4(5.88,82.67) ; CG6566.1 47.51,129.24 v4(47.38,129.38) ; CG6686.1 11.53,74.83 v4(11.87,75.18) ; v4(2.88,82.67) 2.95,82.74 CG6695.1 ; v4(10.37,72.93) 10.49,72.81 CG6677.1 ; v4(55.32,65.78) 55.39,65.84 CG6754.1 ; CG6763.1 38.12,68.33 v4(38.42,68.03) 38.1,67.71 CG6777.1 ; v4(5.88,99.75) 6.18,100.06 CG780.1 ; v4(45.58,62.78) 45.55,62.76 CG6758.1 ; CG783.1 11.64,92.02 v4(11.87,92.26) 11.54,92.59 CG6717.1 ; CG6723.1 5.99,89.89 v4(5.88,90.01) ; CG6676.1 10.49,81.81 v4(10.37,81.92) ; CG6639.1 4.29,131.75 v4(4.38,131.66) ; CG6794.1 39.36,74.21 v4(39.17,74.02) ; CG6828.1 v4(41.75,111.92) ; v4(32.43,63.53) 32.45,63.55 CG6797.1 ; CG838.1 30.22,70.32 v4(30.18,70.27) ; v4(36.17,65.78) 36.12,65.73 CG6775.1 ; CG6796.1 31.92,71.53 v4(31.68,71.77) ; CG741.1 8.11,98.99 v4(8.13,99) ; CG6557.1 39.61,129.47 v4(39.52,129.38) ; CG774.1 8.92,90.81 v4(8.88,90.76) 8.98,90.65 CG6721.1 ; v4(4.38,126.42) 4.36,126.43 CG6632.1 ; v4(39.17,65.78) 39.38,65.98 CG6781.1 ; CG6623.1 CG6611.1 8.13,107.84 v4(8.13,107.84) ; v4(3.63,127.17) 3.71,127.25 CG6642.1 ; v4(57.12,126.38) 57.82,125.68 CG521.1 ; CG6600.1 8.04,107 v4(8.13,107.09) ; v4(15.62,124.17) 15.65,124.2 CG6645.1 ; v4(54.57,70.27) 54.23,70.62 CG6728.1 ; v4(15.62,99.75) 15.68,99.7 CG777.1 ; v4(30.18,69.52) 30.27,69.43 CG6791.1 ; CG6643.1 3.07,123.97 v4(2.88,124.17) ; CG6599.1 3.38,109.84 v4(3.63,110.09) ; v4(14.12,72.93) 14.16,72.89 CG6691.1 ; v4(4.38,97.5) 4.41,97.48 CG6716.1 ; CG6681.1 8,73.8 v4(8.13,73.68) 7.82,73.37 CG6690.1 ; CG6671.1 14.77,79.57 v4(14.87,79.67) ; CG6682.1 14.03,80.33 v4(14.12,80.42) ; CG6687.1 5.93,79.62 v4(5.88,79.67) ; CG6593.1 55.57,126.07 55.94,125.69 v4(57.12,125.69) ; CG6609.1 14.03,114.49 v4(14.12,114.58) ; v4(2.88,90.01) 2.95,89.94 CG6703.1 ; CG6753.1 48.61,63.49 v4(48.58,63.53) ; v4(6.63,114.58) 6.69,114.65 CG6602.1 ; CG6790.1 30.42,68.27 v4(30.18,68.03) ; CG779.1 14.25,99.88 v4(14.12,99.75) ; v4(8.13,133.16) 8.26,133.03 CG6637.1 ; v4(10.37,124.92) 10.65,125.19 CG6644.1 ; v4(9.62,99) 9.91,98.72 CG6720.1 ; v4(39.52,137.62) 39.9,138 v4(40.58,138) ; v4(5.88,127.17) 6.02,127.31 CG6631.1 ; v4(45.58,74.02) 45.52,74.08 CG6735.1 ; CG6705.1 5.74,92.87 v4(5.88,93.01) ; CG6786.1 29.35,62.85 v4(29.43,62.78) ; CG6755.1 46,67.7 v4(46.33,68.03) ; CG6606.1 10.49,116.95 v4(10.37,116.83) ; CG6527.1 39.47,126.32 v4(39.52,126.38) ; CG6583.1 47.82,131.32 v4(48.13,131.63) 48.42,131.33 CG6563.1 ; CG6608.1 14.17,116.88 v4(14.12,116.83) ; v4(12.62,130.91) 12.7,130.99 CG6638.1 ; CG782.1 8.04,99.84 v4(8.13,99.75) ; v4(53.07,66.53) 53.02,66.58 CG6748.1 ; v4(6.63,126.42) 6.65,126.39 CG6630.1 ; v4(11.87,131.66) 12.18,131.36 CG646.1 CG640.2 10.97,130.01 CG644.1 CG641.2 ; v4(3.63,130.91) 3.64,130.9 CG6665.1 ; CG6559.1 49.42,129.92 v4(49.63,130.13) ; v4(4.38,75.18) 4.44,75.24 CG6669.1 ; CG6540.1 v4(40.01,126.01) ; v4(54.12,138.37) 53.82,138.07 CG549.2 ; v4(8.13,124.92) 7.85,125.19 CG6656.1 ; CG6724.1 3.71,93.09 v4(3.63,93.01) ; CG6756.1 46.29,70.31 v4(46.33,70.27) ; v4(14.12,75.18) 14.15,75.15 CG6685.1 ; v4(55.32,72.52) 55.45,72.65 CG6751.1 ; v4(45.58,64.28) 45.5,64.2 CG6742.1 ; CG6591.1 57.75,128.75 v4(57.12,129.38) 57.04,129.29 CG6573.1 ; CG6709.1 14.86,96.77 v4(14.87,96.75) ; CG6592.1 57.46,127.54 v4(57.12,127.88) ; CG6750.1 45.5,70.35 v4(45.58,70.27) ; v4(8.13,116.08) 8.08,116.04 CG578.2 ; v4(58.18,135.22) v4(58.18,134) ; v4(39.52,139.12) 40.39,139.12 v4(40.56,139.3) ; v4(36.17,72.52) 36.28,72.63 CG6792.1 ; CG6594.1 12.7,113.91 v4(12.62,113.83) ; v4(56.37,131.63) 56.13,131.39 CG6577.1 ; CG6727.1 CG6752.1 55.46,70.41 v4(55.32,70.27) ; v4(29.78,127.88) 29.82,127.83 CG6536.1 ; v4(5.88,96.75) 5.74,96.89 CG6714.1 ; CG6627.1 14.12,109.34 v4(14.12,109.34) ; v4(10.37,124.17) 10.5,124.04 CG6658.1 ; CG6661.1 8.84,133.12 v4(8.88,133.16) ; CG6730.1 45.53,65.73 v4(45.58,65.78) ; CG6537.1 36.26,136.61 36.17,136.53 v4(36.17,136.49) ; CG784.1 8.57,98.7 v4(8.88,99) ; CG791.1 47.12,61.52 v4(46.91,61.32) ; v4(10.37,82.67) 10.76,82.29 CG6667.1 ; v4(8.13,82.67) 7.66,82.21 CG6696.1 ; v4(29.43,65.78) 29.3,65.9 CG6774.1 ; CG6718.1 10.71,91.09 v4(10.37,90.76) ; v4(39.17,62.78) 39.25,62.85 CG6767.1 ; v4(12.62,133.91) 12.73,133.81 CG6662.1 ; CG6749.1 52.63,72.89 v4(52.63,72.06) ; v4(12.62,124.17) 12.73,124.27 CG6657.1 ; CG6764.1 38.34,70.2 v4(38.42,70.27) ; v4(9.62,116.08) 9.65,116.06 CG6614.1 ; v4(54.57,68.03) 54.24,67.69 CG6740.1 ; CG6565.1 46.86,134.39 v4(47.38,133.87) ; CG6581.1 47.94,134.06 v4(48.13,133.87) ; CG6680.1 3.35,73.4 v4(2.88,72.93) ; v4(3.63,79.67) 3.85,79.9 CG6689.1 ; v4(38.42,69.52) 38.14,69.24 CG841.1 ; v4(12.62,90.01) 12.49,89.88 CG6710.1 ; v4(47.83,66.53) 47.84,66.54 CG6760.1 ; CG6570.1 CG6578.1 55.05,135.19 v4(54.87,135.37) ; CG6589.1 56.16,134.09 v4(56.37,133.87) ; v4(10.37,73.68) 10.22,73.83 CG6674.1 ; CG6706.1 12.32,100.06 v4(12.62,99.75) ; CG6649.1 10.72,133.5 v4(10.37,133.16) ; CG6778.1 39.24,67.96 v4(39.17,68.03) ; CG6560.1 50.49,127.24 v4(50.38,127.13) ; CG6678.1 9.21,74.09 v4(9.62,73.68) ; v4(54.12,136.12) 54.19,136.19 CG6582.1 ; CG6574.1 54.71,129.12 54.46,129.38 v4(54.12,129.38) ; CG6545.1 29.87,129.47 v4(29.78,129.38) ; CG6713.1 13.01,97.14 v4(12.62,96.75) ; CG6795.1 39.25,70.35 v4(39.17,70.27) ; CG6693.1 12.38,79.43 v4(12.62,79.67) ; v4(14.87,93.01) 14.77,93.11 CG6722.1 ; v4(38.73,136.03) 39.43,136.03 v4(39.52,136.12) ; CG6743.1 53.31,73.78 v4(53.07,74.02) ; CG6761.1 46.76,69.96 v4(46.33,69.52) ; v4(55.32,74.02) 55.49,73.85 CG6739.1 ; v4(32.03,127.88) 32.09,127.94 CG6538.1 ; v4(8.13,72.93) 8.1,72.9 CG6673.1 ; v4(5.88,110.09) 5.84,110.05 CG6597.1 ; v4(12.62,110.09) 12.59,110.05 CG6618.1 ; v4(14.87,110.09) 14.83,110.13 CG6604.1 ; v4(14.12,107.09) 14.07,107.03 CG6603.1 ; CG6524.1 36.6,129.3 v4(36.52,129.38) ; v4(2.88,99.75) 2.88,99.76 CG6725.1 ; CG6733.1 47.83,74.32 v4(47.83,74.02) ; CG6704.1 10.5,89.88 v4(10.37,90.01) ; CG6759.1 v4(52.32,65.78) ; CG6711.1 13.76,97.14 v4(14.12,97.5) ; CG6651.1 6.05,130.74 v4(5.88,130.91) 5.8,130.99 CG6659.1 ; v4(4.38,109.34) 4.5,109.46 CG6596.1 ; CG6650.1 14.03,131.57 v4(14.12,131.66) ; CG6663.1 14.12,133.91 v4(14.12,133.91) ; CG6668.1 11.6,80.15 v4(11.87,80.42) ; v4(2.88,116.83) 2.95,116.9 CG6617.1 ; CG6783.1 29.51,72.61 v4(29.43,72.52) 29.29,72.39 CG6771.1 ; v4(5.88,124.17) 5.99,124.05 CG6655.1 ; v4(6.63,75.18) 6.83,75.38 CG6670.1 ; CG6729.1 45.5,67.95 v4(45.58,68.03) 45.91,68.36 CG796.1 ; CG6522.1 39.46,127.94 v4(39.52,127.88) 39.65,128.01 CG6523.1 ; CG772.1 6.97,91.91 v4(6.63,92.26) ; v4(2.88,107.09) 2.8,107.01 CG6610.1 ; CG6664.1 15.74,133.8 v4(15.62,133.91) ; v4(52.32,74.77) 52.29,74.74 CG6747.1 ; CG771.1 11.62,97.12 11.87,97.37 v4(11.87,97.5) 11.62,97.75 CG773.1 ; CG6738.1 55.64,62.78 v4(55.32,62.78) 55.22,62.67 CG6732.1 ; v4(57.12,136.12) 57.44,136.44 CG520.1 ; CG6654.1 4.41,124.14 v4(4.38,124.17) ; v4(54.87,137.62) 54.78,137.52 CG6584.1 ; v4(32.43,74.77) 32.65,74.55 CG6779.1 ; CG6562.1 50.66,138.66 v4(50.38,138.37) ; v4(6.63,80.42) 6.86,80.19 CG6700.1 ; CG6652.1 14.87,127.56 v4(14.87,127.17) 14.87,126.75 CG6641.1 ; v4(14.12,124.17) 14.25,124.29 CG6646.1 ; CG6601.1 5.74,113.97 v4(5.88,113.83) ; v4(39.05,133.66) 39.05,133.4 v4(38.77,133.12) ; v4(50.38,129.38) 50.44,129.31 CG6561.1 ; CG6568.1 47.31,127.94 v4(47.38,127.88) ; CG6625.1 15.6,107.06 v4(15.62,107.09) ; v4(47.83,71.77) 48.22,71.38 CG6757.1 ; v4(57.12,131.63) 56.71,131.21 CG6576.1 ; CG6741.1 52.17,63.68 v4(52.32,63.53) ; CG6762.1 38.67,75.02 v4(39.17,75.52) ; CG785.2 53.66,64.86 v4(53.07,64.28) 53.09,64.26 CG6736.1 ; v4(54.12,127.13) 54,127 CG6575.1 ; v4(4.38,72.93) 4.38,73.39 CG6672.1 ; CG6585.1 CG6579.1 50.27,136.23 v4(50.38,136.12) ; v4(29.43,75.52) 29.41,75.5 CG6770.1 ; v4(14.12,90.01) 14.11,89.99 CG6712.1 ; CG6707.1 4.53,89.85 v4(4.38,90.01) ; CG6569.1 47.27,126.48 v4(47.38,126.38) ; v4(37.27,130.13) 37.05,130.35 v4(37.05,130.58) ; CG6784.1 29.26,73.85 v4(29.43,74.02) 29.53,73.92 CG6773.1 ; v4(14.87,130.91) 14.3,130.34 CG643.2 CG649.1 ; CG6684.1 4.47,82.77 v4(4.38,82.67) 4.83,82.22 CG680.1 ; v4(54.87,127.88) 54.71,128.04 CG6572.1 ; v4(29.78,126.38) 29.74,126.34 CG6547.1 ; CG6766.1 39.29,64.39 v4(39.17,64.28) ; v4(9.62,81.92) 9.78,81.77 CG6692.1 ; CG6666.1 12.56,72.86 v4(12.62,72.93) 12.61,72.94 CG6699.1 ; v4(3.63,96.75) 3.64,96.74 CG768.1 ; CG6793.1 31.94,64.01 v4(31.68,64.28) ; CG6698.1 8.13,81.92 v4(8.13,81.92) ; v4(54.87,130.13) 54.64,130.36 CG6571.1 ; CG6719.1 10.55,99.93 v4(10.37,99.75) ; CG6595.1 15.66,116.87 v4(15.62,116.83) ; CG6708.1 4.33,92.2 v4(4.38,92.26) ; CG576.2 4.83,116.38 v4(4.38,116.83) 4.47,116.93 CG6620.1 ; CG6737.1 53.02,71.72 v4(53.07,71.77) ; CG6697.1 15.71,73.01 v4(15.62,72.93) 15.47,72.77 CG6688.1 ; CG6648.1 6.94,131.98 v4(6.63,131.66) 6.88,131.41 CG6660.1 7.08,131.4 CG6640.1 ; v4(55.32,64.28) 55.44,64.39 CG6726.1 ; v4(8.88,116.08) 9.06,115.89 CG6619.1 ; CG6653.1 12.52,127.07 v4(12.62,127.17) ; v4(36.17,74.77) 36.14,74.74 CG6776.1 ; CG738.1 4.84,99.29 v4(4.38,99.75) 4.47,99.85 CG776.1 ; v4(8.13,116.83) 8.04,116.92 CG6622.1 ; CG6580.1 49.66,135.34 v4(49.63,135.37) ; CG6744.1 47.84,64.29 v4(47.83,64.28) ; v4(36.17,63.53) 36.07,63.43 CG6768.1 ; v4(36.52,136.12) 36.35,135.95 CG6549.1 ; v4(36.1,90.26) v4(36.67,90.26) ; CG6626.1 10.5,106.96 v4(10.37,107.09) ; v4(8.13,124.17) 7.98,124.02 CG6633.1 ; CG6745.1 48.67,74.68 v4(48.58,74.77) ; CG6612.1 12.55,107.01 v4(12.62,107.09) ; CG6544.1 33.18,126.77 v4(32.8,127.15)
  BOTTOM w0.305: v4(5.88,116.83) 5.8,116.91 CG6605.1
  vias: v1(2.88,133.91) v1(3.63,113.83) v1(3.63,75.93) v1(4.38,133.91) v1(4.38,114.58) v1(4.38,80.42) v1(5.88,133.91) v1(5.88,107.09) v1(5.88,72.93) v1(6.05,129.44) v1(6.05,128.22) v1(6.63,97.5) v1(8.13,133.91) v1(8.13,90.76) v1(8.13,90.01) v1(9.62,133.16) v1(10.37,133.91) v1(10.37,116.08) v1(10.37,107.84) v1(10.37,99) v1(11.87,114.58) v1(11.87,109.34) v1(11.93,85.18) v1(12.15,122.94) v1(12.62,82.67) v1(12.62,75.93) v1(13.26,85.18) v1(13.4,122.94) v1(14.12,92.26) v1(14.12,82.67) v1(14.79,85.18) v1(14.87,113.83) v1(14.87,75.93) v1(15.62,82.67) v1(17.72,112.88) v1(17.7,96) v1(17.75,125.81) v1(19.86,105.06) v1(19.86,103.72) v1(21.78,123.1) v1(26.95,135.47) v1(26.86,123.1) v1(26.99,64.94) v1(26.98,63.72) v1(27.69,123.1) v1(27.69,64.62) v1(27.68,63.4) v1(27.68,62.19) v1(29.55,90.85) v1(29.53,90.26) v1(29.78,139.12) v1(29.78,137.62) v1(29.78,131.63) v1(30.25,103.45) v1(30.18,68.78) v1(30.53,133.12) v1(30.53,132.38) v1(30.53,131.63) v1(31.68,74.02) v1(32.03,137.62) v1(32.03,135.37) v1(32.03,130.13) v1(32.43,72.52) v1(32.43,65.78) v1(32.78,138.37) v1(32.78,136.12) v1(32.78,129.38) v1(36.52,138.37) v1(36.52,127.13) v1(36.92,71.77) v1(36.92,64.28) v1(37.27,137.62) v1(37.27,127.88) v1(38.24,124.29) v1(38.42,68.78) v1(38.77,131.63) v1(39.52,131.63) v1(42.32,138.72) v1(45.58,75.52) v1(46.91,61.75) v1(47.38,139.12) v1(47.38,137.62) v1(47.38,136.12) v1(48.17,61.75) v1(48.58,72.52) v1(48.58,65.78) v1(49.38,61.75) v1(49.63,137.62) v1(49.63,127.88) v1(50.6,61.75) v1(55.32,75.52) v1(55.32,68.03) v1(56.37,133.12) v1(56.37,132.38) v1(57.12,139.12) v1(57.12,137.62) v1(57.12,133.87) v3(2.88,133.91) v3(3.63,113.83) v3(3.63,75.93) v3(4.38,133.91) v3(4.38,114.58) v3(4.38,80.42) v3(5.88,133.91) v3(5.88,107.09) v3(5.88,72.93) v3(6.05,129.44) v3(6.05,128.22) v3(6.63,97.5) v3(8.13,133.91) v3(8.13,90.76) v3(8.13,90.01) v3(9.62,133.16) v3(10.37,133.91) v3(10.37,116.08) v3(10.37,107.84) v3(10.37,99) v3(11.87,114.58) v3(11.87,109.34) v3(11.93,85.18) v3(12.15,122.94) v3(12.62,82.67) v3(12.62,75.93) v3(13.26,85.18) v3(13.4,122.94) v3(14.12,92.26) v3(14.12,82.67) v3(14.79,85.18) v3(14.87,113.83) v3(14.87,75.93) v3(15.62,82.67) v3(17.72,112.88) v3(17.7,96) v3(17.75,125.81) v3(19.86,105.06) v3(19.86,103.72) v3(21.78,123.1) v3(26.69,128.99) v3(26.69,127.38) v3(26.69,125.9) v3(26.86,135.49) v3(26.86,123.1) v3(26.99,64.94) v3(26.98,63.72) v3(27.69,123.1) v3(27.69,64.62) v3(27.68,63.4) v3(27.68,62.19) v3(29.55,90.85) v3(29.53,90.26) v3(29.78,139.12) v3(29.78,137.62) v3(29.78,131.63) v3(30.18,68.78) v3(30.53,133.12) v3(30.53,132.38) v3(30.53,131.63) v3(31.68,74.02) v3(32.03,137.62) v3(32.03,135.37) v3(32.03,130.13) v3(32.43,72.52) v3(32.43,65.78) v3(32.78,138.37) v3(32.78,136.12) v3(32.78,129.38) v3(36.52,138.37) v3(36.52,127.13) v3(36.92,71.77) v3(36.92,64.28) v3(37.27,137.62) v3(37.27,127.88) v3(38.24,124.29) v3(38.42,68.78) v3(38.77,131.63) v3(39.52,131.63) v3(40.58,136.67) v3(40.58,135.44) v3(41.97,125.76) v3(42.32,138.72) v3(42.75,64.87) v3(42.75,63.64) v3(42.75,62.42) v3(45.58,75.52) v3(46.32,139.48) v3(46.32,138.05) v3(46.32,136.57) v3(46.91,61.75) v3(47.14,139.79) v3(47.38,139.12) v3(47.38,137.62) v3(47.38,136.12) v3(48.17,61.75) v3(48.58,72.52) v3(48.58,65.78) v3(49.38,61.75) v3(49.45,69.5) v3(49.45,66.85) v3(49.63,137.62) v3(49.63,127.88) v3(50.6,61.75) v3(50.66,69.5) v3(50.66,66.85) v3(51.4,129.57) v3(51.4,128.81) v3(55.32,75.52) v3(55.32,68.03) v3(56.37,133.12) v3(56.37,132.38) v3(57.12,139.12) v3(57.12,137.62) v3(57.12,133.87) v3(57.99,130.51) v3(58.18,132.78) v3(58.18,131.52) v4(2.88,133.91) v4(3.63,113.83) v4(3.63,75.93) v4(4.38,133.91) v4(4.38,114.58) v4(4.38,80.42) v4(5.88,133.91) v4(5.88,107.09) v4(5.88,72.93) v4(6.05,129.44) v4(6.05,128.22) v4(6.63,97.5) v4(6.58,84.43) v4(8.13,133.91) v4(8.13,90.76) v4(8.13,90.01) v4(9.62,133.16) v4(10.37,133.91) v4(10.37,116.08) v4(10.37,107.84) v4(10.37,99) v4(11.87,114.58) v4(12.15,122.94) v4(12.62,82.67) v4(12.62,75.93) v4(13.4,122.94) v4(14.12,92.26) v4(14.12,82.67) v4(14.87,113.83) v4(14.87,75.93) v4(15.62,82.67) v4(19.86,105.06) v4(19.86,103.72) v4(26.69,128.99) v4(26.69,127.38) v4(26.69,125.9) v4(26.99,64.94) v4(26.98,63.72) v4(27.69,64.62) v4(27.68,63.4) v4(27.68,62.19) v4(29.55,90.85) v4(29.53,90.26) v4(29.78,131.63) v4(30.18,68.78) v4(30.53,133.12) v4(30.53,132.38) v4(30.53,131.63) v4(31.68,74.02) v4(32.03,135.37) v4(32.43,72.52) v4(32.43,65.78) v4(32.78,136.12) v4(35,136.98) v4(35.04,133.05) v4(35.53,136.18) v4(35.54,135.51) v4(35.61,133.05) v4(36.52,138.37) v4(36.52,127.13) v4(36.92,71.77) v4(36.92,64.28) v4(37.27,137.62) v4(37.27,127.88) v4(38.42,68.78) v4(38.77,131.63) v4(39.52,131.63) v4(40.4,133.69) v4(40.4,133.05) v4(40.58,136.67) v4(40.58,135.44) v4(40.58,131.52) v4(41.97,125.76) v4(42.75,64.87) v4(42.75,63.64) v4(42.75,62.42) v4(45.58,75.52) v4(46.32,139.48) v4(46.32,138.05) v4(46.32,136.57) v4(47.14,139.79) v4(47.38,139.12) v4(47.38,137.62) v4(47.38,136.12) v4(48.17,61.32) v4(48.58,72.52) v4(48.58,65.78) v4(49.38,61.32) v4(49.45,69.5) v4(49.45,66.85) v4(49.63,137.62) v4(49.63,127.88) v4(50.6,61.32) v4(50.66,69.5) v4(50.66,66.85) v4(51.4,129.57) v4(51.4,128.81) v4(55.32,75.52) v4(55.32,68.03) v4(56.37,133.12) v4(56.37,132.38) v4(57.12,139.12) v4(57.12,137.62) v4(57.12,133.87) v4(57.99,130.51) v4(58.18,132.78) v4(58.18,131.52) v5(19.35,70.46) v5(19.43,68.57) v5(19.43,67.93) v5(19.49,67.27) v5(19.49,66.64) v5(19.49,66.07) v5(19.49,65.43) v5(19.49,64.8) v5(19.49,64.16) v5(19.49,63.59) v5(19.49,62.96) v5(19.68,69.15) v5(19.96,70.42) v5(20.07,68.54) v5(20.07,67.91) v5(20.07,67.27) v5(20.07,66.64) v5(20.07,66) v5(20.07,65.37) v5(20.07,64.8) v5(20.07,64.16) v5(20.07,63.59) v5(20.07,62.96) v5(20.32,69.79) v5(20.32,69.15) v5(20.55,71.03) v5(20.55,70.4) v5(20.7,68.54) v5(20.7,67.91) v5(20.7,67.27) v5(20.7,66.64) v5(20.7,66) v5(20.7,65.37) v5(20.7,64.8) v5(20.7,64.16) v5(20.7,63.59) v5(20.7,62.96) v5(20.93,69.76) v5(20.93,69.13) v5(21.18,71.03) v5(21.18,70.4) v5(21.27,68.54) v5(21.27,67.91) v5(21.27,67.27) v5(21.27,66.64) v5(21.27,66) v5(21.27,65.37) v5(21.34,64.8) v5(21.34,64.16) v5(21.34,63.59) v5(21.34,62.96) v5(21.56,69.76) v5(21.56,69.13) v5(21.76,71.03) v5(21.76,70.4) v5(21.91,68.54) v5(21.91,67.91) v5(21.91,67.27) v5(21.91,66.64) v5(21.91,66) v5(21.91,65.37) v5(21.97,64.8) v5(21.97,64.16) v5(21.97,63.59) v5(21.97,62.96) v5(22.14,69.76) v5(22.14,69.13) v5(22.39,71.03) v5(22.39,70.4) v5(22.58,65.1) v5(22.58,64.47) v5(22.58,63.9) v5(22.58,63.26) v5(22.77,69.76) v5(22.77,69.13) v5(23.24,65.1) v5(23.24,64.47) v5(23.24,63.9) v5(23.24,63.26) v6(32.03,137.62) v6(32.78,138.37) v8(57.35,77.88) v10(43.18,121.07) v18(29.46,92.07)
+1.35VS_VGA_PGOOD: length 103.3
  TOP w0.081: UG29.1 65.9,93.3 66.17,93.56 v3(66.29,93.56)
  TOP w0.254: PUW1.1 4.32,53.47 3.66,54.13 v1(2.81,54.13)
  IN1 w0.058: v3(66.29,93.56) 66.37,93.48 67.78,93.48 68.07,93.78 69.99,93.78 v4(70.29,93.48)
  GND2 w0.081: v12(3.05,54.38) v1(2.81,54.13)
  IN2 w0.058: v3(59.31,69.93) 59.31,63.53 55.69,59.91 34.86,59.91 34.52,60.25 28.71,60.25 28.37,59.91 18.77,59.91 16.57,57.71 12.71,57.71 10.96,55.96 4.64,55.96 v12(3.05,54.38)
  IN3 w0.058: v3(66.29,93.56) 66.38,93.47 66.38,92.8 66.24,92.66 65.3,92.66 64.97,92.33 64.97,90.32 63.68,89.03 63.68,74.3 v3(59.31,69.93)
  BOTTOM w0.081: v2(68.97,94.35) 69.84,93.48 v4(70.29,93.48)
+1V8_AON: length 781.7
  TOP w0.254: v4(51.63,139.35) 51.4,139.12 UG12.V10 ; RG13.2 v8(100.97,20.45) ; v1(88.68,43.34) 88.68,43.53 88.2,44.01 86.71,44.01 84.16,46.56 v8(84.16,52.53) ; RV652.1 RV648.1 135.06,139.46 133.27,137.67 132.41,137.67 130.89,139.19 130.89,139.42 v1(130.48,139.83) 129.82,139.83 129.49,139.5 129.48,139.5 129.22,139.25 RX7.1 129.22,138.71 128.82,138.31 128.8,138.31 128.45,137.96 RX5.1 ; v8(82.84,42.62) 82.84,38.89 80.61,36.65 80.61,36.32 80.35,36.07 78.25,36.07 78.2,36.12 77.86,36.12 77.81,36.07 77.12,36.07 77.09,36.05 77.06,36.05 75.86,34.84 PRV53.1 PRV52.1 ; RG84.2 RG78.2 RG80.2 RG81.2 69.44,71.36 v6(70.09,70.7) ; UG17.V5 52.32,76.23 v4(52.26,76.29) ; UG11.A10 v8(36,139.12) ; v4(32.43,62.78) 33.33,61.88 44.45,61.88 44.7,62.13 48.32,62.13 48.58,62.38 v4(48.58,62.78)
  TOP w0.356: 3.99,3.19 3.99,3.75 ; 3.99,3.19 3.99,2.76 4.73,2.01 4.84,2.01 v10(4.85,2) 4.87,2.02 5.8,2.02 6.32,2.54 CG478.1 6.75,3.18 UG26.5 ; 3.99,3.19 CG7106.1 ; 3.99,3.75 CG7091.1 ; 3.99,3.75 3.94,3.8 UG47.5 ; RG8.2 RG524.2 RG526.2 RG16.2 ; RG27.2 58.45,76.07 v8(58.98,76.07) ; RG16.2 RG504.1 ; RG16.2 58.52,79.21 58.52,78.58 59.08,78.02 v8(60.06,78.02) 60.22,78.02 60.64,78.45 RG1497.2
  TOP w0.381: UG47.5 v8(3.94,6.29) ; RG523.2 64.87,86.58 65.25,86.96 v1(65.49,86.96) ; RG74.1 77.7,91.28 78.2,91.79 78.2,92.61 77.7,93.12 76.2,93.12 v5(75.92,93.4) 75.64,93.12 74.49,93.12
  IN1 w0.254: v4(79.55,55.81) 80.8,55.81 84.07,52.53 v8(84.16,52.53) ; v4(51.63,139.35) 51.85,139.12 v8(54.12,139.12) ; v8(60.06,78.02) 60.06,77.36 v8(60.07,77.35) ; v3(66.99,97.49) 66.54,97.94 66.07,97.94 65.89,97.77 65.24,97.77 65.06,97.94 64.54,97.94 64.2,97.6 v8(64.2,96.7) ; v4(36.17,62.78) 36.17,62.05 35.62,61.5 16.26,61.5 14.86,62.89 3.96,62.89 3.78,63.07 1.82,63.07 ; v8(100.97,20.45) 100.97,19.97 100.32,19.32 97.8,19.32 97.33,19.79 94.6,19.79 94.35,20.04 v1(94.35,20.22) ; v8(36,139.12) v3(32.78,139.12) 33.72,138.18 33.72,126.9 33.19,126.38 v3(32.78,126.38) ; v8(82.84,42.62) 87.97,42.62 v1(88.68,43.34)
  IN1 w0.305: 1.37,40.95 1.37,53.61 v8(1.89,54.13) 1.37,54.65 1.37,62.63
  IN1 w0.356: v8(58.98,76.07) 59.69,76.78 59.69,76.96 v8(60.07,77.35) 60.55,76.87 v1(62.77,76.87)
  IN1 w0.381: v4(15.62,130.91) 15.62,130.23 15.24,129.85 3.95,129.85 v1(2.88,130.91) ; 1.86,79.67 v4(2.88,79.67) 4.48,78.07 11.24,78.07 11.62,78.45 14.4,78.45 v4(15.62,79.67) ; 1.86,79.67 1.4,80.14 1.4,83.78 1.97,84.36 1.97,89.37 1.46,89.88 1.46,91.59 v1(2.88,93.01) ; 1.86,79.67 1.4,79.21 1.4,77.4 v3(2.88,75.93) 1.4,74.45 1.4,63.49 1.82,63.07 1.37,62.63 ; 1.37,40.95 3.89,38.43 3.89,35.13 5.21,33.81 5.21,33.24 4.06,32.1 4.06,30.25 5.4,28.92 5.4,27.97 5.02,27.59 4.66,27.59 3.54,26.47 3.54,24.03 3.33,23.82 3.33,21.47 3.87,20.92 3.87,18.43 2.98,17.54 2.98,14.32 2.73,14.06 2.73,8.31 3.23,7.81 3.23,7 v8(3.94,6.29)
  IN1 w0.508: v5(76.68,62.66) 75.58,61.56 v5(72.96,61.56) 71.96,60.56 62.42,60.56 61.05,61.93 60.25,61.93 59.66,61.34 v5(59.66,61.19) ; v3(76.66,68) 76.16,67.5 v5(73.29,67.5) ; v3(66.99,97.49) v11(68.33,96.15) 70.89,93.59 70.89,92.87 v3(70.89,92.86)
  GND2 w0.254: v3(50.29,88.43) 50.24,88.43 49.92,88.75 v1(49.85,88.75) ; v1(94.35,20.22) 94.35,20.23 v12(94.11,20.47) ; v1(88.68,43.34) 88.65,43.3 v12(88.65,43.02) ; v12(129.92,139.85) 130.45,139.85 v1(130.48,139.83) ; v1(52.65,92.25) 52.65,92.25 v3(52.3,91.91) ; v12(116.66,139.8) v3(116.29,140.17) ; v1(36.52,126.38) 36.52,126.25 v3(36.77,126.01) ; v1(51.95,92.25) v3(51.63,91.93)
  GND2 w0.381: v1(2.88,130.91) 2.88,130.77 v3(2.64,130.53) ; v3(2.54,126.84) 2.87,127.17 v1(2.88,127.17) ; v1(52.32,62.78) 52.32,62.75 v5(51.98,62.4) ; v3(65.15,86.72) 65.39,86.96 v1(65.49,86.96) ; v3(2.6,93.56) 2.88,93.29 v1(2.88,93.01)
  GND2 w0.508: v1(62.77,76.87) 62.77,77.1 v3(62.97,77.29) ; v4(66.87,89.72) 66.87,89.17 v1(66.92,89.12) 66.08,88.28 v4(66.08,88.23) ; v11(68.33,96.15) 68.38,96.19 68.38,96.21 v4(68.83,96.66)
  IN2 w0.254: v4(47.88,142.13) 47.88,148.95 49.25,150.32 55.17,150.32 58.78,146.71 v3(60.6,146.71) ; v12(116.66,139.8) 117.24,139.23 121.32,139.23 122.44,140.34 129.28,140.34 129.77,139.85 v12(129.92,139.85) ; v12(88.65,43.02) 89.1,43.02 89.53,42.59 89.53,40.26 90.25,39.55 90.25,26.52 92.15,24.62 92.15,22.74 94.11,20.78 v12(94.11,20.47)
  IN3 w0.254: v4(48.58,75.52) 49.98,75.52 51.27,74.23 51.27,65.01 49.03,62.78 v4(48.58,62.78) ; v4(32.43,62.78) 33.46,63.82 33.46,75.08 33.03,75.52 v4(32.43,75.52) ; v3(60.6,146.71) 60.59,146.7 60.59,146.34 62.84,144.1 68.4,144.1 71.87,147.56 79.54,147.56 79.97,148 81.94,148 82.42,148.48 84.84,148.48 85.57,147.74 87.66,147.74 88.51,146.89 90.55,146.89 92.38,145.06 93.32,145.06 93.88,144.5 93.88,143.56 94.15,143.29 94.15,142.9 94.68,142.37 95.66,142.37 95.82,142.53 97.04,142.53 100.36,139.22 105.26,139.22 106.79,140.76 115.83,140.76 116.29,140.29 v3(116.29,140.17)
  IN3 w0.381: v4(64.87,85.05) 64.87,86.44 v3(65.15,86.72)
  IN3 w0.508: v3(36.77,126.01) 33.14,126.01 v3(32.78,126.38)
  GND4 w0.254: v3(32.78,139.12) 32.78,138.99 v4(33.25,138.52) ; v3(54.12,126.38) v4(54.12,125.95)
  GND4 w0.305: v4(2.35,93.1) 2.35,93.31 v3(2.6,93.56)
  GND4 w0.381: v3(65.15,86.72) 64.87,86.44 v4(64.87,86.36) ; v3(2.54,126.84) 2.49,126.89 v4(2.49,127.39) ; v4(2.45,130.14) 2.45,130.3 2.64,130.5 v3(2.64,130.53)
  GND4 w0.508: v3(62.97,77.29) 62.99,77.32 v4(63.47,77.32)
  IN4 w0.254: v5(2.67,103.72) 4.76,103.72 5.21,103.28 16.38,103.28 17.4,102.26 17.4,97.44 16.72,96.75 v4(15.62,96.75) ; v4(2.88,113.83) 3.14,113.83 3.6,113.38 3.68,113.38 4.06,112.99 14.99,112.99 15.62,113.63 v4(15.62,113.83) ; v5(73.29,67.5) v6(70.09,70.7)
  IN4 w0.381: v7(72.34,90.27) 75.46,93.4 v5(75.92,93.4)
  IN4 w0.508: v5(59.66,61.19) 59.44,60.96 53.67,60.96 52.23,62.4 v5(51.98,62.4) ; v4(51.63,139.35) 51.75,139.22 51.75,130.77 50.86,129.89 50.86,126.86 v4(50.38,126.38) ; v7(26.3,139.02) 27.53,137.78 v7(28.27,137.78)
  BOTTOM w0.254: CG555.1 54.41,125.95 v4(54.12,125.95) 54.12,125.4 53.66,124.93 52.26,124.93 CG7084.1 ; CG6818.1 51.42,89.75 51.42,89.89 v7(51.17,90.15) ; 31.99,75.08 31.99,75.26 32.25,75.52 v4(32.43,75.52) ; 31.99,75.08 CG882.1 ; 31.99,75.08 32.26,75.08 32.32,75.15 32.64,75.15 33.27,75.78 35.91,75.78 v4(36.17,75.52) 36.6,75.1 CG878.1 ; CG6819.1 2.83,111.47 CG622.1 2.74,111.56 2.74,112.29 CG625.1 ; v5(73.29,67.5) 73.29,66.41 73.55,66.16 CG476.1 ; v4(15.62,96.75) 15.76,96.89 CG775.1 16.19,96.83 16.19,93.03 CG769.1 15.66,92.97 v4(15.62,93.01) ; 47.98,140.79 47.88,140.89 v4(47.88,142.13) ; v4(15.62,130.91) 15.64,130.93 CG676.1 16.48,130.51 16.48,127.48 CG674.1 15.72,127.07 v4(15.62,127.17) ; CG835.1 48.14,75.08 v4(48.58,75.52) 48.99,75.52 49.22,75.74 51.61,75.74 51.64,75.77 CG823.1 52.06,76.09 v4(52.26,76.29) ; CG556.1 50.67,126.08 v4(50.38,126.38) ; CG7093.1 76.96,62.38 v5(76.68,62.66) ; CG7093.1 77.34,62.38 77.6,62.13 77.67,62.13 77.93,61.88 RG516.1 ; CG7093.1 77.22,64.75 77.72,65.26 78.41,65.26 78.98,64.69 UG22.5 ; v4(15.62,113.83) 15.7,113.91 CG624.1 16.19,113.78 16.19,110.11 CG621.1 15.72,109.98 v4(15.62,110.09) ; RG17.2 RG18.2 66.34,85.46 66.87,84.94 68.04,84.94 68.63,84.35 RG79.2 ; RG533.1 80.95,55.35 80.01,55.35 v4(79.55,55.81) ; CG6817.1 15.82,79.87 v4(15.62,79.67) 15.62,78.58 15.15,78.11 CG7082.1 15.37,76.61 15.62,76.35 15.62,75.93 v4(15.62,75.93)
  BOTTOM w0.381: CG826.1 49.15,62.21 v4(48.58,62.78) ; RG79.2 RG82.2 RG85.2 RG83.2 RG19.2 68.63,79.43 RG20.2 68.61,79.02 68.07,78.49 63.87,78.49 63.47,78.09 v4(63.47,77.32) ; CG889.1 35.6,62.21 v4(36.17,62.78) ; v7(72.34,90.27) 72.34,89.92 72.28,89.86 UG40.5 72.66,89.52 72.97,89.84 CG7088.1 RG1518.1 74.09,89.13 74.47,88.75 UG39.5 ; RG18.2 65.46,85.46 65.3,85.31 65.13,85.31 v4(64.87,85.05) ; 2.46,96.79 CG6824.1 CG781.1 2.46,95.04 CG770.1 2.4,94.8 2.4,94.78 2.35,94.73 v4(2.35,93.1) 2.35,92.24 2.35,92.24 CG6823.1 2.35,91.01 1.97,90.63 1.97,80.58 v4(2.88,79.67) 2.88,79.12 2.07,78.31 2.07,77.33 2.6,76.8 CG7083.1 2.6,75.68 2.45,75.53 CG6821.1 ; 2.46,96.79 2.46,97.07 2.09,97.44 2.09,103.15 v5(2.67,103.72) 2.09,104.3 2.09,109.3 v4(2.88,110.09) 2.88,110.75 CG6819.1 ; 2.46,96.79 2.5,96.75 v4(2.88,96.75) ; v5(51.98,62.4) 51.78,62.21 CG837.1 ; v4(66.87,89.72) 67.7,89.72 UG42.5 ; UG43.5 73.42,61 73.32,60.9 CG7085.1 72.68,60.9 72.64,60.86 71.88,60.86 71.72,61.02 UG44.5 ; CG556.1 51.25,125.45 CG7084.1 ; v4(64.87,86.36) 64.41,86.82 64.41,87.85 64.91,88.34 65.96,88.34 v4(66.08,88.23) ; CG887.1 33,62.21 v4(32.43,62.78) ; QG511.2 75.26,65.86 74.97,66.16 CG246.1 CG476.1 73.79,65.69 73.99,65.48 UG27.5 ; CG625.1 2.74,112.39 2.74,113.1 2.66,113.17 CG623.1 2.66,113.62 v4(2.88,113.83) 2.08,114.63 2.08,126.99 v4(2.49,127.39) ; CG7087.1 74.52,92.23 74.38,92.37 UG41.5 74.38,92.62 75.16,93.4 v5(75.92,93.4)
  BOTTOM w0.406: 2.52,128.42 CG6820.1 ; 2.52,128.42 v4(2.52,129.34) 2.5,129.36 2.5,130.08 v4(2.45,130.14) ; 2.52,128.42 2.52,127.43 v4(2.49,127.39) ; CG889.1 CG888.1 CG887.1 ; CG826.1 CG827.1 CG837.1
  BOTTOM w0.508: 50.72,140.79 43.05,140.79 43.05,140.79 35.24,140.79 34.49,140.05 34.49,138.88 34.13,138.52 v4(33.25,138.52) 33.25,137.43 32.18,136.36 29.15,136.36 28.7,136.81 28.7,137.35 v7(28.27,137.78) ; 51.52,140.79 53.84,140.79 53.99,140.64 54.47,140.64 55.38,139.73 CG552.1 ; 25.21,138.94 24.21,138.94 24.05,139.09 15.88,139.09 13.21,136.43 9.97,136.43 8.06,134.52 2.74,134.52 2.23,134.01 2.23,130.35 v4(2.45,130.14) ; v5(51.96,90.03) 51.96,89.37 CG6818.1 ; CG7085.1 v5(72.96,61.56)
  vias: v1(51.25,89.45) v5(63.68,93.83) v5(64.25,93.83) v5(64.25,93.25) v5(64.82,93.83) v5(64.82,93.25) v5(79.76,80.55)
