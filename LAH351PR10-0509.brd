# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N37206101: length 4.7
  TOP w0.117: v5(100.39,92.61) 100.39,92.67 100.76,93.04 UC1.H13
  BOTTOM w0.117: v5(100.39,92.61) 100.39,92.67 99.9,93.16 v2(99.83,93.16) 99.68,93.16 99.57,93.05 98.75,93.05 98.75,93.06 98.11,93.06 97.87,93.3 97.73,93.3 97.05,92.62 RH154.2
N37206112: length 6.4
  TOP w0.081: RH155.2 141.13,108.07 140.72,108.49 138.41,108.49 137.75,107.83
  TOP w0.107: 137.75,107.83 137.39,107.83 136.9,107.33 135.86,107.33 UC1.BP31
N37239953: length 4
  TOP w0.117: v5(100.43,101.29) 101.15,101.29 101.44,101.01 UC1.J23
  BOTTOM w0.089: RH192.2 98.27,100.9 v2(99.03,100.9) 100.04,100.9 v5(100.43,101.29)
N37239957: length 87.1
  TOP w0.081: v4(90.02,87.61) 90.02,87.56 v2(88.82,86.36) 87.83,85.37 87.83,83.22 89.2,81.85 89.2,81.63 89.2,80.86 90.03,80.04 90.02,80.04 90.78,79.28 90.78,74.69 88.83,72.74 84.19,72.74 83.82,72.37 83.82,70.95 83.82,70.65 81.75,68.57 81.75,60.88 81.75,54.32 82.85,53.22 82.85,53.2 82.92,53.13 82.92,52.91 82.92,52.6 82.92,45.33 84.68,43.57 84.68,39.68 86.94,37.42 86.94,37.11 86.94,33.9 87.22,33.62 RH167.2
  TOP w0.117: UC1.H23 100.79,100.89 v5(100.41,100.52)
  IN4 w0.058: v4(90.02,87.61) 90.35,87.94 90.35,89.05 93.22,91.93 93.22,96.19 95.02,98 97.4,98 98.44,99.04 99.82,99.04 100.41,99.63 v5(100.41,100.52)
N37345395: length 1.1
  TOP w0.122: v5(109.38,33.14) 109.38,33.2 109.69,33.51 UH1.AL35
  BOTTOM w0.122: v5(109.38,33.14) 109.05,33.46 T135.1
N37890445: length 2
  BOTTOM w0.081: QT2.5 98.27,16.9 CT115.1 RT90.1
N37890455: length 1.8
  BOTTOM w0.081: RT89.2 95.68,17.55 QT2.3
N37890462: length 4.1
  BOTTOM w0.081: RT90.2 96.96,14.99 RT88.2 ; RT88.2 96.89,14.44 96.51,14.06 v2(96.49,14.06) ; RT88.2 96.89,15.79 QT2.6
N37890499: length 3
  BOTTOM w0.081: UT5.6 95.1,20.79 CT117.1 95.11,22.27 v2(95.11,22.48)
N38701284: length 5
  BOTTOM w0.081: UE1.25 115.71,18.08 DE1.2 115.44,16.95 RE8.2 v2(114,16.51)
N38702841: length 2.2
  BOTTOM w0.081: RE651.1 121.44,14.69 UE1.20
N38704058: length 10.8
  TOP w0.081: v3(126.63,18.62) 126.63,19.59 v2(126.62,19.6)
  IN3 w0.058: v3(126.63,18.62) 126.3,18.62 126.29,18.62 126.01,18.62 125.81,18.82 v9(123.44,18.82)
  GND4 w0.081: v9(123.44,18.82) v4(123.19,18.82)
  BOTTOM w0.081: UE1.31 118.88,21.08 119.71,20.25 121.39,20.25 122.81,18.82 v4(123.19,18.82)
N38704074: length 10
  IN3 w0.058: v9(123.44,18.44) 125.3,18.44 126.03,17.72 126.11,17.72 126.13,17.74 126.28,17.74 126.3,17.73 v3(126.63,17.73)
  GND4 w0.081: v9(123.44,18.44) v4(123.19,18.44)
  BOTTOM w0.081: v4(123.19,18.44) 122.89,18.44 121.26,20.06 119.63,20.06 119.12,20.58 UE1.30
N40259586: length 5
  TOP w0.081: v3(96.98,141.51) 97.22,141.75 RT108.1 98.51,141.75 v2(98.77,141.49)
  GND4 w0.081: v3(96.98,141.51) 97.36,141.51 v4(97.51,141.35)
  BOTTOM w0.081: UT4.D6 96.2,140.17 96.44,140.41 96.44,141.27 96.54,141.37 97.5,141.37 v4(97.51,141.35)
N46084233: length 2.6
  TOP w0.081: QX2.2 123.58,142.74 RX2.1 v2(124.79,142.78)
N123247790: length 1.4
  BOTTOM w0.203: C2507.1 68.41,9.74 U17.10
N123252636: length 1.4
  BOTTOM w0.203: U17.12 67.61,9.86 C2506.1
N140856784: length 2
  BOTTOM w0.081: UD1.F9 131.52,67.05 RD157.1
N140856890: length 2.1
  BOTTOM w0.381: UD2.F9 123.09,67.04 RD158.1
N140858392: length 2.1
  TOP w0.081: UD3.F9 141.88,67.05 RD164.1
N140858498: length 2.1
  TOP w0.127: RD163.1 129.74,67.29 UD4.F9
N148537289: length 2.4
  BOTTOM w0.081: UD2.E9 122.23,68.72 RD231.2
N148539009: length 2
  BOTTOM w0.081: RD230.2 131.55,67.85 UD1.E9
N148539686: length 2.1
  TOP w0.081: RD232.2 141.85,67.85 UD3.E9
N148539959: length 2.1
  TOP w0.081: RD233.2 129.67,68.02 UD4.E9
N148540239: length 2.3
  BOTTOM w0.081: RD234.2 106.92,68.53 UD5.E9
N148541018: length 2.5
  TOP w0.381: UD7.E9 114.94,67.85 115.87,68.79 RD236.2
N148541530: length 2.3
  TOP w0.381: UD8.E9 104.22,68.47 RD237.2
N148566755: length 20.8
  TOP w0.081: v5(144.34,65.18) 144.34,66.6 v2(143.89,67.05) 143.29,66.45 RD238.1
  BOTTOM w0.122: v5(144.34,65.18) 142.62,65.18 142.43,64.99 142.43,62.8 RD239.1 140.74,63.6 140.74,64.68 140.45,64.98 134.84,64.98 134.7,64.83 134.7,64.47 134.47,64.24 134.14,64.24 133.88,63.98 133.88,62.63 UD1.M9
N148569917: length 2.9
  BOTTOM w0.122: UD2.M9 121.8,62.25 121.45,62.6 RD240.1 RD241.1
N148572207: length 11.6
  TOP w0.122: RD243.1 RD242.1 131.53,65.04 132.33,65.04 132.42,65.13 135.31,65.13 135.41,65.23 137.87,65.23 138.05,65.05 138.54,65.05 138.71,64.88 138.71,64.44 138.94,64.21 139.38,64.21 139.5,64.1 139.5,62.45 139.7,62.25 UD3.M9
N148574907: length 11.9
  TOP w0.122: RD244.1 RD245.1 121.34,65.41 121.71,65.04 128.16,65.04 128.31,64.88 128.31,64.44 128.54,64.21 128.98,64.21 129.1,64.1 129.1,62.45 129.3,62.25 UD4.M9
N148577773: length 3.4
  BOTTOM w0.122: RD247.1 RD246.1 107.42,62.25 UD5.M9
N148580948: length 2.7
  TOP w0.122: RD250.1 RD251.1 114.88,62.51 114.62,62.25 UD7.M9
N148582662: length 12.3
  TOP w0.081: v2(94.26,66.04) 94.46,65.84 RD253.1
  TOP w0.122: RD253.1 RD252.1 95.26,65.22 95.43,65.05 102.21,65.05 102.41,64.85 102.41,64.49 102.64,64.26 102.9,64.26 103.2,63.96 103.2,62.61 103.56,62.25 UD8.M9
N249404770: length 5.1
  BOTTOM w0.081: UT4.G10 98.41,141.84 98.57,141.84 98.59,141.87 98.8,141.87 98.83,141.84 99.01,141.84 99.26,142.09 100.43,142.09 100.97,142.62 102.34,142.62 102.51,142.45 102.53,142.45 T122.1
N249407320: length 4.9
  BOTTOM w0.081: UT4.E10 98.45,140.87 100.46,140.87 100.74,140.59 102.6,140.59 T121.1
N249408950: length 5.9
  IN4 w0.058: v4(91.19,138.48) 91.43,138.73 91.94,138.73 93.24,140.03 94.15,140.03 94.62,140.51 94.62,140.85 94.9,141.12 v7(95.2,141.12)
  BOTTOM w0.081: v4(91.19,138.48) 91.02,138.48 T62.1
N249410070: length 3.5
  BOTTOM w0.081: T64.1 91.79,137.46 91.83,137.46 92.71,138.33 92.99,138.33 93.54,138.88 93.95,138.88 UT4.B2
N249410630: length 7.7
  IN4 w0.058: v4(90.17,138.65) 90.41,138.89 91.83,138.89 93.11,140.17 94.09,140.17 94.49,140.57 94.49,140.91 v7(95.2,141.62)
  BOTTOM w0.081: v4(90.17,138.65) 89.77,138.25 89.77,138.03 T63.1
N249410910: length 2.9
  BOTTOM w0.081: T65.1 92.11,138.7 92.79,139.37 93.89,139.37 94.14,139.62 UT4.C2
N2494119425: length 1.9
  BOTTOM w0.081: UT4.D10 98.44,140.36 98.59,140.36 98.59,140.36 98.8,140.36 98.8,140.36 T114.1
N2494119426: length 1.8
  BOTTOM w0.081: T120.1 100.06,141.73 99.93,141.86 99.54,141.86 99.3,141.62 UT4.G11
N2494119430: length 1.8
  TOP w0.081: v4(97.66,140.24) T70.1
  BOTTOM w0.081: UT4.D7 96.76,140.12 97.03,139.85 97.28,139.85 v4(97.66,140.24)
N3269959812: length 2.3
  TOP w0.203: v4(53.45,21.87) 54.1,21.87 54.29,22.06 PU501.10
  BOTTOM w0.081: v4(53.45,21.87) v2(52.26,21.87)

## Copper pours and planes (outline as drawn)
3V3_SYS_EN on TOP (solid shape): 10.29,15.46 10.29,15.01 10.1,14.82 9.46,14.82 9.21,14.57 9.21,13.87 9.02,13.68 8.45,13.68 8.38,13.74 8.38,14 8.64,14.25 8.64,15.2 8.76,15.33 9.33,15.33 9.53,15.52 10.22,15.52
3V_SN on BOTTOM (solid shape): 65.53,27 65.53,25.63 65.37,25.47 64.76,25.47 64.34,25.89 63.04,25.89 62.92,26.01 62.92,26.9 63.04,27.03 65.51,27.03
3VS on BOTTOM (solid shape): 71.95,12.79 71.95,10.76 71.82,10.63 69.93,10.63 69.57,10.28 69.57,9.78 69.46,9.67 68.95,9.67 68.87,9.74 68.87,10.07 68.71,10.07 68.71,10.63 68.64,10.7 68.64,11.39 68.71,11.46 69.22,11.46 69.47,11.71 69.47,12.28 69.66,12.47 70.87,12.47 71.25,12.85 71.88,12.85
5V_SN on BOTTOM (solid shape): 53.34,20.09 53.34,17.17 53.21,17.05 52.26,17.05 52.13,17.17 52.13,20.09 52.26,20.22 53.21,20.22
5VS on BOTTOM (solid shape): 66.42,11.52 67.12,11.52 67.31,11.33 67.31,10.44 66.91,10.04 66.9,10.03 66.9,9.4 66.86,9.36 66.06,9.36 65.92,9.5 65.92,10.07 65.8,10.19 64.14,10.19 64.01,10.31 64.01,12.22 64.14,12.35 65.6,12.35
+0.6VS on TOP: 94.11,58.32 93.98,58.19 92.2,58.19 91.95,58.45 91.95,64.99 92.14,65.18 93.98,65.18 94.11,65.05
+0.6VS on TOP: 141.35,55.27 141.35,52.61 141.6,52.35 143.38,52.35 143.51,52.48 143.51,52.99 143.26,53.24 143.26,55.15 143.13,55.27 143.13,56.99 143.92,57.78 143.92,62.54 144.65,63.27 144.65,64.42 144.4,64.67 143.07,64.67 142.81,64.92 142.43,64.92 142.37,64.86 142.37,62.38 142.4,62.35 142.4,57.08 141.86,56.54 139.95,56.54 139.7,56.29 139.7,55.78 139.95,55.53 141.1,55.53
+0.6VS on BOTTOM: 143.26,64.8 144.4,64.8 144.53,64.67 144.53,58.19 144.4,58.07 143.26,58.07 143.13,58.19 143.13,64.67
+0.6VS on BOTTOM: 100.46,54.76 99.95,55.27 91.06,55.27 90.93,55.4 90.93,63.27 92.08,64.42 93.85,64.42 94.11,64.16 94.11,57.99 93.7,57.58 93.7,56.82 95.33,56.82 95.56,56.59 101.8,56.59 102.74,55.65 107.57,55.65 109.09,57.18 135.89,57.18 136.14,56.92 136.14,55.91 135.89,55.65 127.38,55.65 126.62,56.42 110.36,56.42 108.71,54.76
+0.6VS on IN3: 130.3,56.67 140.97,56.67 141.35,56.29 141.35,55.78 140.97,55.4 130.3,55.4 130.18,55.53 130.18,56.54
+0.6VSP on TOP (solid shape): 142.72,51.7 143.16,51.7 143.16,52.21 143.55,52.21 144.08,51.68 144.08,50.74 144.85,50.74 145.18,50.41 145.25,50.41 145.37,50.33 145.52,50.31 145.59,50.23 145.59,49.41 145.71,49.29 146.15,49.29 146.28,49.16 146.28,48.47 146.22,48.4 145.96,48.4 145.9,48.47 144.96,48.47 144.83,48.34 144.83,47.97 144.97,47.83 145.83,47.83 145.9,47.77 145.9,47.64 145.83,47.58 144.6,47.58 144.51,47.67 144.51,47.68 144.51,49 143.78,49.74 143.56,49.74 143.38,49.91 143.38,50.4 142.96,50.82 142.75,50.82 142.35,51.21 142.35,52.12 142.44,52.21 142.72,52.21
+0.9V_CIO on TOP: 80.45,141.63 81.22,141.63 81.92,140.93 82.04,140.93 82.11,140.87 82.11,140.62 81.98,140.49 80.52,140.49 80.39,140.62 80.39,141.57
+0.9V_CIO on BOTTOM: 79.38,141.63 81.47,141.63 81.6,141.51 81.6,141.06 81.47,140.93 79.38,140.93 79.31,141 79.31,141.57
+0.9V_DP on TOP: 79.88,143.47 80.33,143.47 80.42,143.38 80.42,141.73 80.3,141.6 80.3,139.82 80.14,139.66 78.87,139.66 78.74,139.79 78.74,140.55 78.93,140.74 79.18,140.74 79.31,140.87 79.31,143.16 79.38,143.22 79.63,143.22
+0.9V_DP on BOTTOM: 79.5,143.28 82.49,143.28 82.61,143.16 82.61,139.85 82.49,139.73 78.93,139.73 78.74,139.92 78.74,140.11 78.8,140.17 78.93,140.17 79.5,140.74 81.41,140.74 81.66,141 81.66,141.82 81.47,142.01 79.76,142.01 79.63,142.14 79.63,142.65 79.38,142.9 79.38,143.16
+0.9V_LVR_OUT on TOP: 77.03,147.41 78.04,147.41 78.3,147.16 78.3,145.57 78.93,144.93 79.82,144.93 80.26,144.49 80.26,144.43 80.14,144.3 77.28,144.3 76.9,144.68 76.9,147.28
+0.9V_LVR_OUT on BOTTOM: 76.71,145.32 77.15,145.32 77.28,145.19 77.28,144.49 77.47,144.3 79.57,144.3 79.88,144.62 80.26,144.62 80.33,144.55 80.33,143.73 80.2,143.6 80.07,143.6 79.69,143.98 76.83,143.98 76.64,144.17 76.64,145.25
+0.9V_PCIE on TOP: 79.06,142.84 79.06,142.46 78.93,142.33 76.58,142.33 76.33,142.08 76.33,141.38 76.26,141.32 75.95,141.32 75.88,141.38 75.88,142.71 76.2,143.03 78.87,143.03
+0.9V_PCIE on BOTTOM: 76.2,143.28 77.22,143.28 77.53,142.97 78.87,142.97 78.99,142.84 78.99,142.14 78.87,142.01 77.47,142.01 77.15,141.7 76.2,141.7 76.14,141.76 76.14,142.01 76.2,142.08 76.45,142.08 76.52,142.14 76.52,142.84 76.45,142.9 76.2,142.9 76.14,142.97 76.14,143.22
+0.9V_SVR on TOP: 73.47,145.38 74.23,145.38 74.36,145.51 74.36,146.08 75.88,147.6 78.04,147.6 78.36,147.28 78.36,145.95 78.74,145.57 79.5,145.57 80.01,146.08 81.47,146.08 81.6,146.2 81.6,147.73 81.53,147.79 78.74,147.79 77.41,149.13 75.31,149.13 75.06,149.38 75.06,150.27 74.93,150.4 73.6,150.4 73.47,150.27
+0.9V_SVR on BOTTOM: 80.58,143.92 80.58,142.52 80.71,142.39 80.9,142.39 81.03,142.52 81.03,143.86 81.28,144.11 81.28,144.81 81.15,144.93 80.77,144.93 80.14,145.57 80.01,145.57 79.57,146.01 78.87,146.01 78.68,145.82 78.68,145.44 78.61,145.38 78.23,145.38 78.11,145.25 78.11,145 78.17,144.93 80.01,144.93 80.45,144.49 80.45,144.05
+0.9V_USB on TOP: 77.53,141.7 78.55,141.7 78.61,141.63 78.61,141.38 78.55,141.32 78.04,141.32 77.91,141.19 77.91,139.79 77.66,139.54 77.09,139.54 77.03,139.6 77.03,141.12 77.15,141.25 77.28,141.25 77.47,141.44 77.47,141.63
+1.0VS_VGAP on BOTTOM (solid shape): 71.44,114.71 71.44,110.3 71.31,110.17 65.66,110.17 65.47,110.36 65.47,112.61 64.45,113.63 64.45,114.65 64.58,114.77 71.37,114.77
+1.2V_DDR on BOTTOM (solid shape): 138.94,74.68 126.94,74.68 126.94,84.68 138.94,84.68
+1.2V_DDR on TOP: 91.06,85.12 91.06,84.36 91.19,84.23 92.08,84.23 92.33,84.48 93.09,84.48 93.22,84.61 93.22,85.5 93.15,85.56 91.5,85.56
+1.2V_DDR on TOP: 142.05,67.85 142.05,64.67 140.14,62.77 112.01,62.77 109.86,64.92 109.03,64.92 108.06,63.96 108.06,63.03 107.73,62.7 103.7,62.7 103.5,62.89 103.5,63.91 102.49,64.92 97.54,64.92 96.33,66.13 96.32,66.13 95.67,66.78 94.96,66.78 94.87,66.87 94.87,68.94 95.24,69.32 95.89,69.32 96.33,69.76 96.33,79.4 97.03,80.1 142.24,80.1 143.89,78.45 143.89,68.04 143.7,67.85 ; 8 cut-outs
+1.2V_DDR on TOP: 121.28,92.17 122.62,92.17 123.38,91.4 123.38,90.32 123.19,90.13 122.17,90.13 121.92,90.39 121.92,91.34 121.86,91.4 118.75,91.4 118.49,91.15 117.35,91.15 116.9,91.59 116.9,91.98 117.03,92.1 117.67,92.1 117.92,91.85 120.97,91.85
+1.2V_DDR on TOP: 113.67,92.42 113.98,92.42 114.17,92.23 114.17,91.34 114.74,90.77 114.94,90.77 115.44,90.26 115.44,89.94 115.32,89.82 115,89.82 114.68,90.13 113.92,90.13 113.73,89.94 113.73,88.67 114.17,88.23 114.74,88.23 115.38,87.59 115.38,87.34 115.25,87.21 113.73,87.21 112.78,88.17 112.78,92.1 112.9,92.23 113.47,92.23
+1.2V_DDR on BOTTOM: 137.21,56.47 136.07,57.61 136.04,57.58 133.17,57.58 133.17,58.08 133.12,58.13 96.2,58.13 94.93,59.4 94.93,64.8 93.73,64.8 93.6,64.92 93.6,66.56 89.59,70.58 89.59,72.85 91.44,74.7 91.44,85.94 93.22,87.72 99.44,87.72 99.44,88.42 99.63,88.61 100.33,88.61 101.03,89.31 101.03,89.63 101.16,89.75 101.73,89.75 101.85,89.88 101.85,91.95 101.98,92.08 112.75,92.08 113.22,92.55 114.09,92.55 115.17,91.47 119.95,91.47 120.52,90.9 137.86,90.9 138.18,90.58 138.18,85.58 139.31,84.44 139.31,79.43 139.59,79.16 139.59,79.15 142.19,76.55 143.7,76.55 145.03,75.21 145.03,66.13 143.7,64.8 142.56,64.8 142.56,63.21 141.41,62.07 141.41,59.08 141.41,59.08 141.41,57.28 140.6,56.47 ; 5 cut-outs
+1.2V_DDR on VCC: 96.24,57.18 94.74,58.68 94.74,80.69 99.69,85.65 99.69,88.06 101.22,89.58 101.22,91.49 102.09,92.36 142.33,92.36 144.15,90.54 144.15,57.18
+1.2V_DDR on IN3: 116.59,91.47 137.48,91.47 140.21,88.74 140.21,80.61 144.02,76.8 144.02,60.42 141.1,57.5 137.86,57.5 137.35,58 96.33,58 95.82,58.51 95.82,73.56 99.06,76.8 109.54,76.8 115.89,83.15 115.89,90.77
+1.2V_VCCPLL_OC on TOP: 91.19,82.83 91.95,82.83 92.33,82.45 93.34,82.45 93.47,82.32 93.47,80.86 93.15,80.55 91.76,80.55 91.54,80.77 91.54,81.59 91.06,82.07 91.06,82.7
+1.2V_VCCPLL_OC on BOTTOM: 99.49,91.37 99.27,91.37 99.26,91.38 99.12,91.41 98.96,91.37 98.57,91.37 98.57,91.37 98.47,91.39 98.37,91.38 98.35,91.37 98.28,91.43 98.28,92.26 98.37,92.34 98.39,92.34 98.52,92.34 98.64,92.39 98.98,92.39 98.99,92.38 99.13,92.35 99.28,92.38 99.29,92.39 100.26,92.39 100.27,92.38 100.39,92.36 100.54,92.39 101.32,92.39 101.47,92.23 101.47,91.4 100.84,90.77 100.09,90.77
+1.2V_VCCPLL_OC on IN1: 100.59,93.17 100.59,93.17 100.67,93.18 100.73,93.13 101.24,92.88 101.66,93.26 101.71,93.33 101.8,93.33 102.25,93.37 102.49,93.75 103.48,94.74 128.04,94.74 128.91,93.88 131.89,93.88 132.46,93.31 132.46,92.23 132.33,92.1 113.86,92.1 113.73,92.23 110.17,92.23 110.17,92.23 102.93,92.23 102.93,92 102.29,91.35 102.29,88.22 100.39,86.32 100.39,85.5 98.68,83.78 98.68,83.47 95.69,80.48 91.76,80.48 91.5,80.74 91.5,81.63 91.88,82.01 93.15,82.01 93.22,81.94 94.81,81.94 97.22,84.36 97.22,90.52 99.87,93.17
+1.2VP on TOP (solid shape): 150.15,67.18 150.15,63.81 149.99,63.65 145.48,63.65 145.13,64 145.13,67.24 145.38,67.5 149.83,67.5
+1.2VP on IN1 (solid shape): 148.79,64.77 148.79,63.75 148.47,63.43 147.26,63.43 147.07,63.62 147.07,64.51 147.45,64.89 148.66,64.89
+1.2VP on TOP: 145.9,50.82 146.15,50.82 146.33,50.64 146.33,49.81 146.72,49.42 146.72,48.47 146.66,48.4 146.53,48.4 146.47,48.47 146.47,49.1 145.77,49.8 145.77,50.69
+1.2VP on BOTTOM: 151.32,70.7 151.32,63.59 151.13,63.4 145.61,63.4 145.54,63.46 145.54,70.64 146.05,71.15 150.88,71.15
+1.2VP on IN1: 146.18,52.1 146.69,52.1 146.88,51.91 146.88,49.88 146.6,49.6 145.91,49.6 145.8,49.71 145.8,50.8 146.05,51.06 146.05,51.97
+1.8V_PRIM on BOTTOM: 101.82,33.85 101.82,31.7 101.81,31.62 101.82,31.54 101.82,30.85 101.25,30.28 100.17,30.28 99.86,29.96 99.86,29.01 99.22,28.37 99.22,27.67 99.03,27.48 97.23,27.48 96.99,27.72 96.99,28.21 97.08,28.3 98.08,28.3 98.14,28.36 98.14,28.87 98.04,28.96 97.17,28.96 97.13,29.01 97.13,29.47 97.4,29.74 97.4,29.98 97.25,30.13 97.25,34.92 98.26,35.92 100.29,35.92 100.3,35.92 102.22,35.92 102.44,35.7 102.44,34.93 101.79,34.29 101.73,34.09 101.8,33.88
+1.8V_PRIM on IN2: 101.18,31.35 101.21,31.37 101.23,31.4 97.68,31.4 97.23,31.84 97.23,35.44 97.7,35.91 100.2,35.91 101.6,34.51 101.6,31.59 101.37,31.35
+1.8V_RUN on TOP (solid shape): 71.63,9.36 71.63,7.27 71.5,7.14 70.26,7.14 70.14,7.27 70.14,9.33 70.26,9.46 71.53,9.46
+1.8V_RUN on VCC: 54.4,4.79 50.84,8.35 20.02,8.35 19.07,7.39 12.06,7.39 11.43,8.03 11.43,9 11.6,9.17 51.77,9.17 54.82,6.12 62.78,6.12 63.54,6.89 70.7,6.89 71.31,6.27 71.31,4.85 69.57,4.85 69.51,4.79
+1.8V_RUN_PWR on TOP: 67.06,9.43 69.34,9.43 69.47,9.3 69.47,7.27 69.34,7.14 67.06,7.14 66.8,7.39 66.8,9.17
+1.8V_RUN_PWR on BOTTOM: 80.58,8.35 81.41,8.35 81.47,8.28 81.47,7.39 81.66,7.2 81.66,6.53 81.47,6.34 80.92,6.34 80.62,6.04 80.62,5.39 80.45,5.22 80,5.22 79.79,5.43 79.79,6.79 80.52,7.52 80.52,8.28
+1.8VALW on TOP (solid shape): 66.67,10 66.67,7.14 66.55,7.01 64.71,7.01 63.82,7.9 61.91,7.9 61.72,8.09 61.72,10.12 61.85,10.25 66.42,10.25
+1.8VALW on BOTTOM (solid shape): 69.22,93.69 69.22,91.28 69.09,91.15 68.01,91.15 67.88,91.28 67.88,92.86 67.56,93.18 67.25,93.18 67.12,93.31 67.12,94.07 67.25,94.2 68.71,94.2
+1.8VALW on IN3: 68.58,94.83 73.22,94.83 73.31,94.74 74.8,94.74 75.31,94.23 75.31,39.02 68.77,32.48 68.77,15.59 67.75,14.57 67.75,7.52 67.31,7.08 64.58,7.08 64.14,7.52 64.14,35.78 68.96,40.6 68.96,47.53 66.87,49.62 66.87,85.37 66.93,85.37 68.2,86.64 68.2,94.45
+1.8VALW on IN4: 65.02,8.28 66.67,8.28 67.31,7.65 67.31,6.89 66.93,6.5 65.15,6.5 64.9,6.76 64.9,8.16
+1.8VSP on TOP (solid shape): 61.02,9.93 61.02,8.16 60.83,7.97 58.55,7.97 58.23,7.65 58.23,6.89 57.91,6.57 57.04,6.57 56.85,6.38 56.85,4.89 56.68,4.71 55.05,4.71 54.83,4.93 54.83,9.18 55.71,10.06 60.9,10.06
+1.35VS_VGA on TOP: 18.29,53.94 17.91,54.32 17.91,57.69 18.73,58.51 18.73,63.97 19.11,64.35 19.11,71.08 19.88,71.85 24.51,71.85 28.07,68.29 30.16,68.29 31.62,66.83 39.69,66.83 41.08,68.23 46.35,68.23 47.88,66.7 52.96,66.7 54.42,68.16 55.75,68.16 55.94,67.97 55.94,62.7 55.44,62.19 24.45,62.19 23.69,61.43 23.69,57.81 22.1,56.23 22.1,54.26 21.78,53.94
+1.35VS_VGA on TOP: outline of 232 points within 29.26,89.1 47.94,112.97
+1.35VS_VGA on BOTTOM: 42.35,65.37 43.12,65.37 43.18,65.31 43.18,61.94 43.12,61.88 42.42,61.88 42.29,62 42.29,65.31
+1.35VS_VGA on BOTTOM: 17.53,59.27 16.57,60.23 16.57,66.45 12.26,70.77 7.79,70.77 7.79,71.16 7.68,71.16 7.68,71.21 7.38,71.21 7.38,71.16 7.37,71.16 7.37,70.77 5.54,70.77 5.54,71.26 5.46,71.34 1.87,71.34 1.62,71.59 1.62,81.21 1.91,81.5 1.91,91.15 2.29,91.53 2.29,93.94 2.6,94.26 2.6,94.39 2.22,94.77 2.22,96.48 2.03,96.67 2.03,103.22 2.16,103.22 2.41,103.47 2.41,103.98 1.91,104.49 1.91,109.2 2.41,109.71 2.41,111.22 2.35,111.28 2.35,126.52 2.67,126.84 2.67,131.03 2.69,131.05 2.69,133.85 2.97,134.13 5.77,134.13 5.91,134.27 7.62,134.27 10.03,136.68 31.5,136.68 34.04,139.22 35.7,139.22 36.84,140.36 48.01,140.36 49.15,139.22 56.53,139.22 58.61,137.13 58.61,122.2 50.36,113.95 47.24,113.95 44.51,111.22 33.27,111.22 32.89,111.6 30.29,111.6 30.1,111.41 30.1,110.9 30.23,110.77 30.67,110.77 30.86,110.58 30.86,104.49 30.48,104.1 30.48,103.22 30.86,102.83 30.86,102.01 30.04,101.18 30.04,98.07 29.72,97.75 29.72,90.26 25.78,86.32 25.78,60.23 25.34,59.78 21.78,59.78 21.27,59.27 ; 3 cut-outs
+1.35VS_VGA on IN1: outline of 120 points within 29.14,89.03 48.01,113.14
+1.35VS_VGA on IN1: 38.7,60.01 35.94,62.77 35.94,75.64 36.09,75.8 39.52,75.8 39.75,75.57 39.75,62.77 39.74,62.75 40.6,61.89 50.69,61.89 52.13,63.34 52.13,77.31 52.9,78.07 57.59,78.07 58.17,77.5 58.17,63.08 58.03,62.94 58.03,61.34 56.69,60.01
+1.35VS_VGA on IN2: outline of 131 points within 28.92,88.87 47.66,113.18
+1.35VS_VGA on IN2: outline of 81 points within 19.11,60.86 56.13,76.74
+1.35VS_VGA on VCC: 12.06,62.38 12.06,64.27 11.79,64.54 1.17,64.54 1.17,138.73 1.25,138.81 1.54,141.06 4.12,141.67 5,142.55 7.82,142.6 9.31,141.57 11.6,140.23 23.59,140.23 24.23,140.36 24.77,140.72 27.48,143.43 27.84,143.97 27.97,144.61 27.97,147.22 58.17,147.22 58.17,120.04 23.01,120.04 21.84,118.88 21.84,72.31 23.7,70.46 23.7,63.2 22.88,62.38
+1.35VS_VGA on IN3: 60.54,137.16 57.85,139.85 45.97,139.85 45.02,138.9 43.24,138.9 42.04,140.11 42.04,140.24 40.64,141.63 29.72,141.63 24.74,136.65 2.29,136.65 1.26,135.63 1.26,69.97 1.89,69.33 9.02,69.33 10.41,67.93 10.41,64.73 12.14,63.01 12.19,63.01 12.81,62.38 22.99,62.38 23.5,62.89 23.5,70.56 21.34,72.72 21.34,120.17 22.35,121.19 58.36,121.19 60.54,123.37
+1.35VS_VGA on IN4: outline of 100 points within 1.4,59.34 54.86,135.51
+1.35VS_VGA on IN4: 29.91,139.35 40.58,139.35 40.83,139.09 40.83,131.09 40.51,130.77 38.61,130.77 37.08,129.25 35.56,129.25 34.48,130.33 30.48,130.33 29.53,131.28 29.53,138.97
+1V8_AON on BOTTOM (solid shape): 55.61,140.47 55.61,139.44 55.51,139.34 53.75,139.34 53.44,139.66 53.44,140.4 53.75,140.72 55.35,140.72
+1V8_AON on BOTTOM (solid shape): 51.83,140.79 51.83,139.16 51.76,139.09 50.86,139.09 50.5,139.45 50.5,141.07 50.52,141.08 51.54,141.08
+1V8_AON on BOTTOM (solid shape): 65.79,94.29 65.79,93.44 65.6,93.25 65.02,93.25 64.9,93.12 64.9,92.23 64.83,92.17 62.93,92.17 62.8,92.29 62.8,93.82 63.25,94.26 64.05,94.26 64.14,94.35 65.72,94.35
+1V8_AON on TOP: 53.04,92.32 52.77,92.59 51.89,92.59 51.75,92.45 51.75,90.31 50.56,89.12 49.85,89.12 49.66,88.93 49.66,88.67 49.78,88.55 50.67,88.55 51.18,89.05 51.18,89.08 52.39,89.08 53.04,89.73
+1V8_AON on TOP: 68.07,90.58 67.31,89.82 67.31,88.93 67.18,88.8 66.42,88.8 66.29,88.93 66.29,91.47 66.17,91.59 65.41,91.59 65.28,91.47 65.28,90.83 65.15,90.71 64.64,90.71 64.52,90.83 64.52,92.1 64.26,92.36 63.37,92.36 63.25,92.48 63.25,94.01 63.37,94.13 64.9,94.13 65.02,94.01 65.02,93.25 65.66,92.61 67.94,92.61 68.07,92.48
+1V8_AON on TOP: 66.67,97.82 68.45,97.82 68.58,97.69 68.58,96.8 68.33,96.55 66.67,96.55 66.29,96.93 66.29,97.44
+1V8_AON on BOTTOM: 67.87,96.47 68.38,96.98 69.19,96.98 69.31,96.86 69.31,96.3 69.22,96.21 69.22,95.47 69.13,95.38 68.39,95.38 68.26,95.51 68.25,95.51 68.2,95.56 67.27,95.56 67.18,95.65 67.18,96.17 67.19,96.17 67.19,96.35 67.31,96.47
+1V8_AON on BOTTOM: 26.67,138.88 26.48,138.69 25.06,138.69 25.06,139.19 25.18,139.32 25.57,139.32 25.76,139.51 25.76,140.63 25.93,140.81 26.48,140.81 26.67,140.62
+1V8_AON on VCC: 74.8,52.73 74.8,85.86 72.88,87.78 50.65,87.78 50.04,88.4 50.04,90.47 51.69,92.12 51.69,94.13 77.11,94.13 79.88,91.36 79.88,53.92 78.7,52.73
+1V8_MAIN on TOP (solid shape): outline of 331 points within 51.68,99.57 53.79,105.26
+1V8_MAIN on BOTTOM (solid shape): 66.23,97.73 66.23,96.99 65.85,96.61 65.85,95.6 65.82,95.57 65.09,95.57 65.09,94.77 64.96,94.64 63.82,94.64 63.69,94.77 63.69,97.56 63.82,97.69 65.21,97.69 65.3,97.78 66.18,97.78
+1V8_MAIN on BOTTOM: 50.83,105.66 51.26,105.23 52.02,105.23 52.22,105.03 52.22,103.16 52.16,103.11 52.16,98.81 52.41,98.57 53.05,98.57 53.49,98.13 59.18,98.13 59.31,98 59.31,93.88 59.5,93.69 60.07,93.69 60.2,93.82 60.2,105.72 53.04,105.72 52.76,106 51.98,106 51.91,106.07 51.91,109.68 52.34,110.11 52.34,112.66 52.26,112.74 51.31,112.74 51.16,112.59 51.16,110.08 50.83,109.75
+1V8_MAIN on IN2: 51.37,104.74 52.45,104.74 52.64,104.55 52.64,100.42 52.39,100.17 51.31,100.17 51.18,100.29 51.18,104.55
+1V8_MAIN on VCC: 51.69,94.64 51.69,106.98 59.8,115.09 65.68,115.09 67.06,113.71 67.06,94.64
+1V8_MAIN on IN4: 52.68,92.23 52.52,92.4 52.52,98.51 53.84,99.83 53.84,104.56 53.47,104.93 52.2,104.93 51.83,104.56 51.83,100.04 51.17,99.39 51.17,92.66 49.93,91.42 47.87,91.42 46.98,90.53 46.98,87.58 47.32,87.24 52.16,87.24 52.68,87.76
+1V_MPHY on TOP (solid shape): 93.1,51.16 93.12,51.16 93.24,51.04 93.24,48.46 93.09,48.3 93.09,48.11 93.15,47.95 93.3,47.86 93.32,47.86 93.34,47.83 93.43,47.85 93.5,47.89 93.68,47.89 93.84,47.83 94,47.89 94.18,47.89 94.22,47.86 94.26,47.82 94.26,47.54 94.16,47.44 93.82,47.44 93.66,47.28 93.66,46.97 93.53,46.84 93.37,46.84 93.15,47.05 92.94,47.05 91.98,48.01 91.98,49.31 91.35,49.94 91.35,50.47 91.3,50.52 91.3,51.03 91.43,51.16 91.66,51.16 91.75,51.26 91.75,51.44 91.98,51.66 92.6,51.66
+1V_MPHY on TOP: 94.36,42 93.43,42 93.01,41.58 93.01,41.25 93.22,41.05 93.6,41.05 93.92,41.37 93.92,41.56 93.98,41.62 94.36,41.62 94.42,41.68 94.42,41.94
+1V_MPHY on TOP: 117.44,46.61 117.2,46.85 117.2,47.35 117.12,47.43 116.51,47.43 116.46,47.39 116.46,46.17 116.51,46.11 117.35,46.11 117.44,46.2
+1V_MPHY on BOTTOM: 107.34,38.41 107.21,38.55 107.21,38.95 107.31,39.06 107.37,39.06 107.47,39.16 107.51,39.16 107.66,39.19 107.78,39.28 107.78,39.35 107.79,39.36 107.83,39.47 107.82,39.58 107.81,39.61 107.89,39.68 107.89,40.75 108.29,41.15 110.04,41.15 111.54,42.65 111.54,43.45 111.65,43.56 111.65,44.32 111.67,44.34 113.14,44.34 113.49,44.69 113.49,46.99 113.97,47.47 117.69,47.47 117.77,47.39 117.77,45.94 117.64,45.82 115.82,45.82 115.1,45.09 115.1,40.38 114.12,39.4 109.86,39.4 108.86,38.41
+1V_MPHY on IN4: 101.53,40.18 101.53,37.85 101.96,37.41 107.26,37.41 107.68,37.83 107.68,40.18 107.53,40.32 101.67,40.32
+1V_PCH on BOTTOM: 93.13,40.79 93.13,38.15 93.1,38.12 90.65,38.12 90.13,38.64 90.13,40.86 90.32,41.05 92.88,41.05
+1VALW on TOP (solid shape): outline of 110 points within 101.62,35.14 104.87,38.42
+1VALW on BOTTOM (solid shape): 129.49,41.27 129.49,40.76 129.41,40.68 126.05,40.68 125.93,40.8 125.93,41.69 126.24,42 128.76,42
+1VALW on TOP: outline of 271 points within 104.23,32.86 109.24,40.8
+1VALW on TOP: outline of 200 points within 98.81,32.86 107.84,40.27
+1VALW on TOP: 88.51,112.71 88.65,112.58 88.65,106.4 88.53,106.28 86.92,106.28 86.86,106.34 86.86,107.38 86.67,107.57 86.26,107.57 86.04,107.78 86.04,108.42 85.01,109.45 85.01,110.22 85.07,110.28 85.77,110.28 86.13,110.64 86.13,112.29 85.89,112.53 85.04,112.53 84.96,112.6 84.96,113.19 85.03,113.25 85.81,113.25 85.89,113.33 85.89,114.11 85.94,114.17 86.55,114.17 86.64,114.08 86.64,113.39 87.31,112.71
+1VALW on BOTTOM: outline of 164 points within 93.24,34.53 113.18,48.42
+1VALW on IN3: 97.47,101.19 97.47,87.47 90.23,80.23 90.23,55.08 96.58,48.73 127.89,48.73 128.4,48.22 128.4,39.84 123.95,35.4 103.01,35.4 102.37,36.03 98.3,36.03 90.39,43.94 90.39,46.54 88.9,48.03 88.9,50.83 86.61,53.11 86.61,82.07 91.06,86.51 91.06,95.07 91.73,95.75 91.73,100.27 91.06,100.94 91.06,103.22 86.98,107.29 86.98,109.57 87.31,109.89 88.77,109.89
+1VALWP on TOP (solid shape): 128.43,39.86 128.43,27.24 128.08,26.89 124.71,26.89 124.21,27.4 124.21,33.91 123.76,34.36 123.76,38.19 125.68,40.11 128.18,40.11
+1VALWP on BOTTOM (solid shape): 128.41,31.7 128.41,29.54 128.1,29.24 123.76,29.24 123.63,29.36 123.63,31.59 123.83,31.78 128.33,31.78
+1VALWP on BOTTOM: 129.45,40.03 129.63,39.86 129.63,39.31 129.42,39.11 128.52,39.11 128.18,38.76 128.18,37.83 127.89,37.54 126.01,37.54 125.82,37.73 125.82,37.78 125.03,38.57 125.03,39.76 125.3,40.03
+2.5V_MEM on TOP (solid shape): 96.9,71.66 96.9,70.83 97.22,70.51 97.35,70.51 97.41,70.46 97.41,70.05 97.36,70 95,70 92.84,67.85 91.82,67.85 91.69,67.97 91.69,70.2 92.65,71.15 92.65,71.72 92.71,71.78 96.77,71.78
+2.5V_MEMP on TOP: 85.6,71.53 85.6,69.88 85.72,69.75 86.61,69.75 86.74,69.62 86.74,65.81 86.87,65.69 87.63,65.69 87.76,65.81 87.76,67.46 88.14,67.85 90.93,67.85 91.06,67.97 91.06,70.26 90.55,70.77 87.5,70.77 86.61,71.66 85.72,71.66
+2.5VOUT on TOP: 70.17,142.2 70.17,141.95 70.23,141.89 71.24,141.89 71.39,141.73 71.39,140.18 71,139.8 70.22,139.8 70.19,139.77 70.19,139.51 70.28,139.42 71.5,139.42 72.18,140.1 72.53,140.1 72.63,140.2 72.63,143.49 72.6,143.51 71.43,143.51 71.34,143.43 71.34,142.35 71.25,142.26 70.23,142.26
+2.5VSP_VIN on TOP: 87.76,60.35 88.01,60.1 88.01,56.42 87.88,56.29 86.87,56.29 86.74,56.42 86.74,62.26 86.87,62.38 87.63,62.38 87.76,62.26
+3.3V_LC on TOP: 84.9,141.38 85.09,141.19 85.09,138.71 85.03,138.65 84.65,138.65 84.58,138.71 84.58,140.93 84.45,141.06 81.98,141.06 81.92,141.12 81.92,141.32 81.98,141.38
+3.3V_TBT_SX on TOP: 81.22,145.53 81.22,145 81.28,144.93 81.51,144.93 81.89,145.32 83.36,145.32 83.49,145.44 83.49,146.2 84.02,146.74 84.02,147.23 84.33,147.54 84.33,148.21 84.18,148.36 83.62,148.36 83.57,148.31 83.57,147.09 83.44,146.97 83.12,146.97 83.06,146.9 83.06,146.08 83.03,146.05 81.74,146.05
+3V3_SYS on TOP (solid shape): 8.36,20.52 8.67,20.52 8.85,20.34 8.85,18.85 8.33,18.33 8.33,17.56 8.26,17.49 6.85,17.49 6.7,17.34 6.49,17.34 6.49,17.13 5.99,16.63 5.31,16.63 5.25,16.7 5.25,17.23 5.36,17.34 5.9,17.34 6.99,18.43 6.99,20.42 7.1,20.53 8.35,20.53
+3V_PCH on BOTTOM (solid shape): 110.92,39.21 111.2,39.04 111.48,39.21 111.49,39.23 112.73,39.23 112.74,39.23 113.04,39.23 113.39,38.89 113.39,38.43 113.28,38.33 112.78,38.33 112.6,38.51 111.85,38.51 111.63,38.29 111.1,38.29 111.04,38.23 111.02,38.23 110.85,38.08 110.82,37.85 110.82,37.78 110.74,37.78 110.64,37.68 109.44,37.68 109.37,37.75 109.37,37.77 109.36,37.78 109.36,38.68 109.92,39.23 110.91,39.23
+3V_PCH on TOP: 109.46,35.33 110.62,35.33 110.68,35.4 110.68,38.06 110.55,38.19 109.41,38.19 109.35,38.13 109.35,35.45
+3V_PCH on TOP: 103,21.43 103,18.63 102.87,18.51 102.87,14.76 103.38,14.25 104.9,14.25 105.16,14.51 105.16,15.01 104.65,15.52 104.65,21.36 104.52,21.49 103.06,21.49
+3V_PCH on BOTTOM: 114.67,34.58 114.55,34.7 113.83,34.7 113.67,34.55 111.29,34.55 111.2,34.56 111.11,34.55 110.45,34.55 110.37,34.56 110.27,34.55 109.4,34.55 109.32,34.63 109.32,35.18 109.01,35.48 108.82,35.48 108.69,35.61 108.69,36.07 108.8,36.17 117.97,36.17 118.72,35.42 119.16,35.42 119.2,35.46 119.96,35.46 120.55,34.87 120.55,30.44 120.24,30.14 119.67,30.14 119.65,30.11 119.05,30.11 118.58,29.65 118.58,29.29 118.53,29.24 117.91,29.24 117.85,29.3 117.85,30.16 118.42,30.73 119.2,30.73 119.44,30.98 119.44,33.75 119.24,33.95 118.44,33.95 117.82,34.58
+3V_PCH on IN1: 105.59,33.26 105.59,31.76 105.75,31.6 109.9,31.6 110.66,32.36 110.66,36.1 110.47,36.29 108.63,36.29
+3V_PCH on IN2: 109.53,24.82 109.53,24.83 109.51,24.94 109.53,25.06 109.53,25.07 109.53,25.83 109.49,25.92 109.39,25.93 108.94,26.21 109.39,26.5 109.49,26.51 109.53,26.59 109.53,30.22 109.53,30.23 109.51,30.36 109.53,30.49 109.53,32.34 109.14,32.73 102.24,32.73 101.92,32.41 101.92,31.32 101.3,30.7 100.99,30.53 100.69,30.7 100.22,30.7 100.21,30.68 99.98,30.47 99.68,30.52 99.62,30.56 99.6,30.59 99.54,30.63 99.25,30.58 99.06,30.7 98.91,30.7 98.78,30.6 98.62,30.57 98.3,30.46 98.03,30.67 98.02,30.7 96.64,30.7 95.75,29.81 95.75,22.83 96.77,21.81 96.77,19.27 97.02,19.02 98.87,19.02 99.97,20.12 101.61,20.12 103.4,18.32 104.27,18.32 105.53,19.59 109.53,19.59
+3VALW on BOTTOM (solid shape): 149.39,28.77 149.39,28.06 149.33,28 147,28 146.93,28.07 146.93,28.75 147.01,28.82 149.33,28.82
+3VALW on BOTTOM (solid shape): 70.55,105.5 70.55,105.37 70.48,105.31 69.53,105.31 68.58,106.26 68.14,106.26 68.07,106.33 68.07,106.83 68.14,106.9 69.15,106.9
+3VALW on GND2 (solid shape): 83.94,58.57 83.94,58.47 83.95,58.46 83.95,57.66 83.85,57.56 83.55,57.56 83.06,58.05 83.06,58.56 83.3,58.8 83.71,58.8
+3VALW on TOP: 78.11,20.11 79.68,20.11 80.16,20.59 80.16,21.19 80.39,21.42 80.42,21.42 80.42,22.32 80.66,22.56 81.13,22.56 81.38,22.3 81.38,21.5 80.96,21.08 80.96,20.33 80.85,20.22 80.56,20.22 80.19,19.85 80.19,19.42 80.12,19.36 78.07,19.36 78,19.42 78,20.01
+3VALW on TOP: 99.57,15.39 101.47,15.39 101.73,15.14 101.73,13.49 101.35,13.11 100.2,13.11 99.44,13.87 99.44,15.27
+3VALW on TOP: 83.6,58.14 83.81,57.94 84.01,57.94 84.15,57.8 84.15,56.64 84.68,56.11 87.92,56.11 87.97,56.06 87.97,55.15 87.68,54.85 84.3,54.85 82.83,56.33 82.83,58.65 82.97,58.79 83.53,58.79 83.6,58.71
+3VALW on TOP: 70.87,93.91 72.15,93.91 72.31,93.74 72.31,91.94 71.89,91.52 70.89,91.52 70.61,91.8 70.61,93.65
+3VALW on TOP: 56.77,144.93 56.77,145.82 56.64,145.95 55.75,145.95 55.63,145.82 55.63,144.68 56.41,143.9 57.31,143.9 57.58,143.63 57.58,142.97 57.15,142.53 57.15,141.19 57.38,140.96 57.82,140.96 58.04,141.18 58.04,141.53 58.59,142.09 58.59,143.92 57.85,144.66 57.04,144.66
+3VALW on TOP: 89.53,16.63 89.53,15.08 89.6,15.01 93.47,15.01 93.6,15.14 93.6,18.13 93.47,18.25 92.27,18.25 91,19.52 89.94,19.52 89.86,19.44 89.86,18.44 90.87,17.43 90.87,16.83 90.72,16.68 89.59,16.68
+3VALW on TOP: 64.01,122.84 65.28,122.84 65.41,122.71 65.41,122.07 63.82,120.49 63.54,120.49 62.97,119.92 62.23,119.92 61.98,120.17 61.98,121.1 62.97,122.09 63.26,122.09
+3VALW on BOTTOM: 88.42,20.16 90.06,20.16 90.26,20.36 91.24,20.36 91.31,20.3 91.31,17.75 91.02,17.46 89.51,17.46 89.39,17.58 89.39,18.91 89.14,19.16 88.56,19.16 88.35,19.37 88.35,20.09
+3VALW on BOTTOM: 31.62,138.98 31.34,139.26 30.84,139.26 30.57,139.52 30.57,141.26 30.66,141.35 31.23,141.35 31.43,141.55 31.43,142.17 32.56,143.31 32.56,144.29 32.37,144.48 30.77,144.48 30.33,144.92 30.33,145.96 30.71,146.34 33.6,146.34 34.99,147.73 56.96,147.73 57.47,147.22 61.4,147.22 61.85,146.78 61.85,146.08 61.65,145.88 61.65,141.32 61.53,141.2 59.99,141.2 59.68,141.52 59.43,141.52 55.06,145.89 35.88,145.89 35.05,145.06 35.05,141.39 33.48,139.82 33.48,138.48 33.12,138.13 31.8,138.13 31.62,138.31
+3VALW on BOTTOM: 68.83,12.73 70.99,12.73 71.95,13.68 76.14,13.68 76.25,13.79 76.25,15.26 75.91,15.6 75.29,15.6 74.45,16.44 74.45,19.54 73.76,20.22 68.2,20.22 68.01,20.03 68.01,16.98 68.07,16.92 69.02,16.92 69.88,16.06 69.88,14.09 69.6,13.81 68.9,13.81 68.71,13.62 68.71,12.85
+3VALW on IN1: 71.34,92.38 72.64,92.38 76.14,88.89 76.89,88.89 77.24,88.53 77.24,87.72 76.85,87.33 74.91,87.33 71.17,91.07 71.17,92.22
+3VALW on IN1: 85.38,60.62 85.79,60.21 85.79,59.13 84.34,57.67 83.36,57.67 83.05,57.99 83.05,59.24 84.43,60.62
+3VALW on IN1: 69.02,18.7 69.91,18.7 70.48,18.13 70.48,17.68 68.2,15.39 68.2,13.62 65.53,10.95 60.26,10.95 59.5,11.71 53.02,11.71 52.32,11.01 12.64,11.01 11.62,12.03 11.62,14.89 11.97,15.24 14.19,15.24 14.67,14.76 14.67,13.49 15.3,12.85 22.35,12.85 22.8,13.3 49.4,13.3 50.23,12.47 65.28,12.47 67.18,14.38 67.18,16.86
+3VALW on GND2: 82.98,22.6 80.89,22.6 80.62,22.33 80.62,21.52 80.73,21.4 80.85,21.4 81.11,21.67 81.11,21.91 81.2,22 83.01,22 83.13,22.13 83.13,22.44
+3VALW on GND2: 64.01,122.84 65.02,122.84 65.28,122.58 65.28,122.33 65.02,122.07 64.01,122.07 63.88,122.2 63.88,122.71
+3VALW on IN2: 64.01,121.82 63.88,121.95 63.88,122.96 63.18,123.66 63.18,141.12 60.01,144.3 56.52,144.3 55.88,144.93 55.88,145.95 56.39,146.46 60.58,146.46 61.09,146.97 61.72,146.97 63.25,145.44 63.31,145.44 65.47,143.28 65.47,122.07 65.21,121.82
+3VALW on IN2: 90.04,19.59 90.93,19.59 91.19,19.33 91.19,18.95 92.01,18.13 92.01,17.81 91.82,17.62 91.5,17.62 91.44,17.68 89.92,17.68 89.79,17.81 89.79,19.33
+3VALW on VCC: 69.66,11.46 69.66,18.59 70.02,18.95 77.83,18.95 81.51,22.63 130.05,22.63 130.05,18.55 128.67,17.17 84.6,17.17 78.89,11.46
+3VALW on IN3: 90.42,19.52 90.68,19.52 90.87,19.33 90.87,18.57 91.25,18.19 91.25,17.87 91.19,17.81 89.98,17.81 89.73,18.06 89.73,18.82
+3VALW on IN3: 81.03,22.76 81.03,22.13 81.41,21.74 82.55,21.74 83.06,22.25 83.06,22.42 84.58,23.94 84.58,24.49 84.12,24.95 83.21,24.95
+3VALW on IN3: 83.41,58.73 84.18,58.73 84.39,58.51 84.39,56.87 84.48,56.78 84.48,55.45 84.05,55.02 82.92,55.02 82.68,55.26 82.68,56.17 82.89,56.38 82.89,58.2
+3VALW on IN3: 61.19,146.84 61.98,146.84 62.42,147.28 63.13,147.28 63.65,146.76 63.65,145.77 63.42,145.54 61.75,145.54 60.99,146.31 60.99,146.64
+3VALW on IN3: 86.73,33.71 88.35,33.71 89.61,32.45 89.61,29.82 88.72,28.93 86.98,28.93 86.33,29.58 86.33,29.99 86.84,30.5 87.02,30.5 87.34,30.81 87.34,31.77 87.15,31.96 86.64,31.96 86.49,32.11 86.49,33.47
+3VALW on IN4: 31.88,141.57 32.58,141.57 32.96,141.19 32.96,140.93 32.61,140.59 31.46,140.59 31.37,140.68 31.37,141.06
+3VALW on IN4: 5.02,15.14 12.26,15.14 12.51,14.89 12.51,5.49 11.24,4.22 4.57,4.22 4.13,4.66 4.13,14.25
+3VALW on IN4: 55.24,146.2 56.01,146.2 57.15,145.06 57.15,144.3 56.9,144.05 55.88,144.05 54.86,145.06 54.86,145.82
+3VALW_EC on TOP (solid shape): 72.16,15.51 72.16,14.44 72,14.28 70.97,14.28 70.8,14.44 70.8,15.5 71.03,15.73 71.95,15.73
+3VALW_TBT on TOP: 77.2,132.39 78.5,132.39 78.65,132.23 78.65,131.55 78.31,131.21 77.35,131.21 77.04,131.52 77.04,132.22
+3VALW_TBT on TOP: 87.06,147.03 87.44,146.65 87.44,145.7 87.69,145.44 88.2,145.44 88.33,145.32 88.33,145.06 88.27,145 87.88,145 87.76,145.13 86.61,145.13 85.92,145.82 85.92,146.33 85.79,146.46 85.22,146.46 85.09,146.33 84.43,146.33 84.15,146.05 84.15,145.24 83.95,145.04 83.95,144.11 83.88,144.05 83.5,144.05 83.44,144.11 83.44,144.43 83.31,144.55 81.72,144.55 81.47,144.3 80.71,144.3 80.26,144.74 80.26,145.19 80.33,145.25 81.03,145.25 81.09,145.19 81.09,144.93 81.22,144.81 81.6,144.81 81.98,145.19 83.44,145.19 83.63,145.38 83.63,146.14 84.14,146.65 84.14,147.16 84.35,147.37 85.09,147.37 85.1,147.36 85.46,147.36 85.79,147.03
+3VALW_TBT on BOTTOM: 87.61,142.56 87.61,138.84 87.71,138.75 88.23,138.75 88.38,138.91 88.38,142.55 88.2,142.73 87.78,142.73
+3VALW_TBT_S5 on TOP: 83.76,149.76 85.41,148.11 85.6,148.11 86.11,147.6 87.95,147.6 91.31,144.24 91.31,143.64 91.24,143.57 90.14,143.57 89.85,143.86 89.85,144.74 88.96,145.63 87.88,145.63 87.76,145.76 87.76,146.71 87.31,147.16 85.92,147.16 85.37,147.7 84.61,147.7 84.52,147.79 84.52,148.17 84.07,148.62 82.27,148.62 82.04,148.85 82.04,149.71 82.09,149.76
+3VALWP on TOP (solid shape): 66.87,17.74 66.87,13.01 66.55,12.7 63.69,12.7 63.31,13.08 63.31,16.09 62.55,16.86 62.55,17.93 62.74,18.13 66.48,18.13
+3VALWP on BOTTOM (solid shape): 67.69,19.97 67.69,16.79 67.06,16.16 60.2,16.16 60.07,16.28 60.07,18.95 60.33,19.2 65.79,19.2 66.8,20.22 67.44,20.22
+3VLP on TOP: 60.41,24.06 59.57,24.06 59.39,23.87 59.39,22.85 59.62,22.61 60.14,22.61 60.47,22.94 60.47,24
+3VLP on BOTTOM: 85.77,11.52 85.77,9.28 85.86,9.18 89.17,9.18 89.25,9.26 89.25,12.42 89.11,12.56 87.63,12.56 87.52,12.45 87.52,11.72 87.41,11.61 85.86,11.61
+3VS on BOTTOM (solid shape): 149.4,29.71 149.4,29 149.35,28.94 146.96,28.94 146.91,28.99 146.91,29.66 147.02,29.77 149.35,29.77
+3VS on GND4 (solid shape): 73.72,12.08 73.95,12.08 74,12.13 74.21,12.13 74.3,12.04 74.3,11.58 74.17,11.46 71.75,11.46 71.63,11.58 71.63,12.28 71.75,12.41 73.39,12.41
+3VS on TOP: 102.52,142.57 104.53,142.57 104.64,142.67 104.64,145.67 104.53,145.77 103.58,145.77 103.48,145.68 102.57,145.68 102.44,145.55 102.44,142.64
+3VS on TOP: 121.41,34.19 120.52,34.19 120.4,34.32 120.4,34.95 121.16,35.71 121.16,37.24 121.92,38 121.92,38.51 122.05,38.64 122.68,38.64 124.84,40.79 124.84,41.18 125.09,41.43 125.35,41.43 125.48,41.3 125.48,40.67 122.05,37.24 122.05,34.83
+3VS on TOP: 6.6,17.17 6.79,17.36 8.89,17.36 9.04,17.51 9.04,17.94 8.99,17.98 8.68,17.98 8.56,18.1 8.56,18.38 8.65,18.47 8.65,18.5 8.67,18.52 9.52,18.52 9.57,18.47 9.57,17.52 9.59,17.5 9.72,17.36 10.16,17.36 10.29,17.24 10.29,16.86 10.16,16.73 9.53,16.73 9.02,16.22 9.02,15.71 8.83,15.52 7.81,15.52 7.68,15.39 7.68,14.95 7.62,14.89 6.73,14.89 6.6,15.01
+3VS on TOP: 70.23,14.12 72.01,14.12 72.14,14 72.14,13.36 71.88,13.11 70.99,13.11 70.36,12.47 69.85,12.47 69.6,12.73 69.6,13.49
+3VS on TOP: 63.93,133.17 63.93,131.41 64.2,131.13 67.02,131.13 67.06,131.17 67.06,131.7 67.03,131.73 66.31,131.73 66.22,131.82 66.22,131.99 66.03,132.18 66.03,132.4 66.23,132.61 66.83,132.61 66.9,132.68 66.9,133.2 66.87,133.23 65.84,133.23 65.78,133.16 65.78,132.79 65.66,132.67 64.54,132.67 64.41,132.8 64.41,133.17 64.37,133.21 63.98,133.21
+3VS on TOP: 105.37,20.98 107.14,20.98 107.21,20.91 107.21,20.18 107.06,20.03 106.71,20.03 106.61,19.92 106.61,19.01 106.57,18.97 106.01,18.97 105.97,19.02 105.97,19.84 105.92,19.89 105.33,19.89 105.28,19.93 105.28,20.89
+3VS on BOTTOM: 88.47,25.25 89.05,25.25 89.12,25.32 89.12,25.78 89.87,26.53 89.87,28.61 90.06,28.79 91.85,28.79 91.95,28.69 91.95,26.65 92.84,25.76 92.84,25.29 92.9,25.24 93.53,25.24 93.6,25.3 93.6,25.75 92.47,26.87 92.47,34.95 92.52,35 92.52,35.55 92.5,35.57 91.92,35.57 91.84,35.5 91.84,35.04 91.93,34.95 91.93,32.39 91.9,32.36 90.09,32.36 89.91,32.54 89.91,34.92 89.99,35 89.99,35.52 89.93,35.57 89.34,35.57 89.3,35.53 89.3,34.3 89.37,34.23 89.37,26.84 88.43,25.9 88.43,25.28
+3VS on BOTTOM: 103.31,20.98 105.16,20.98 105.28,21.11 107.31,21.11 107.44,20.98 107.44,20.09 107.06,19.71 103.96,19.71 103.23,20.45 103.23,20.89
+3VS on BOTTOM: 72.77,12.79 73.15,12.79 73.34,12.6 73.98,12.6 74.68,11.9 78.36,11.9 78.61,11.65 78.61,11.01 78.11,10.51 78.11,9.81 78.04,9.74 73.72,9.74 73.38,9.4 73.38,9.05 73.29,8.96 72.36,8.96 72.31,9.02 72.31,10.17 72.71,10.57 72.71,12.73
+3VS on IN2: 73.34,12.41 73.34,11.27 73.28,11.2 64.45,11.2 63.31,12.35 63.31,15.27 61.34,17.24 61.34,19.14 61.59,19.4 65.79,19.4 66.87,18.32 66.87,13.36 67.56,12.66 68.71,12.66 69.91,13.87 71.88,13.87
+3VS on VCC: 18.14,18.19 12.06,24.26 12.06,61.88 22.8,61.88 22.8,54.09 24.66,52.22 78.91,52.22 80.39,53.71 80.39,91.57 77.32,94.64 67.56,94.64 67.56,113.93 65.89,115.6 59.94,115.6 59.94,118.62 58.67,119.89 58.67,147.22 61.83,147.22 63.5,148.89 63.5,150.83 74.77,150.83 75.2,150.89 75.6,151.05 83.69,155.73 83.69,151.18 85.11,149.76 91.14,149.76 92.16,148.74 94.38,148.74 94.76,148.36 95.59,148.36 99.97,143.98 101.71,143.98 102.75,145.03 108.77,145.03 109.11,144.68 140.31,144.68 141.2,145.57 143.94,145.57 144.35,145.39 144.8,145.33 151.83,145.33 151.83,118.46 140.88,118.46 131.06,128.28 131.06,131.71 126.34,136.43 108.71,136.43 108.71,140.15 106.91,141.95 74.76,141.95 70.93,138.12 70.93,132.07 73.03,129.97 73.03,107.49 82.8,97.71 82.8,52.95 88.1,47.65 105.26,47.65 105.39,47.78 124.69,47.78 125.55,46.92 125.55,31.82 124.05,30.32 91.21,30.32 89.24,28.35 87.67,28.35 87.23,28.79 70.89,28.79 63.5,21.41 63.5,18.93 62.76,18.19 ; 1 cut-out
+3VS on IN3: 6.73,23.01 6.73,22.1 7.87,20.95 7.87,17.43 9.27,16.03 11.94,16.03 12.19,16.28 12.19,16.66 11.18,17.68 11.18,21.87 13.21,23.9 13.21,25.81 12.95,26.06 9.78,26.06
+3VS_CAMERA on BOTTOM (solid shape): 80.61,14.22 80.61,12.74 80.55,12.68 78.67,12.68 78.58,12.77 78.58,14.17 78.73,14.32 80.5,14.32
+3VS_DP on TOP: 105.42,145.59 105.42,142.88 105.58,142.71 106.7,142.71 106.83,142.84 106.83,143.49 106.96,143.62 108.26,143.62 108.38,143.74 108.38,144.49 110.24,146.35 110.24,149.44 110.81,150.01 117.03,150.01 117.16,149.89 117.16,149.13 117.41,148.87 117.86,148.87 118.05,149.06 118.05,150.97 117.67,151.35 110.3,151.35 108.52,149.57 108.52,146.46 108.27,146.2 106.96,146.2 106.54,145.78 105.6,145.78
+3VS_SSD on TOP: 118.24,10.06 119.51,10.06 119.63,10.19 119.63,12.73 119.25,13.11 118.24,13.11 117.98,12.85 117.98,10.31
+3VS_SSD on TOP: 107.31,11.84 107.31,10.19 107.82,9.68 112.52,9.68 113.41,10.57 113.41,12.6 112.9,13.11 108.58,13.11
+3VS_SSD on TOP: 132.08,9.66 136.76,9.66 136.9,9.79 136.9,13.17 136.68,13.39 129.55,13.39 129.4,13.24 129.4,11.98 129.61,11.77 131.79,11.77 131.95,11.61 131.95,9.79
+3VS_SSD on TOP: 90.24,14.79 95.85,14.79 96.09,14.56 96.09,13.64 95.89,13.44 95.07,13.44 94.8,13.17 94.8,9.94 94.72,9.86 92.56,9.86 92.4,10.02 92.4,12.62 92.24,12.78 90.55,12.78 90.15,13.18 90.15,14.71
+3VS_SSD on BOTTOM: 133.83,12.88 129.65,12.88 129.47,12.69 129.47,11.89 129.29,11.71 127.89,11.71 127.64,11.46 127.64,10.82 127.8,10.65 131.65,10.65 132.5,9.81 133.85,9.81 134.01,9.97 134.01,12.7
+3VS_SSD on BOTTOM: 113.16,13.24 113.67,13.74 115.19,13.74 115.32,13.62 115.32,11.2 115.19,11.08 113.67,11.08 113.03,11.71 110.24,11.71 110.11,11.84 110.11,12.35 111,13.24
+3VS_SSD on BOTTOM: 92.3,13.1 92.3,10.7 92.37,10.63 94.45,10.63 94.49,10.67 94.49,11.6 94.45,11.64 94.18,11.64 94.03,11.79 94.03,12.96 93.82,13.16 92.36,13.16
+3VS_SSD on BOTTOM: 118.49,13.49 119.51,13.49 119.63,13.36 119.63,10.95 119.51,10.82 118.75,10.82 118.11,11.46 118.11,13.11
+3VS_SSD on IN3: 92.96,12.22 92.96,11.71 93,11.68 93,10.09 93.54,9.55 111.82,9.55 112.71,10.44 115.89,10.44 116.14,10.19 131.83,10.19 132.59,10.95 132.59,12.85 132.33,13.11 128.4,13.11 127.64,12.35 120.4,12.35 117.67,15.08 106.68,15.08 105.73,14.12 103.57,14.12 102.04,12.6 93.34,12.6
+3VS_TOUCH on BOTTOM: 93.98,20.46 95,20.46 95.4,20.86 96.13,20.86 96.19,20.81 96.19,18.32 96.1,18.23 94.98,18.23 94.85,18.11 94.85,17.7 94.86,17.7 94.86,17.24 94.77,17.15 94.11,17.15 94.06,17.2 94.06,17.8 93.93,17.93 93.93,20.41
+5V_TOBII on IN1: 82.33,22.55 83.25,23.46 83.25,26.76 83.69,27.21 83.69,33.37 79.69,37.37 79.69,52.16 77.28,54.57 76.71,54.57 76.45,54.32 76.45,53.24 77.72,51.97 77.72,36.22 81.79,32.16 81.79,27.78 81.66,27.65 81.66,23.21 81.39,22.93 81.39,22.67 81.51,22.55
+5V_TOBII on IN2: 68.2,118.33 71.95,118.33 72.64,117.63 76.83,117.63 78.61,119.41 80.33,119.41 80.45,119.28 80.45,118.52 78.36,116.42 71.69,116.42 70.87,117.25 68.07,117.25 67.88,117.44 67.88,118.01
+5V_TOBII on IN3: 76.45,53.69 76.58,53.56 77.41,53.56 77.6,53.75 77.6,60.16 78.04,60.61 78.04,68.48 78.99,69.43 78.99,70.77 80.52,72.29 80.58,72.29 81.41,73.12 81.41,89.37 79.08,91.7 79.08,94.36 70.54,102.91 70.54,116.06 68.33,118.26 67.82,118.26 66.23,116.68 66.23,104.87 77.28,93.82 77.28,89.47 79.57,87.19 79.57,75.97 78.49,74.89 78.49,72.35 76.96,70.83 76.96,70 76.45,69.5
+5V_TOBII on GND4: 80.07,120.3 80.39,120.3 80.52,120.17 80.52,118.52 80.39,118.39 80.07,118.39 79.95,118.52 79.95,120.17
+5V_TOBII on IN4: 79.95,121.57 79.95,119.47 80.07,119.34 80.9,119.34 81.79,120.23 81.79,128.49 84.26,130.96 102.93,130.96 104.39,132.43 106.24,132.43 107.25,131.41 111.63,131.41 113.28,133.06 122.94,133.06 123.63,133.76 125.67,133.76 126.43,133 134.94,133 136.59,131.35 139.13,131.35 139.76,130.71 142.62,130.71 143.57,131.66 143.57,133.89 144.65,134.97 144.65,140.36 143.19,141.82 142.68,141.82 142.37,141.51 142.37,140.93 143.61,139.7 143.61,136.14 142.88,135.41 142.88,134.52 141.03,132.68 137.1,132.68 135.45,134.33 129.1,134.33 128.71,134.71 121.54,134.71 120.97,134.14 112.71,134.14 111.06,132.49 108.2,132.49 107.06,133.63 103.89,133.63 102.43,132.17 83.82,132.17 80.45,128.81 80.45,122.07
+5VALW on TOP (solid shape): 78.34,58.95 78.34,58.09 78.18,57.92 77.48,57.92 77.32,58.08 77.32,58.97 77.54,59.19 78.1,59.19
+5VALW on TOP (solid shape): 151.19,43.53 151.19,41.94 150.94,41.68 149.03,41.68 148.97,41.75 148.97,42.36 149.01,42.4 149.49,42.4 149.67,42.57 149.67,43.33 149.92,43.59 151.13,43.59
+5VALW on TOP (solid shape): 136.46,33.75 136.46,32.32 136.26,32.12 135.09,32.12 134.92,32.29 134.92,32.98 135.19,33.25 135.19,33.75 135.32,33.87 136.33,33.87
+5VALW on TOP (solid shape): 6.16,16.22 6.16,14.95 6.41,14.7 7.75,14.7 7.94,14.89 7.94,15.27 8,15.33 8.26,15.33 8.32,15.27 8.32,14.32 8.06,14.06 3.75,14.06 3.56,14.25 3.53,14.25 3.37,14.29 3.2,14.25 3.2,14.25 3.11,14.34 3.11,16.11 3.36,16.36 6.02,16.36
+5VALW on BOTTOM (solid shape): 146.81,28.76 146.81,27.36 146.68,27.24 145.39,27.24 145.25,27.09 144.75,27.09 144.49,27.35 144.49,28.78 144.58,28.87 146.7,28.87
+5VALW on BOTTOM (solid shape): 63.94,14.76 66.93,14.76 66.99,14.7 66.99,13.93 67.31,13.62 67.31,12.79 67.25,12.73 64.14,12.73 63.88,12.47 59.56,12.47 59.37,12.66 59.37,15.52 59.56,15.71 62.99,15.71
+5VALW on IN1 (solid shape): 81.03,57.81 81.26,57.56 81.53,57.77 81.92,57.77 83.06,56.62 83.8,56.62 84.66,55.77 84.66,54.64 84.48,54.47 83.22,54.47 81.19,56.5 78.79,56.5 77.33,57.96 77.33,58.45 77.44,58.56 80.27,58.56
+5VALW on TOP: 88.58,56.53 89.47,56.53 89.8,56.2 89.8,55.73 89.31,55.23 88.54,55.23 88.24,55.54 88.24,56.19
+5VALW on TOP: 84.33,23.65 84.33,23.27 84.07,23.01 83.57,23.01 83.44,22.89 83.44,21.24 83.31,21.11 81.79,21.11 81.53,21.36 81.53,22.25 82.42,23.14 82.42,24.16 81.92,24.67 81.66,24.67 81.41,24.92 81.41,25.3 81.53,25.43 82.04,25.43 82.8,24.67 84.2,24.67 85.34,25.81 86.36,25.81 86.49,25.68 86.49,25.17 85.09,23.78 84.45,23.78
+5VALW on TOP: 89.66,85.12 90.42,85.12 90.55,84.99 90.55,84.36 90.42,84.23 90.04,84.23 89.92,84.36 88.9,84.36 88.77,84.23 88.14,84.23 87.88,84.48 87.88,85.24 88.39,85.75 89.03,85.75
+5VALW on BOTTOM: 6.28,12.59 8.46,12.59 8.49,12.61 8.49,14.14 8.17,14.45 5.18,14.45 4.76,14.87 4.76,16.54 5.02,16.79 5.46,16.79 5.59,16.66 5.59,16.03 5.71,15.9 6.03,15.9 6.1,15.97 6.1,16.73 6.54,17.17 6.54,18.63 6.29,18.89 1.84,18.89 1.46,18.51 1.46,11.84 1.7,11.6 6.04,11.6 6.11,11.66 6.11,12.42
+5VALW on BOTTOM: 98.52,140.19 98.52,137.46 98.75,137.22 101.22,137.22 101.89,136.55 107.89,136.55 108.14,136.8 108.14,138.92 108.05,139.01 101.41,139.01 101.22,139.2 101.22,139.79 101.03,139.98 99.89,139.98 99.61,140.26 98.59,140.26
+5VALW on IN1: 149.99,43.84 151.13,43.84 151.26,43.72 151.26,40.29 150.5,39.52 145.41,39.52 143.76,41.18 141.1,41.18 140.84,41.43 140.84,42.57 140.97,42.7 143.76,42.7 145.8,40.67 149.35,40.67 149.86,41.18 149.86,43.72
+5VALW on VCC: 5.12,11.46 3.81,12.77 3.81,17.51 4.89,18.59 4.89,46.91 7.37,49.39 7.37,64.04 11.56,64.04 11.56,24.05 17.93,17.68 62.97,17.68 64.01,18.72 64.01,21.2 71.1,28.29 87.02,28.29 87.46,27.84 89.45,27.84 91.42,29.81 124.27,29.81 126.11,31.65 126.11,47.08 124.9,48.29 105.18,48.29 105.05,48.16 88.31,48.16 83.31,53.16 83.31,97.92 73.53,107.7 73.53,130.18 71.44,132.28 71.44,137.91 74.97,141.44 106.7,141.44 108.2,139.94 108.2,136.43 87.97,136.43 80.96,129.42 80.96,127.03 77.36,127.03 76.58,126.24 76.58,111.56 91,97.14 91,55.87 94.38,52.48 137.31,52.48 141.48,48.31 141.48,39.92 139.55,37.99 139.55,32.49 130.2,23.14 81.3,23.14 77.62,19.46 69.81,19.46 69.15,18.8 69.15,11.46
+5VALW on IN4: 145.35,27.33 142.75,24.73 136,24.73 133.29,27.45 133.29,32.95 133.64,33.3 136.4,33.3 137.03,32.67 137.03,28.86 138.4,27.49 140.39,27.49 141.99,29.09 144.17,29.09 145.35,27.9
+5VALW on IN4: 90.61,24.28 91.38,24.28 91.69,23.97 91.69,19.2 91.57,19.08 91.19,19.08 91.12,19.14 91.12,19.33 90.87,19.59 90.36,19.59 89.66,18.89 89.66,18.19 89.53,18.06 89.15,18.06 89.03,18.19 89.03,19.71 90.3,20.98 90.3,23.97
+5VALWP on TOP (solid shape): outline of 89 points within 52.9,13.74 60.2,19.4
+5VALWP on BOTTOM (solid shape): 58.61,15.39 58.61,12.47 58.55,12.41 53.34,12.41 53.09,12.66 53.09,15.59 53.21,15.71 58.29,15.71
+5VS on TOP (solid shape): 3.9,64.1 3.61,63.81 3.36,63.81 3.36,63.57 3.23,63.43 3.23,62.98 2.45,62.98 2.45,62.17 3.23,62.17 3.23,61.46 3.16,61.39 1.81,61.39 1.65,61.55 1.65,61.67 1.79,61.92 1.65,62.16 1.63,62.17 1.63,63.59 2.51,64.48 3.9,64.48
