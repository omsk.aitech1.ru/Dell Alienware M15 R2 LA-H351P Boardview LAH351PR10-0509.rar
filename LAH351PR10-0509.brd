# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CS#0: length 68.3
  TOP w0.081: UC1.AD5 113,87.1 113.58,87.1 114,86.69 114,84.56 116.69,81.87 118.28,81.87 118.64,81.5 v10(118.64,81.28) 118.85,81.07 122.2,81.07 122.71,80.57 v6(122.94,80.57)
  TOP w0.122: UD3.L7 v6(135.71,63.05) ; UD4.L7 v6(125.32,63.05)
  IN4 w0.086: v6(122.94,80.57) 122.94,75.08 122.62,74.14 122.62,66.82 123,65.89 123.16,64.03 123.16,64 123.18,63.95 124.37,62.77 124.73,62.77 125.21,63.05 v6(125.32,63.05) 125.32,62.89 125.41,62.8 125.52,62.8 125.6,62.89 125.6,63.06 125.67,63.12 125.83,63.12 125.91,63.04 125.91,62.6 126,62.51 126.16,62.51 126.25,62.6 126.25,63.08 126.33,63.16 126.5,63.16 126.59,63.08 126.59,62.6 126.68,62.51 126.85,62.51 126.94,62.6 126.94,62.91 127.02,62.99 127.58,62.99 127.79,62.79 v7(127.79,62.66) 128.07,62.66 128.22,62.51 128.52,62.51 128.91,62.89 129.98,62.89 130.06,62.81 130.06,62.57 130.15,62.49 130.32,62.49 130.41,62.57 130.41,62.81 130.49,62.89 130.67,62.89 130.75,62.81 130.75,62.55 130.84,62.46 131.01,62.46 131.1,62.55 131.1,62.81 131.18,62.89 134.77,62.89 134.92,62.74 135.4,62.74 v6(135.71,63.05) 135.74,63.02 135.74,62.78 135.82,62.69 136.36,62.69 136.42,62.75 136.42,63.05 136.55,63.17 136.55,63.24 136.65,63.33 136.86,63.33 136.96,63.23 136.96,63.12 136.87,63.03 136.87,62.91 137.01,62.77 137.16,62.77 137.24,62.84 v7(137.24,62.97) 137.3,62.91 137.97,62.91 138.12,62.77 138.4,62.77 138.53,62.64 138.63,62.54 138.94,62.54 139.36,62.96 142.33,62.96 v7(142.84,63.46)
  BOTTOM w0.122: v7(137.24,62.97) 135.18,62.97 UD1.L7 ; v7(127.79,62.66) 127.51,62.94 124.81,62.94 UD2.L7
DDR_A_D0: length 31.6
  IN1 w0.058: v8(136.15,87.98) 136.21,87.91 136.91,87.91 137.41,87.4 137.41,86.49 139.63,84.27 139.63,83.95 139.57,83.89 139.2,83.89 139.15,83.83 139.15,83.71 139.2,83.65 139.57,83.65 139.63,83.6 139.63,83.48 139.57,83.42 139.2,83.42 139.15,83.36 139.15,83.25 139.2,83.19 139.57,83.19 139.63,83.13 139.63,83.01 139.57,82.95 139.2,82.95 139.15,82.89 139.15,82.78 139.2,82.72 139.57,82.72 139.63,82.66 139.63,77.31 142.84,74.1 142.84,69.21 139.87,66.24 139.79,66.24 139.65,66.37 139.57,66.37 139.49,66.29 139.49,66.2 139.62,66.07 139.62,65.99 139.38,65.75 138.94,65.75 138.75,65.56 138.75,65.1 v8(138.3,64.65)
DDR_A_D1: length 31
  IN1 w0.058: v8(136.81,88.38) 137.6,87.59 137.6,86.67 139.89,84.38 139.89,80.56 139.95,80.5 140.2,80.5 140.26,80.45 140.26,80.33 140.2,80.27 139.95,80.27 139.89,80.21 139.89,80.09 139.95,80.04 140.2,80.04 140.26,79.98 140.26,79.86 140.2,79.8 139.95,79.8 139.89,79.74 139.89,79.63 139.95,79.57 140.2,79.57 140.26,79.51 140.26,79.39 140.2,79.34 139.95,79.34 139.89,79.28 139.89,79.16 139.95,79.1 140.2,79.1 140.26,79.04 140.26,78.93 140.2,78.87 139.95,78.87 139.89,78.81 139.89,78.69 139.95,78.63 140.2,78.63 140.26,78.58 140.26,78.46 140.2,78.4 139.95,78.4 139.89,78.34 139.89,78.23 139.95,78.17 140.2,78.17 140.26,78.11 140.26,77.99 140.2,77.93 139.95,77.93 139.89,77.87 139.89,77.42 143.1,74.21 143.1,69.09 139.46,65.45 v8(139.1,65.45)
DDR_A_D2: length 30.1
  TOP w0.081: UC1.BP3 v8(135.19,86.58)
  IN1 w0.058: v8(135.19,86.58) 135.19,85.5 135.32,85.37 135.74,85.37 136.85,84.27 136.85,79.64 136.9,79.58 137.15,79.58 137.21,79.53 137.21,79.41 137.15,79.35 136.9,79.35 136.85,79.29 136.85,79.13 136.9,79.07 137.15,79.07 137.21,79.01 137.21,78.9 137.15,78.84 136.9,78.84 136.85,78.78 136.85,78.66 136.9,78.61 137.15,78.61 137.21,78.55 137.21,76.92 140.83,73.31 140.83,70.01 138.79,67.97 134.61,67.97 133.99,67.35 133.99,66.56 v8(134.3,66.25)
DDR_A_D3: length 29.4
  IN1 w0.058: v8(136.16,86.17) 136.38,86.39 136.91,86.39 138.62,84.67 138.62,80.18 138.68,80.12 139.05,80.12 139.11,80.06 139.11,79.95 139.05,79.89 138.68,79.89 138.62,79.83 138.62,79.71 138.68,79.66 139.05,79.66 139.11,79.6 139.11,79.48 139.05,79.42 138.68,79.42 138.62,79.36 138.62,79.25 138.68,79.19 139.05,79.19 139.11,79.13 139.11,79.01 139.05,78.95 138.68,78.95 138.62,78.9 138.62,78.78 138.68,78.72 139.05,78.72 139.11,78.66 139.11,78.55 139.05,78.49 138.68,78.49 138.62,78.43 138.62,78.31 138.68,78.25 139.05,78.25 139.11,78.19 139.11,78.08 139.05,78.02 138.68,78.02 138.62,77.96 138.62,77.58 142.32,73.88 142.32,69.45 139.67,66.81 138.55,66.81 v8(138.3,67.05)
DDR_A_D4: length 31.8
  TOP w0.081: UD3.J3 134.9,64.85 v8(134.75,64.85)
  IN1 w0.058: v8(134.75,64.85) 134.72,64.87 134.29,64.87 133.86,65.31 133.86,65.59 133.41,66.04 133.41,67.41 134.37,68.37 138.45,68.37 140.2,70.12 140.2,73.2 136.32,77.07 136.32,84.05 135.41,84.97 135.15,84.97 134.64,85.48 134.64,86.49 134.56,86.58 134.56,87.11 v8(134.98,87.53)
DDR_A_D5: length 31.4
  IN1 w0.058: v8(135.47,88.08) 136.34,87.21 136.91,87.21 137.18,86.94 137.18,86.43 138.88,84.73 138.88,82.38 138.94,82.33 139.13,82.33 139.19,82.27 139.19,82.15 139.13,82.09 138.94,82.09 138.88,82.03 138.88,81.92 138.94,81.86 139.31,81.86 139.37,81.8 139.37,81.68 139.31,81.62 138.94,81.62 138.88,81.57 138.88,81.45 138.94,81.39 139.31,81.39 139.37,81.33 139.37,81.22 139.31,81.16 138.94,81.16 138.88,81.1 138.88,80.98 138.94,80.92 139.31,80.92 139.37,80.86 139.37,80.75 139.31,80.69 138.94,80.69 138.88,80.63 138.88,80.51 138.94,80.46 139.31,80.46 139.37,80.4 139.37,77.2 142.58,73.99 142.58,69.32 139.9,66.64 139.04,66.64 138.3,65.9 v8(138.3,65.45)
DDR_A_D6: length 29.6
  IN1 w0.058: v8(135.1,65.45) 135.1,65.84 134.37,66.58 134.37,67.52 134.63,67.78 138.97,67.78 141.15,69.96 141.15,73.36 137.47,77.03 137.47,79.85 137.41,79.91 137.17,79.91 137.11,79.97 137.11,80.09 137.17,80.14 137.41,80.14 137.47,80.2 137.47,80.32 137.41,80.38 137.17,80.38 137.11,80.44 137.11,80.55 137.17,80.61 137.41,80.61 137.47,80.67 137.47,84.01 135.96,85.52 135.55,85.52 v8(135.47,85.61)
DDR_A_D7: length 29.8
  IN1 w0.058: v8(134.89,86.09) 134.89,85.49 135.23,85.14 135.6,85.14 136.58,84.16 136.58,78.29 136.64,78.23 136.87,78.23 136.93,78.18 136.93,78.06 136.87,78 136.64,78 136.58,77.94 136.58,77.82 136.64,77.77 136.87,77.77 136.93,77.71 136.93,77.59 136.87,77.53 136.64,77.53 136.58,77.47 136.58,77.18 140.51,73.25 140.51,70.06 138.61,68.16 134.59,68.16 133.6,67.17 133.6,66.15 v8(134.3,65.45)
DDR_A_D8: length 19.9
  IN1 w0.058: v8(133.57,86.74) 133.82,86.49 133.82,85.67 135.57,83.92 135.57,76.8 138.5,73.86 138.5,72.02 138.65,71.88 138.73,71.88 138.85,71.99 138.93,71.99 139.01,71.91 139.01,71.83 138.89,71.71 138.89,71.63 138.98,71.55 139.06,71.55 139.18,71.66 139.26,71.66 139.34,71.58 139.34,71.5 139.22,71.38 139.22,71.3 139.37,71.15 139.37,70.52 v8(139.1,70.25)
DDR_A_D9: length 20.8
  IN1 w0.058: v8(139.1,69.45) 139.1,69.74 139.66,70.29 139.66,71.75 138.77,72.64 138.77,73.97 135.83,76.91 135.83,83.97 134.49,85.31 134.49,85.88 134.3,86.07 134.18,86.07 133.99,86.26 133.99,86.97 v8(133.57,87.39)
DDR_A_D10: length 19.2
  IN1 w0.058: v8(138.3,68.65) 138.3,68.99 138.82,69.5 138.82,71.33 138.24,71.91 138.24,73.75 135.3,76.69 135.3,83.86 134.11,85.05 134.01,85.05 v8(133.62,85.44)
DDR_A_D11: length 17.3
  IN1 w0.058: v8(134,84.79) 135.04,83.74 135.04,76.58 137.98,73.65 137.98,71.8 138.56,71.22 138.56,69.71 v8(138.3,69.45)
DDR_A_D12: length 20.6
  IN1 w0.058: v8(132.79,86.74) 132.52,86.48 132.52,85.24 132.65,85.12 132.65,84.1 133.15,83.6 133.15,80.46 133.21,80.4 133.31,80.4 133.37,80.34 133.37,80.22 133.31,80.17 133.21,80.17 133.15,80.11 133.15,79.99 133.21,79.93 133.31,79.93 133.37,79.87 133.37,79.76 133.31,79.7 133.21,79.7 133.15,79.64 133.15,79.52 133.21,79.46 133.31,79.46 133.37,79.41 133.37,79.29 133.31,79.23 133.21,79.23 133.15,79.17 133.15,79.06 133.21,79 133.31,79 133.37,78.94 133.37,78.82 133.31,78.76 133.21,78.76 133.15,78.71 133.15,78.59 133.21,78.53 133.31,78.53 133.37,78.47 133.37,78.35 133.31,78.3 133.21,78.3 133.15,78.24 133.15,78.12 133.21,78.06 133.31,78.06 133.37,78 133.37,75.89 135.17,74.09 135.17,71.46 135.41,71.23 135.41,70.84 134.43,69.87 134.43,69.58 v8(134.3,69.45)
DDR_A_D13: length 20.7
  IN1 w0.058: v8(132.79,87.39) 132.33,86.94 132.33,85.12 132.46,84.99 132.46,84.04 132.89,83.61 132.89,77.76 132.95,77.7 133.05,77.7 133.11,77.64 133.11,77.53 133.05,77.47 132.95,77.47 132.89,77.41 132.89,77.29 132.95,77.23 133.05,77.23 133.11,77.17 133.11,77.06 133.05,77 132.95,77 132.89,76.94 132.89,76.82 132.95,76.77 133.05,76.77 133.11,76.71 133.11,76.59 133.05,76.53 132.95,76.53 132.89,76.47 132.89,76.36 132.95,76.3 133.05,76.3 133.11,76.24 133.11,76.12 133.05,76.06 132.95,76.06 132.89,76.01 132.89,75.72 133.06,75.55 133.15,75.55 133.2,75.61 133.28,75.61 133.37,75.52 133.37,75.44 133.31,75.38 133.31,75.3 133.39,75.22 133.48,75.22 133.53,75.27 133.61,75.27 133.7,75.19 133.7,75.11 133.64,75.05 133.64,74.97 133.72,74.89 133.81,74.89 133.86,74.94 133.94,74.94 134.03,74.86 134.03,74.78 133.97,74.72 133.97,74.64 134.05,74.56 134.14,74.56 134.19,74.61 134.28,74.61 134.36,74.53 134.36,74.45 134.3,74.39 134.3,74.31 134.39,74.23 134.47,74.23 134.52,74.28 134.61,74.28 134.69,74.2 134.69,74.12 134.63,74.06 134.63,73.98 134.77,73.84 134.77,73.53 134.83,73.47 134.85,73.47 134.91,73.41 134.91,73.29 134.85,73.24 134.83,73.24 134.77,73.18 134.77,73.06 134.83,73 134.85,73 134.91,72.94 134.91,72.83 134.85,72.77 134.83,72.77 134.77,72.71 134.77,72.59 134.83,72.53 134.85,72.53 134.91,72.48 134.91,72.36 134.85,72.3 134.83,72.3 134.77,72.24 134.77,72.13 134.83,72.07 134.85,72.07 134.91,72.01 134.91,71.89 134.85,71.83 134.83,71.83 134.77,71.77 134.77,71.38 v8(135.1,71.05)
DDR_A_D14: length 18.5
  IN1 w0.058: v8(133.22,84.79) 133.22,84.23 133.89,83.56 133.89,83.17 133.83,83.11 133.78,83.11 133.72,83.05 133.72,82.94 133.78,82.88 133.83,82.88 133.89,82.82 133.89,82.7 133.83,82.65 133.78,82.65 133.72,82.59 133.72,82.47 133.78,82.41 133.83,82.41 133.89,82.35 133.89,82.24 133.83,82.18 133.78,82.18 133.72,82.12 133.72,82 133.78,81.94 133.83,81.94 133.89,81.89 133.89,81.77 133.83,81.71 133.78,81.71 133.72,81.65 133.72,81.54 133.78,81.48 133.83,81.48 133.89,81.42 133.89,76.11 136.32,73.68 136.32,72.2 136.26,72.14 136.05,72.14 135.99,72.08 135.99,71.96 136.05,71.9 136.26,71.9 136.32,71.84 136.32,70.88 135.1,69.66 v8(135.1,69.45)
DDR_A_D15: length 18.8
  IN1 w0.058: v8(135.1,68.65) 134.75,69 134.75,69.69 135.67,70.61 135.67,71.34 135.43,71.57 135.43,74.2 133.63,76 133.63,80.62 133.57,80.67 133.52,80.67 133.46,80.73 133.46,80.85 133.52,80.91 133.57,80.91 133.63,80.97 133.63,81.08 133.57,81.14 133.52,81.14 133.46,81.2 133.46,83.68 132.84,84.29 132.84,85.38 v8(132.79,85.44)
DDR_A_D16: length 33
  IN4 w0.058: v7(139.1,66.25) 139.49,66.64 140.27,66.64 141.77,68.14 141.77,74.35 138.75,77.37 138.75,86.45 138.81,86.51 139.05,86.51 139.11,86.57 139.11,86.68 139.05,86.74 138.81,86.74 138.75,86.8 138.75,86.92 138.81,86.98 139.05,86.98 139.11,87.03 139.11,87.15 139.05,87.21 138.81,87.21 138.75,87.27 138.75,87.39 138.81,87.44 139.05,87.44 139.11,87.5 139.11,87.62 139.05,87.68 138.81,87.68 138.75,87.74 138.75,87.85 138.81,87.91 139.05,87.91 139.11,87.97 139.11,88.09 139.05,88.14 138.81,88.14 138.75,88.2 138.75,88.32 138.81,88.38 139.05,88.38 139.11,88.44 139.11,88.55 139.05,88.61 138.81,88.61 138.75,88.67 138.75,88.79 138.81,88.85 139.05,88.85 139.11,88.9 139.11,89.02 139.05,89.08 138.81,89.08 138.75,89.14 138.75,89.25 138.81,89.31 139.05,89.31 139.11,89.37 139.11,89.49 139.05,89.55 138.81,89.55 138.75,89.61 138.75,89.99 137.5,91.24 v6(136.81,91.24)
DDR_A_D17: length 33.9
  IN4 w0.058: v6(136.16,91.24) 136.52,91.59 137.54,91.59 139.37,89.76 139.37,86.17 139.31,86.11 139.07,86.11 139.01,86.05 139.01,85.94 139.07,85.88 139.31,85.88 139.37,85.82 139.37,85.7 139.31,85.64 139.07,85.64 139.01,85.59 139.01,85.47 139.07,85.41 139.31,85.41 139.37,85.35 139.37,85.24 139.31,85.18 139.07,85.18 139.01,85.12 139.01,85 139.07,84.94 139.31,84.94 139.37,84.88 139.37,84.77 139.31,84.71 139.07,84.71 139.01,84.65 139.01,77.48 142.03,74.46 142.03,68.03 139.88,65.88 138.73,65.88 v7(138.3,65.45)
DDR_A_D18: length 31.5
  IN4 w0.058: v6(136.81,90.45) 136.94,90.33 136.94,90.12 137.6,89.46 137.6,76.22 140.26,73.56 140.26,68.31 139.74,67.79 136.32,67.79 135.76,67.24 135.76,65.05 135.36,64.65 v7(135.1,64.65)
DDR_A_D19: length 31.9
  IN4 w0.058: v6(136.16,89.66) 137.34,88.49 137.34,83.98 137.28,83.92 137.02,83.92 136.96,83.86 136.96,83.75 137.02,83.69 137.28,83.69 137.34,83.63 137.34,83.51 137.28,83.45 137.02,83.45 136.96,83.4 136.96,83.28 137.02,83.22 137.28,83.22 137.34,83.16 137.34,83.05 137.28,82.99 137.02,82.99 136.96,82.93 136.96,82.81 137.02,82.75 137.28,82.75 137.34,82.7 137.34,76.11 139.36,74.09 139.36,72.69 139.86,72.19 139.86,70.16 139.97,70.04 139.97,68.28 139.67,67.97 136.21,67.97 135.51,67.27 135.51,65.56 135.4,65.45 v7(135.1,65.45)
DDR_A_D20: length 34
  IN4 w0.058: v6(135.51,91.24) 136.06,91.79 137.72,91.79 139.63,89.87 139.63,84.41 139.57,84.35 139.33,84.35 139.27,84.29 139.27,84.18 139.33,84.12 139.57,84.12 139.63,84.06 139.63,83.94 139.57,83.88 139.33,83.88 139.27,83.82 139.27,83.71 139.33,83.65 139.57,83.65 139.63,83.59 139.63,83.47 139.57,83.42 139.33,83.42 139.27,83.36 139.27,77.59 142.3,74.57 142.3,67.92 140.12,65.75 139.96,65.75 139.94,65.73 139.38,65.73 v7(139.1,65.45)
DDR_A_D21: length 35.1
  IN4 w0.058: v7(138.3,64.65) 138.58,64.92 139.76,64.92 142.56,67.72 142.56,74.68 139.89,77.34 139.89,89.98 137.9,91.98 135.6,91.98 v6(134.86,91.24)
DDR_A_D22: length 32.2
  IN4 w0.058: v6(135.51,89.66) 136.91,88.27 136.91,86.23 136.85,86.17 136.51,86.17 136.45,86.11 136.45,85.99 136.51,85.93 136.85,85.93 136.91,85.87 136.91,85.76 136.85,85.7 136.51,85.7 136.45,85.64 136.45,85.52 136.51,85.47 136.85,85.47 136.91,85.41 136.91,85.29 136.85,85.23 136.51,85.23 136.45,85.17 136.45,85.06 136.51,85 136.85,85 136.91,84.94 136.91,84.82 136.85,84.76 136.51,84.76 136.45,84.71 136.45,84.59 136.51,84.53 136.95,84.53 137.01,84.47 137.01,84.36 136.95,84.3 136.51,84.3 136.45,84.24 136.45,76.63 139.1,73.98 139.1,72.58 139.6,72.08 139.6,70.05 139.71,69.94 139.71,68.48 139.4,68.16 135.76,68.16 135.1,67.5 v7(135.1,67.05)
DDR_A_D23: length 32.9
  IN4 w0.058: v6(134.86,89.66) 136.19,88.33 136.19,87.89 136.25,87.83 136.59,87.83 136.64,87.77 136.64,87.66 136.59,87.6 136.25,87.6 136.19,87.54 136.19,87.42 136.25,87.36 136.59,87.36 136.64,87.31 136.64,87.19 136.59,87.13 136.25,87.13 136.19,87.07 136.19,86.96 136.25,86.9 136.59,86.9 136.64,86.84 136.64,86.72 136.59,86.66 136.25,86.66 136.19,86.61 136.19,76.52 138.83,73.88 138.83,72.47 139.33,71.97 139.33,69.94 139.45,69.83 139.45,68.58 139.22,68.35 135.26,68.35 134.85,67.95 134.85,67.89 134.68,67.72 134.68,65.83 v7(134.3,65.45)
DDR_A_D24: length 24.9
  IN4 w0.058: v7(139.1,69.45) 138.87,69.68 138.87,71.26 137.67,72.46 137.67,74.38 135.73,76.33 135.73,88.08 134.44,89.36 134.44,91.14 v6(133.56,92.02)
DDR_A_D25: length 24.8
  IN4 w0.058: v7(138.3,68.65) 138.61,68.96 138.61,71.15 137.37,72.38 137.37,74.31 135.46,76.22 135.46,87.88 134.22,89.13 134.22,90.58 v6(133.56,91.24)
DDR_A_D26: length 22.4
  IN4 w0.058: v6(133.56,89.66) 133.56,89.35 135.2,87.71 135.2,76.11 137.11,74.2 137.11,73.08 137.05,73.02 136.64,73.02 136.58,72.96 136.58,72.84 136.64,72.78 137.05,72.78 137.11,72.73 137.11,72.24 137.26,72.09 137.26,72.01 137.12,71.88 137.12,71.79 137.21,71.71 137.29,71.71 137.42,71.84 137.51,71.84 137.59,71.76 137.59,71.68 137.46,71.54 137.46,71.46 137.54,71.38 137.62,71.38 137.75,71.51 137.84,71.51 v7(138.3,71.05)
DDR_A_D27: length 22.9
  IN4 w0.058: v6(132.68,89.35) 132.4,89.07 132.4,87.69 133.49,86.6 133.49,81.09 133.43,81.03 133.4,81.03 133.34,80.97 133.34,80.86 133.4,80.8 133.43,80.8 133.49,80.74 133.49,80.62 133.43,80.57 133.4,80.57 133.34,80.51 133.34,80.39 133.4,80.33 133.43,80.33 133.49,80.27 133.49,80.16 133.43,80.1 133.4,80.1 133.34,80.04 133.34,79.92 133.4,79.86 133.43,79.86 133.49,79.81 133.49,79.69 133.43,79.63 133.4,79.63 133.34,79.57 133.34,79.46 133.4,79.4 133.43,79.4 133.49,79.34 133.49,79.22 133.43,79.16 133.4,79.16 133.34,79.11 133.34,78.99 133.4,78.93 133.43,78.93 133.49,78.87 133.49,78.75 133.43,78.7 133.4,78.7 133.34,78.64 133.34,78.52 133.4,78.46 133.43,78.46 133.49,78.4 133.49,78.29 133.43,78.23 133.4,78.23 133.34,78.17 133.34,78.05 133.4,78 133.43,78 133.49,77.94 133.49,77.82 133.43,77.76 133.4,77.76 133.34,77.7 133.34,77.59 133.4,77.53 133.43,77.53 133.49,77.47 133.49,77.35 133.43,77.29 133.4,77.29 133.34,77.24 133.34,77.12 133.4,77.06 133.43,77.06 133.49,77 133.49,76.89 133.43,76.83 133.4,76.83 133.34,76.77 133.34,76.65 133.4,76.59 133.43,76.59 133.49,76.53 133.49,76.42 133.43,76.36 133.4,76.36 133.34,76.3 133.34,76.18 133.4,76.13 133.43,76.13 133.49,76.07 133.49,75.95 133.43,75.89 133.4,75.89 133.34,75.83 133.34,75.72 133.4,75.66 133.43,75.66 133.49,75.6 133.49,75.42 133.87,75.04 133.87,74.88 133.81,74.82 133.41,74.82 133.35,74.76 133.35,74.64 133.41,74.59 133.81,74.59 133.87,74.53 133.87,70.68 v7(134.3,70.25)
DDR_A_D28: length 24.6
  IN4 w0.058: v7(135.1,68.65) 134.76,68.99 134.11,68.99 133.79,69.31 133.79,69.55 133.34,70 133.34,73.46 132.81,73.98 132.81,86.53 132.02,87.33 132.02,90.63 v6(132.68,91.3)
DDR_A_D29: length 24.5
  IN4 w0.058: v6(132.68,90.65) 132.21,90.18 132.21,87.51 133.08,86.64 133.08,86.08 133.13,86.02 133.17,86.02 133.23,85.96 133.23,85.84 133.17,85.78 133.13,85.78 133.08,85.73 133.08,85.61 133.13,85.55 133.17,85.55 133.23,85.49 133.23,85.38 133.17,85.32 133.13,85.32 133.08,85.26 133.08,85.14 133.13,85.08 133.17,85.08 133.23,85.02 133.23,84.91 133.17,84.85 133.13,84.85 133.08,84.79 133.08,84.67 133.13,84.62 133.17,84.62 133.23,84.56 133.23,84.44 133.17,84.38 133.13,84.38 133.08,84.32 133.08,84.21 133.13,84.15 133.17,84.15 133.23,84.09 133.23,83.97 133.17,83.91 133.13,83.91 133.08,83.86 133.08,83.74 133.13,83.68 133.17,83.68 133.23,83.62 133.23,83.51 133.17,83.45 133.13,83.45 133.08,83.39 133.08,83.27 133.13,83.21 133.17,83.21 133.23,83.16 133.23,83.04 133.17,82.98 133.13,82.98 133.08,82.92 133.08,82.81 133.13,82.75 133.17,82.75 133.23,82.69 133.23,82.57 133.17,82.51 133.13,82.51 133.08,82.45 133.08,82.34 133.13,82.28 133.23,82.28 133.29,82.22 133.29,82.1 133.23,82.05 133.13,82.05 133.08,81.99 133.08,81.87 133.13,81.81 133.23,81.81 133.29,81.75 133.29,81.64 133.23,81.58 133.13,81.58 133.08,81.52 133.08,74.32 133.13,74.26 133.55,74.26 133.6,74.2 133.6,69.95 134.11,69.45 v7(134.3,69.45)
DDR_A_D30: length 21.5
  IN4 w0.058: v6(133.57,88.77) 134.94,87.4 134.94,76 136.32,74.62 136.32,71 137.69,69.62 138.13,69.62 v7(138.3,69.45)
DDR_A_D31: length 22.5
  IN4 w0.058: v7(135.1,69.45) 135.06,69.49 135.06,69.81 134.68,70.2 134.68,70.27 134.13,70.83 134.13,73.9 134.19,73.96 134.71,73.96 134.77,74.02 134.77,74.14 134.71,74.19 134.19,74.19 134.13,74.25 134.13,74.37 134.19,74.43 134.64,74.43 134.7,74.49 134.7,74.6 134.64,74.66 134.19,74.66 134.13,74.72 134.13,75.19 133.75,75.56 133.75,86.7 132.61,87.84 132.61,88.63 v6(132.68,88.7)
DDR_A_D32: length 28.6
  IN1 w0.058: v8(131.06,86.74) 131.51,86.29 131.51,84.32 132.16,83.66 132.16,75.42 134.05,73.54 134.05,70.78 133.58,70.32 133.58,69.76 132.52,68.69 132.52,66.68 132.46,66.62 132.3,66.62 132.24,66.68 132.24,66.97 132.18,67.03 132.06,67.03 132.01,66.97 132.01,66.68 131.95,66.62 131.83,66.62 131.77,66.68 131.77,66.97 131.71,67.03 131.6,67.03 131.54,66.97 131.54,66.68 131.48,66.62 131.41,66.62 131.3,66.51 128.62,66.51 127.9,65.8 v8(127.9,65.45)
DDR_A_D33: length 29.1
  IN1 w0.058: v8(131.06,87.39) 131.66,86.79 131.66,84.4 132.42,83.63 132.42,75.53 134.31,73.65 134.31,70.67 133.85,70.21 133.85,69.64 132.87,68.66 132.87,66.53 132.35,66 130.67,66 130.61,65.95 130.61,65.62 130.55,65.56 130.44,65.56 130.38,65.62 130.38,65.95 130.32,66 130.2,66 130.14,65.95 130.14,65.62 130.09,65.56 129.97,65.56 129.91,65.62 129.91,65.95 129.85,66 128.97,66 128.7,65.74 v8(128.7,65.45)
DDR_A_D34: length 29.3
  IN1 w0.058: v8(124.7,64.65) 124.7,64.69 124.33,65.05 124.33,65.62 124.21,65.75 123.89,65.75 123.57,66.07 123.57,67.34 124.4,68.16 129.43,68.16 130.29,69.03 130.29,70.07 130.81,70.59 130.81,73.52 129.87,74.46 129.87,76.3 129.87,79.07 129.87,86.29 v8(130.32,86.74)
DDR_A_D35: length 29.4
  IN1 w0.058: v8(130.32,87.39) 129.73,86.79 129.73,84.38 129.73,81.8 129.32,81.39 129.32,76.35 129.38,76.3 129.55,76.3 129.61,76.24 129.61,76.12 129.55,76.06 129.38,76.06 129.32,76 129.32,75.89 129.38,75.83 129.55,75.83 129.61,75.77 129.61,75.65 129.55,75.6 129.38,75.6 129.32,75.54 129.32,75.42 129.38,75.36 129.55,75.36 129.61,75.3 129.61,74.35 130.11,73.85 130.11,71.11 129.99,71 129.99,69.42 129.63,69.07 129.49,69.07 128.78,68.35 124.33,68.35 123.38,67.4 123.38,65.97 v8(123.9,65.45)
DDR_A_D36: length 27.2
  IN1 w0.058: v8(127.9,64.65) 127.57,64.98 127.57,65.57 127.51,65.62 127.08,65.62 127.03,65.68 127.03,65.8 127.08,65.86 127.51,65.86 127.57,65.92 127.57,66.27 128.01,66.7 130.72,66.7 132.26,68.24 132.26,68.86 133.32,69.93 133.32,70.43 133.78,70.89 133.78,73.43 131.9,75.31 131.9,83.59 131.3,84.18 131.3,85.19 v8(131.06,85.44)
DDR_A_D37: length 26.3
  IN1 w0.058: v8(131.06,84.79) 131.06,84.16 131.64,83.58 131.64,75.21 133.06,73.78 133.06,73.24 133.12,73.19 133.46,73.19 133.52,73.13 133.52,73.01 133.46,72.95 133.12,72.95 133.06,72.89 133.06,72.78 133.12,72.72 133.46,72.72 133.52,72.66 133.52,72.54 133.46,72.48 133.12,72.48 133.06,72.43 133.06,72.31 133.12,72.25 133.46,72.25 133.52,72.19 133.52,72.08 133.46,72.02 133.12,72.02 133.06,71.96 133.06,71.84 133.12,71.78 133.46,71.78 133.52,71.72 133.52,71.61 133.46,71.55 133.12,71.55 133.06,71.49 133.06,71.37 133.12,71.32 133.46,71.32 133.52,71.26 133.52,71.14 133.46,71.08 133.12,71.08 133.06,71.02 133.06,70.11 131.99,69.04 131.99,68.35 130.69,67.05 v8(127.9,67.05)
DDR_A_D38: length 27
  IN1 w0.058: v8(124.7,65.45) 124.7,65.57 124.27,66 124.27,66.28 123.95,66.6 123.95,67.21 124.52,67.78 129.78,67.78 130.81,68.81 130.81,69.52 131.22,69.93 131.22,70.01 131.14,70.09 131.14,70.18 131.22,70.26 131.3,70.26 131.38,70.18 131.47,70.18 131.89,70.6 131.89,73.18 130.4,74.67 130.4,84.18 130.32,84.25 v8(130.32,84.79)
DDR_A_D39: length 27.6
  IN1 w0.058: v8(130.32,85.44) 130.08,85.19 130.08,84.15 130.14,84.09 130.14,74.57 131.07,73.63 131.07,73.1 131.13,73.05 131.54,73.05 131.6,72.99 131.6,72.87 131.54,72.81 131.13,72.81 131.07,72.75 131.07,72.64 131.13,72.58 131.54,72.58 131.6,72.52 131.6,72.4 131.54,72.34 131.13,72.34 131.07,72.29 131.07,70.48 130.55,69.96 130.55,68.92 129.61,67.97 124.46,67.97 123.76,67.27 123.76,66.39 v8(123.9,66.25)
DDR_A_D40: length 17.5
  IN1 w0.058: v8(127.9,68.65) 128.46,69.47 128.46,71.23 128.62,71.4 128.62,74.48 128.27,74.83 128.27,82.88 128.62,83.24 128.62,84.28 128.83,84.48 128.83,85.15 v8(128.54,85.44)
DDR_A_D41: length 15.9
  IN1 w0.058: v8(127.9,69.45) 128.19,69.74 128.19,71.58 128.36,71.75 128.36,74.37 128.01,74.72 128.01,83.02 128.36,83.37 128.36,84.35 128.54,84.53 v8(128.54,84.79)
DDR_A_D42: length 19.3
  IN1 w0.058: v8(127.81,86.74) 126.78,86.29 126.65,86.17 126.47,85.74 126.32,85.21 126.32,75.95 125.72,73.2 125.59,73.07 124.45,71.14 124.45,69.27 v8(124.7,68.65)
DDR_A_D43: length 19.5
  IN1 w0.058: v8(127.81,87.39) 126.72,86.93 126.72,86.93 126.06,86.27 126.06,75.98 125.54,73.6 125.54,73.6 125.48,73.33 125.44,73.29 125.44,73.1 124.15,70.92 124.15,69.62 123.98,69.45 v8(123.9,69.45)
DDR_A_D44: length 19
  IN1 w0.058: v8(128.54,87.39) 129.12,86.81 129.12,81.93 128.86,81.67 128.86,74.99 129.15,74.69 129.15,74.11 129.64,73.61 129.64,71.92 129.22,71.49 129.22,69.97 v8(128.7,69.45)
DDR_A_D45: length 18.4
  IN1 w0.058: v8(128.54,86.74) 128.63,86.74 128.98,86.39 128.98,84.27 128.89,84.18 128.89,82.7 128.83,82.64 128.59,82.64 128.53,82.58 128.53,82.46 128.59,82.41 128.83,82.41 128.89,82.35 128.89,82.23 128.83,82.17 128.59,82.17 128.53,82.11 128.53,74.94 128.89,74.59 128.89,72.67 128.94,72.61 129.16,72.61 129.22,72.55 129.22,72.44 129.16,72.38 128.94,72.38 128.89,72.32 128.89,71.65 128.95,71.59 128.95,70.5 v8(128.7,70.25)
DDR_A_D46: length 17.3
  IN1 w0.058: v8(124.7,69.45) 125.22,69.97 125.22,70.96 125.86,71.6 125.86,71.68 125.71,71.83 125.71,71.92 125.79,72 125.88,72 126.03,71.85 126.11,71.85 126.61,72.35 126.61,73.35 126.84,73.58 126.84,84.02 127.61,84.79 v8(127.81,84.79)
DDR_A_D47: length 17.5
  IN1 w0.058: v8(127.81,85.44) 127.81,85.61 127.61,85.8 126.8,85.8 126.58,85.59 126.58,74.26 126.52,74.2 126.25,74.2 126.19,74.14 126.19,74.02 126.25,73.97 126.52,73.97 126.58,73.91 126.58,73.69 125.54,72.65 125.54,71.89 v8(124.7,71.05)
DDR_A_D48: length 29.6
  IN4 w0.058: v6(130.85,91.3) 131.32,90.83 131.44,90.83 131.83,90.45 131.83,87.15 132.1,86.87 132.1,86.58 132.35,86.34 132.35,68.35 129.69,65.7 129.36,65.7 128.79,65.13 128.38,65.13 v7(127.9,64.65)
DDR_A_D49: length 28.9
  IN4 w0.058: v6(130.85,90.65) 130.85,90.41 131.13,90.13 131.32,90.13 131.64,89.82 131.64,87.01 131.76,86.89 131.76,84.93 131.38,84.55 131.38,79.86 131.81,79.43 132.03,79.43 132.09,79.37 132.09,79.25 132.03,79.2 131.81,79.2 131.76,79.14 131.76,79.02 131.81,78.96 132.03,78.96 132.09,78.9 132.09,78.79 132.03,78.73 131.81,78.73 131.76,78.67 131.76,78.55 131.81,78.5 132.03,78.5 132.09,78.44 132.09,68.46 129.57,65.94 129.19,65.94 v7(128.7,65.45)
DDR_A_D50: length 28
  IN4 w0.058: v6(130.85,89.35) 130.85,89.2 131.23,88.83 131.23,88.46 131,88.23 131,78.32 131.15,78.18 131.77,78.18 131.83,78.12 131.83,78 131.77,77.94 131.55,77.94 131.49,77.88 131.49,77.77 131.55,77.71 131.77,77.71 131.83,77.65 131.83,77.53 131.77,77.47 131.55,77.47 131.49,77.42 131.49,77.3 131.55,77.24 131.77,77.24 131.83,77.18 131.83,68.57 129.77,66.51 129.4,66.51 128.83,65.94 128.39,65.94 v7(127.9,65.45)
DDR_A_D51: length 28.2
  IN4 w0.058: v6(129.94,89.35) 129.94,89.07 129.69,88.83 129.69,87.72 129.75,87.67 129.75,69.29 128.56,68.11 127.36,68.11 126.79,67.54 126.71,67.54 126.58,67.67 126.49,67.67 126.41,67.59 126.41,67.5 126.54,67.37 126.54,67.29 126.46,67.21 126.38,67.21 126.25,67.34 126.16,67.34 126.08,67.26 126.08,67.17 126.21,67.04 126.21,66.96 126.13,66.88 126.04,66.88 125.91,67.01 125.83,67.01 125.75,66.93 125.75,66.84 125.88,66.71 125.88,66.63 v7(124.7,65.45)
DDR_A_D52: length 30.2
  IN4 w0.058: v6(129.94,91.3) 129.94,91.17 129.6,90.83 129.16,90.83 128.8,90.47 128.8,87.64 129.29,87.15 129.29,76.43 129.16,76.3 129.16,69.45 128.12,68.41 126.05,68.41 125.9,68.25 125.82,68.25 125.51,68.56 125.42,68.56 125.34,68.47 125.34,68.39 125.65,68.08 125.65,68 125.57,67.92 125.48,67.92 125.18,68.23 125.09,68.23 125.01,68.14 125.01,68.06 125.32,67.75 125.32,67.67 v7(124.7,67.05)
DDR_A_D53: length 30
  IN4 w0.058: v6(129.94,90.65) 129.94,90.53 129.6,90.19 129.48,90.19 129.1,89.81 129.1,87.87 129.48,87.49 129.48,69.4 128.34,68.26 126.28,68.26 125.2,67.17 125.2,67.09 125.26,67.02 125.26,66.94 125.18,66.85 125.1,66.85 125.03,66.92 124.95,66.92 124.86,66.84 124.86,66.76 125.17,66.45 125.17,66.37 124.25,65.45 v7(123.9,65.45)
DDR_A_D54: length 26.9
  IN4 w0.058: v6(130.85,88.7) 130.75,88.59 130.75,77.45 131.29,76.91 131.51,76.91 131.56,76.85 131.56,76.73 131.51,76.68 131.29,76.68 131.23,76.62 131.23,76.5 131.29,76.44 131.51,76.44 131.56,76.38 131.56,76.27 131.51,76.21 131.29,76.21 131.23,76.15 131.23,76.03 131.29,75.98 131.51,75.98 131.56,75.92 131.56,75.8 131.51,75.74 131.29,75.74 131.23,75.68 131.23,75.57 131.29,75.51 131.51,75.51 131.56,75.45 131.56,75.33 131.51,75.27 131.29,75.27 131.23,75.22 131.23,75.1 131.29,75.04 131.51,75.04 131.56,74.98 131.56,74.87 131.51,74.81 131.29,74.81 131.23,74.75 131.23,74.57 131.56,74.24 131.56,69.87 131.21,69.51 131.21,68.37 129.84,67.01 129.84,66.96 129.59,66.7 129.15,66.7 v7(128.7,66.25)
DDR_A_D55: length 27.9
  IN4 w0.058: v6(129.94,88.7) 130.01,88.63 130.01,75.86 130.08,75.78 130.08,71.4 129.97,71.29 129.97,70.75 130.05,70.67 130.05,69.19 128.82,67.96 127.66,67.96 126.07,66.37 126.07,66.29 126.34,66.02 126.34,65.94 126.26,65.86 126.17,65.86 125.9,66.13 125.82,66.13 125.35,65.65 125.35,65.3 v7(124.7,64.65)
DDR_A_D56: length 23.7
  IN4 w0.058: v6(127.19,91.3) 126.48,90.59 126.48,89.49 125.86,88.86 125.86,84.42 125.21,83.78 125.21,75.9 124.94,75.63 124.94,74.05 123.36,72.46 123.36,69.99 v7(123.9,69.45)
DDR_A_D57: length 22.9
  IN4 w0.058: v7(128.7,69.45) 128.7,69.45 128.7,76.5 128.65,76.55 128.65,77.27 128.71,77.32 128.91,77.32 128.97,77.38 128.97,77.5 128.91,77.56 128.71,77.56 128.65,77.62 128.65,86.96 128.65,91.24 128.59,91.3 v6(128.11,91.3)
DDR_A_D58: length 22.4
  IN4 w0.058: v6(127.19,89.35) 126.18,88.34 126.18,75.61 125.47,74.9 125.47,73.83 123.76,72.13 123.76,70.77 124.21,70.32 124.21,69.65 v7(124.7,68.65)
DDR_A_D59: length 21.1
  IN4 w0.058: v7(127.9,69.45) 127.9,69.88 128.17,70.15 128.17,75.81 128.12,75.87 127.92,75.87 127.86,75.93 127.86,76.04 127.92,76.1 128.12,76.1 128.17,76.16 128.17,76.28 128.12,76.33 127.92,76.33 127.86,76.39 127.86,86.8 128.35,87.3 128.35,89.1 v6(128.11,89.35)
DDR_A_D60: length 22.4
  IN4 w0.058: v7(127.9,68.65) 127.9,69 128.15,69.25 128.15,69.84 128.44,70.12 128.44,87.06 128.5,87.13 128.5,90.26 v6(128.11,90.65)
DDR_A_D61: length 23.5
  IN4 w0.058: v6(127.19,90.65) 126.65,90.1 126.65,89.29 126.04,88.67 126.04,84.09 125.48,83.53 125.48,76.64 125.53,76.58 125.86,76.58 125.92,76.52 125.92,76.41 125.86,76.35 125.53,76.35 125.48,76.29 125.48,76.17 125.53,76.11 125.86,76.11 125.92,76.05 125.92,75.94 125.86,75.88 125.53,75.88 125.48,75.82 125.48,75.34 125.2,75.07 125.2,73.94 123.57,72.31 123.57,70.58 v7(123.9,70.25)
DDR_A_D62: length 19.4
  IN4 w0.058: v7(127.9,71.05) 127.67,71.28 127.67,72.27 127.61,72.33 127.38,72.33 127.32,72.39 127.32,72.51 127.38,72.57 127.7,72.57 127.76,72.63 127.76,72.74 127.7,72.8 127.38,72.8 127.32,72.86 127.32,72.98 127.38,73.03 127.7,73.03 127.76,73.09 127.76,73.96 127.6,74.12 127.6,76.57 127.7,76.67 127.7,87.02 128.11,87.43 v6(128.11,88.7)
DDR_A_D63: length 21.8
  IN4 w0.058: v7(124.7,69.45) 124.7,69.66 124.43,69.93 124.43,70.35 123.91,70.87 123.91,71.9 126.13,74.13 126.13,74.37 126.08,74.42 125.79,74.42 125.73,74.48 125.73,74.6 125.79,74.66 126.39,74.66 126.45,74.72 126.45,87.8 127.19,88.54 v6(127.19,88.7)
DDR_A_DQS0: length 30
  IN1 w0.058: v8(135.54,87.16) 135.66,87.12 135.73,87.02 135.73,85.99 136.02,85.69 136.52,85.69 136.86,85.35 136.86,85.35 136.93,85.28 136.93,85.27 136.94,85.26
  IN1 w0.076: v8(135.1,66.25) 134.9,66.45 134.74,66.45 134.54,66.64 134.54,67.35 134.82,67.63 135.98,67.63 136.18,67.43 136.18,67.41 136.25,67.34 136.69,67.34 136.76,67.41 136.76,67.43 136.96,67.63 139.5,67.63 141.64,69.77 141.64,73.6 137.95,77.3 137.95,84.26 136.94,85.26
DDR_A_DQS1: length 19.2
  IN1 w0.058: 134.37,83.37 134.37,83.38 134.37,83.39 134.37,83.57 133.48,84.47 133.48,84.93 133.09,85.32 133.09,86.03 133.03,86.09 v8(132.79,86.09)
  IN1 w0.076: 134.37,83.37 134.37,76.3 137.01,73.66 137.01,72.91 137.2,72.71 137.23,72.71 137.3,72.63 137.3,72.2 137.23,72.13 137.2,72.13 136.88,71.8 136.88,70.78 137.23,70.43 138.12,70.43 v8(138.3,70.25)
DDR_A_DQS2: length 33.1
  IN4 w0.058: 137.41,90.32 137.4,90.33 137.4,90.34 137.15,90.59 136.97,90.77 135.46,90.77 135.28,90.59 135.28,90.51 135.34,90.45 v6(135.51,90.45)
  IN4 w0.076: 137.41,90.32 138.07,89.66 138.07,76.53 138.62,75.98 138.9,75.98 138.96,76.04 139.06,76.04 139.37,75.74 139.37,75.63 139.31,75.57 139.31,75.29 139.74,74.87 140.01,74.87 140.07,74.93 140.18,74.93 140.49,74.62 140.49,74.51 140.43,74.46 140.43,74.18 140.73,73.88 140.73,73.84 140.73,73.84 140.73,73.23 140.93,73.03 141.02,73.03 141.1,72.96 141.1,72.52 141.02,72.45 140.93,72.45 140.73,72.25 140.73,71.65 140.93,71.46 141.02,71.46 141.1,71.38 141.1,70.95 141.02,70.87 140.93,70.87 140.73,70.68 140.73,70.08 140.93,69.88 141.02,69.88 141.1,69.81 141.1,69.37 141.02,69.3 140.93,69.3 140.73,69.1 140.73,68.41 140.73,68.41 140.73,68.24 140.08,67.59 138.05,67.59 137.67,67.21 137.67,66.84 137.86,66.65 138.22,66.65 138.3,66.57 v7(138.3,66.25)
DDR_A_DQS3: length 22.4
  IN4 w0.058: 133.1,88.17 133.1,88.18 133.11,88.19 133.11,90 133.03,90.1 132.94,90.13 v6(132.68,90)
  IN4 w0.076: 133.1,88.17 133.1,88.03 134.26,86.86 134.26,75.72 135.28,74.7 135.28,73.66 134.61,72.98 134.61,72.47 134.8,72.28 135.03,72.28 135.1,72.2 135.1,71.77 135.03,71.7 134.8,71.7 134.61,71.5 134.61,70.75 134.8,70.56 134.88,70.56 135.1,70.34 v7(135.1,70.25)
DDR_A_DQS4: length 27.8
  IN1 w0.058: v8(130.32,86.09) 130.54,86.09 130.6,86.03 130.6,83.99 130.97,83.61 130.97,83.39 130.96,83.38 130.96,83.37
  IN1 w0.076: v8(124.7,66.25) 124.63,66.25 124.14,66.74 124.14,67.15 124.54,67.54 130.23,67.54 131.32,68.63 131.32,69.32 132.38,70.39 132.38,73.5 130.96,74.92 130.96,83.37
DDR_A_DQS5: length 17.8
  IN1 w0.058: v8(127.81,86.09) 128.02,86.09 128.08,86.03 128.08,84.69 127.69,84.3 127.69,84.05 127.69,84.04 127.69,84.03
  IN1 w0.076: 127.69,84.03 127.69,83.65 127.31,83.28 127.31,74.36 127.51,74.16 127.61,74.16 127.69,74.09 127.69,72.38 126.77,71.46 126.77,70.84 127.19,70.41 127.74,70.41 v8(127.9,70.25)
DDR_A_DQS6: length 27.9
  IN4 w0.058: v6(129.94,90) 130.24,90 130.3,89.94 130.3,88.44 130.37,88.36 130.37,86.87 130.37,86.86 130.37,86.85
  IN4 w0.076: v7(127.9,66.25) 127.71,66.44 127.58,66.44 127.19,66.83 127.19,67.27 127.64,67.72 129.44,67.72 130.53,68.81 130.53,69.98 130.82,70.26 130.82,71.02 130.56,71.27 130.56,71.68 130.75,71.88 130.81,71.88 130.89,71.95 130.89,72.38 130.81,72.46 130.75,72.46 130.56,72.66 130.56,73.26 130.75,73.45 130.81,73.45 130.89,73.53 130.89,73.96 130.81,74.04 130.75,74.04 130.56,74.23 130.56,76.64 130.37,76.83 130.37,86.85
DDR_A_DQS7: length 22.2
  IN4 w0.058: 126.92,86.78 126.92,86.8 126.93,86.81 126.93,87.91 127.57,88.55 127.57,89.93 127.5,90 v6(127.19,90)
  IN4 w0.076: v7(124.7,70.25) 124.7,70.49 124.62,70.56 124.54,70.56 124.14,70.96 124.14,71.47 124.59,71.91 124.86,71.91 124.93,71.84 125.04,71.84 125.35,72.15 125.35,72.25 125.28,72.32 125.28,72.6 126.92,74.24 126.92,86.78
DDR_A_DQS#0: length 30
  IN1 w0.058: v8(136.17,86.95) 135.92,86.7 135.92,86.06 136.1,85.88 136.6,85.88 137.07,85.41 137.08,85.41 137.09,85.4
  IN1 w0.076: 137.09,85.4 138.15,84.34 138.15,77.38 141.84,73.69 141.84,69.68 139.58,67.42 137.04,67.42 136.97,67.35 136.97,67.33 136.77,67.13 136.17,67.13 135.97,67.33 135.97,67.35 135.9,67.42 134.9,67.42 134.75,67.27 134.75,66.73 134.82,66.65 135.18,66.65 135.26,66.73 135.26,66.89 v8(135.1,67.05)
DDR_A_DQS#1: length 19.1
  IN1 w0.058: v8(133.57,86.09) 133.33,86.09 133.27,86.03 133.27,85.4 133.66,85 133.66,84.54 134.56,83.65 134.56,83.39 134.57,83.38 134.57,83.37
  IN1 w0.076: 134.57,83.37 134.57,76.39 137.21,73.75 137.21,72.99 137.29,72.91 137.31,72.91 137.51,72.72 137.51,72.12 137.31,71.92 137.29,71.92 137.08,71.72 137.08,70.87 137.31,70.64 138.12,70.64 138.3,70.82 v8(138.3,71.05)
DDR_A_DQS#2: length 33.1
  IN4 w0.058: v6(134.86,90.45) 135.04,90.45 135.1,90.51 135.1,90.67 135.38,90.95 137.05,90.95 137.53,90.47 137.54,90.47 137.55,90.46
  IN4 w0.076: 137.55,90.46 138.28,89.74 138.28,76.62 138.71,76.19 138.81,76.19 138.87,76.25 139.15,76.25 139.57,75.82 139.57,75.54 139.52,75.49 139.52,75.38 139.82,75.07 139.93,75.07 139.99,75.13 140.26,75.13 140.69,74.71 140.69,74.43 140.63,74.37 140.63,74.26 140.94,73.96 140.94,73.31 141.01,73.24 141.1,73.24 141.3,73.04 141.3,72.44 141.1,72.24 141.01,72.24 140.94,72.17 140.94,71.74 141.01,71.66 141.1,71.66 141.3,71.47 141.3,70.87 141.1,70.67 141.01,70.67 140.94,70.59 140.94,70.16 141.01,70.09 141.1,70.09 141.3,69.89 141.3,69.29 141.1,69.1 141.01,69.1 140.94,69.02 140.94,68.33 140.93,68.32 140.93,68.16 140.17,67.39 138.13,67.39 137.87,67.13 137.87,66.93 137.95,66.85 138.1,66.85 v7(138.3,67.05)
DDR_A_DQS#3: length 22.3
  IN4 w0.058: v6(133.56,90.45) 133.26,90.29 133.21,90.16 133.29,90.06 133.29,88.19 133.3,88.18 133.3,88.17
  IN4 w0.076: 133.3,88.17 133.3,88.11 134.47,86.94 134.47,75.8 135.48,74.79 135.48,73.57 134.81,72.9 134.81,72.56 134.89,72.48 135.11,72.48 135.31,72.29 135.31,71.69 135.11,71.49 134.89,71.49 134.81,71.42 134.81,70.84 134.89,70.76 135.08,70.76 135.15,70.84 135.15,71 v7(135.1,71.05)
DDR_A_DQS#4: length 27.8
  IN1 w0.058: 131.17,83.37 131.17,83.38 131.16,83.39 131.16,83.69 130.78,84.07 130.78,86.03 130.84,86.09 v8(131.06,86.09)
  IN1 w0.076: v8(124.7,67.05) 124.79,66.96 124.79,66.78 124.71,66.71 124.46,66.71 124.35,66.83 124.35,67.06 124.62,67.34 130.31,67.34 131.52,68.55 131.52,69.23 132.59,70.3 132.59,73.59 131.17,75.01 131.17,83.37
DDR_A_DQS#5: length 17.7
  IN1 w0.058: 127.89,84.03 127.89,84.04 127.88,84.05 127.88,84.22 128.27,84.61 128.27,86.03 128.33,86.09 v8(128.54,86.09)
  IN1 w0.076: v8(127.9,71.05) 127.9,70.77 127.75,70.62 127.28,70.62 126.97,70.92 126.97,71.38 127.89,72.29 127.89,74.17 127.69,74.37 127.59,74.37 127.52,74.44 127.52,83.2 127.89,83.57 127.89,84.03
DDR_A_DQS#6: length 27.9
  IN4 w0.058: 130.57,86.85 130.57,86.86 130.56,86.87 130.56,88.44 130.49,88.52 130.49,89.94 130.54,90 v6(130.85,90)
  IN4 w0.076: 130.57,86.85 130.57,76.91 130.76,76.72 130.76,74.31 130.84,74.24 130.9,74.24 131.09,74.04 131.09,73.44 130.9,73.25 130.84,73.25 130.76,73.17 130.76,72.74 130.84,72.66 130.9,72.66 131.09,72.47 131.09,71.87 130.9,71.67 130.84,71.67 130.76,71.6 130.76,71.36 131.02,71.1 131.02,70.18 130.73,69.9 130.73,68.72 129.53,67.52 127.72,67.52 127.39,67.19 127.39,66.92 127.67,66.64 127.82,66.64 127.9,66.72 v7(127.9,67.05)
DDR_A_DQS#7: length 22.2
  IN4 w0.058: 127.12,86.78 127.12,86.8 127.11,86.81 127.11,87.83 127.75,88.47 127.75,89.94 127.81,90 v6(128.11,90)
  IN4 w0.076: v7(124.7,71.05) 124.81,71.05 124.9,70.97 124.9,70.85 124.82,70.77 124.62,70.77 124.35,71.04 124.35,71.38 124.67,71.71 124.78,71.71 124.85,71.64 125.13,71.64 125.55,72.06 125.55,72.34 125.48,72.41 125.48,72.52 127.12,74.16 127.12,86.78
DDR_A_MA0: length 53.2
  TOP w0.081: UC1.AH3 115.97,85.83 116.25,85.55 116.25,85.14 116.42,84.97 116.42,84.46 116.92,83.96 118.55,83.96 119.54,82.96 v8(119.76,82.96)
  IN1 w0.086: v8(119.76,82.96) 119.73,82.93 119.73,71.8 119.82,71.71 120.16,71.71 120.27,71.59 120.27,71.47 120.16,71.36 119.82,71.36 119.74,71.27 119.74,71.1 119.82,71.01 120.15,71.01 120.23,70.93 120.23,70.76 120.15,70.67 119.82,70.67 119.74,70.58 119.74,70.41 119.82,70.32 120.15,70.32 120.23,70.24 120.23,70.06 120.15,69.98 119.82,69.98 119.74,69.89 119.74,69.72 119.82,69.63 120.15,69.63 120.23,69.55 120.23,69.37 120.15,69.29 119.82,69.29 119.74,69.2 119.74,69.03 119.82,68.94 120.15,68.94 120.23,68.86 120.23,63.13 122.36,61 123.94,61 124.29,60.65 v8(124.7,60.65) 124.97,60.38 126.92,60.38 127.19,60.65 v4(127.9,60.65) 128.3,60.25 130.37,60.25 130.45,60.34 132.76,60.34 133.35,60.92 134.43,60.92 134.7,60.65 v8(135.1,60.65) 135.37,60.38 136.12,60.38 136.28,60.54 138.19,60.54 v4(138.3,60.65) 138.53,60.42 141.69,60.42 v8(141.95,60.16)
DDR_A_MA1: length 66.4
  TOP w0.081: UC1.AP4 v6(121.5,86.37)
  TOP w0.122: UD4.P7 v6(125.3,60.65) ; UD3.P7 v6(135.7,60.65)
  IN4 w0.058: v6(121.5,86.37) 121.71,86.37 121.77,86.43 121.77,86.69 121.68,86.78 121.27,86.78 121.21,86.72 121.21,86.16 120.75,85.7 120.75,84.03 120.88,83.9 120.88,83.8
  IN4 w0.086: 120.88,83.8 120.88,63.65 120.98,63.55 121.22,63.55 121.35,63.43 121.35,61.89 122.94,60.3 123.1,60.3 123.18,60.39 123.18,60.65 123.27,60.73 123.44,60.73 123.53,60.65 123.53,60.39 123.62,60.3 124.17,60.3 124.26,60.39 124.26,60.6 124.34,60.68 124.51,60.68 124.6,60.6 124.6,60.39 124.69,60.3 124.84,60.3 124.94,60.4 124.94,60.66 125.02,60.73 125.21,60.73 v6(125.3,60.65) 125.59,60.94 125.76,60.94 125.83,60.86 125.83,60.68 125.91,60.61 126.09,60.61 126.17,60.69 126.17,60.85 126.26,60.94 126.43,60.94 126.52,60.85 126.52,60.69 126.61,60.61 126.97,60.61 127.05,60.53 127.38,60.53 127.57,60.34 127.57,60.24 127.66,60.15 128.14,60.15 128.3,60.3 v7(128.35,60.3) 128.4,60.35 134.42,60.35 134.57,60.2 134.82,60.2 134.98,60.35 134.98,60.6 135.06,60.68 135.66,60.68 v6(135.7,60.65) 136.79,60.65 136.92,60.52 136.92,60.27 136.99,60.2 137.19,60.2 137.26,60.28 137.26,60.45 137.34,60.53 137.78,60.53 137.97,60.34 137.97,60.24 138.06,60.15 138.54,60.15 138.7,60.3 v7(138.75,60.3) 138.8,60.35 141.61,60.35 141.67,60.41 142.46,60.41 v7(142.84,60.04)
  BOTTOM w0.122: UD2.P7 127.31,60.65 127.69,60.28 128.32,60.28 v7(128.35,60.3) ; v7(138.75,60.3) 138.72,60.28 138.09,60.28 137.71,60.65 UD1.P7
DDR_A_MA2: length 55.8
  TOP w0.081: v6(120.64,86.39) 120.61,86.43 120.6,86.43 120.29,86.74 UC1.AN4
  IN4 w0.058: 120.53,83.91 120.53,86.28 v6(120.64,86.39)
  IN4 w0.086: v7(142.84,59.46) 142.05,59.46 141.54,59.97 140.59,59.97 140.4,60.16 139.51,60.16 139.32,59.97 138.42,59.97 v7(138.3,59.85) 137.95,59.85 137.81,59.99 136.67,59.99 136.59,60.08 136.59,60.22 136.5,60.3 136.33,60.3 136.24,60.22 136.24,60.08 136.15,59.99 135.98,59.99 135.89,60.08 135.89,60.16 135.81,60.25 135.66,60.25 135.55,60.14 135.55,59.94 135.46,59.85 v6(135.1,59.85) 134.98,59.97 133.53,59.97 133.45,59.89 133.45,59.86 133.36,59.77 133.19,59.77 133.1,59.86 133.1,59.89 133.02,59.97 132.84,59.97 132.76,59.89 132.76,59.86 132.67,59.77 132.5,59.77 132.41,59.86 132.41,59.89 132.32,59.97 128.02,59.97 v7(127.9,59.85) 127.55,59.85 127.41,59.99 126.96,59.99 126.88,60.08 126.88,60.19 126.79,60.28 126.62,60.28 126.53,60.19 126.53,60.08 126.44,59.99 126.27,59.99 126.19,60.08 126.19,60.32 126.1,60.4 125.93,60.4 125.84,60.32 125.84,60.08 125.75,59.99 125.58,59.99 125.49,60.08 125.49,60.29 125.41,60.38 125.24,60.38 125.15,60.29 125.15,60.08 125.06,59.99 124.84,59.99 v6(124.7,59.85) 124.47,59.62 124.36,59.62 124.28,59.69 124.28,59.94 124.2,60.02 124.04,60.02 123.95,59.94 123.95,59.68 123.87,59.59 123.69,59.59 123.61,59.68 123.61,59.98 123.52,60.07 123.35,60.07 123.26,59.98 123.26,59.68 123.18,59.59 123,59.59 122.92,59.68 122.92,59.98 122.83,60.07 122.64,60.07 122.52,59.95 122.4,59.95 122.28,60.07 122.28,60.19 122.39,60.31 122.39,60.43 122.27,60.55 122.15,60.55 122.03,60.44 121.91,60.44 121.79,60.56 121.79,60.68 121.9,60.8 121.9,60.92 121.78,61.04 121.66,61.04 121.54,60.93 121.39,60.93 121.3,61.01 121.3,61.17 121.42,61.29 121.42,61.41 121.18,61.65 120.7,61.65 120.53,61.82 120.53,62.05 120.62,62.14 120.97,62.14 121.06,62.22 121.06,62.4 120.97,62.48 120.62,62.48 120.53,62.57 120.53,83.91
DDR_A_MA3: length 63.7
  TOP w0.081: UC1.AP5 v6(121.39,87.02)
  TOP w0.122: UD4.N7 v6(125.32,61.45) ; UD3.N7 v6(135.72,61.45)
  IN4 w0.058: 121.46,84 121.46,84.05 121.41,84.1 121.29,84.1 121.07,84.32 121.07,84.92 122.07,85.93 122.07,86.69 121.74,87.02 v6(121.39,87.02)
  IN4 w0.086: 121.46,84 121.46,83.11 121.69,82.88 122.84,82.88 122.94,82.78 122.94,81.97 122.83,81.87 122.43,81.87 121.66,81.11 121.66,75.28 121.46,75.08 121.46,64.26 121.93,63.79 121.93,62.23 122.97,61.18 125.05,61.18 v6(125.32,61.45) 125.4,61.37 127.38,61.37 127.56,61.19 127.56,61.01 127.65,60.92 127.8,60.92 v7(127.94,61.06) 128.22,61.34 128.63,61.34 128.85,61.11 135.36,61.11 135.48,61.24 135.48,61.34 135.59,61.45 v6(135.72,61.45) 135.8,61.37 137.78,61.37 137.96,61.19 137.96,61.01 138.05,60.92 138.2,60.92 v7(138.34,61.06) 138.38,61.06 138.63,61.32 141.05,61.32 141.22,61.5 142.52,61.5 v7(142.84,61.18)
  BOTTOM w0.122: UD2.N7 127.33,61.45 127.71,61.06 v7(127.94,61.06) ; UD1.N7 137.73,61.45 138.11,61.06 v7(138.34,61.06)
DDR_A_MA4: length 55.7
  TOP w0.081: v6(121.41,84.47) 122.03,84.47 122.25,84.69 122.25,85.02 122.15,85.12 121.41,85.12 121.09,85.44 UC1.AP2
  IN4 w0.058: v6(121.41,84.47) 121.23,84.64 121.23,84.86 121.97,85.6 122.05,85.6 122.22,85.43 122.22,85.26 121.79,84.84 121.79,84.04 121.75,84
  IN4 w0.086: 121.75,84 121.75,83.34 121.92,83.17 123.09,83.17 123.23,83.04 123.23,81.72 123.09,81.58 122.55,81.58 121.95,80.99 121.95,75.16 121.75,74.96 121.75,65.93 121.84,65.84 122.05,65.84 122.19,65.7 122.19,65.54 122.1,65.45 121.85,65.45 121.77,65.37 121.77,65.2 121.85,65.11 122.1,65.11 122.19,65.02 122.19,64.85 122.1,64.76 121.85,64.76 121.77,64.68 121.77,64.5 121.85,64.42 122.1,64.42 122.19,64.33 122.19,63.94 122.22,63.91 122.22,62.93 122.4,62.74 122.4,62.51 122.33,62.44 122.33,62.28 122.43,62.18 122.55,62.18 122.76,62.39 122.88,62.39 123,62.27 123,62.15 122.79,61.94 122.79,61.82 123.19,61.42 123.38,61.42 123.46,61.51 123.46,61.64 123.55,61.72 123.72,61.72 123.81,61.64 123.81,61.51 123.89,61.42 124.07,61.42 124.15,61.51 124.15,61.64 124.24,61.72 124.41,61.72 124.5,61.64 124.5,61.51 124.59,61.42 124.67,61.42 v6(124.7,61.45) 125,61.75 125.4,61.75 125.58,61.57 127.48,61.57 127.61,61.45 v7(127.9,61.45) 127.97,61.52 133.33,61.52 133.42,61.61 133.42,61.61 133.5,61.7 133.68,61.7 133.76,61.61 133.76,61.56 133.85,61.47 134.02,61.47 134.11,61.56 134.11,61.6 134.19,61.69 134.35,61.69 134.48,61.56 134.48,61.55 134.58,61.45 v6(135.1,61.45) 135.55,61.9 135.86,61.9 135.94,61.83 135.94,61.67 136.04,61.57 137.88,61.57 138.01,61.45 v7(138.3,61.45) 138.36,61.51 140.73,61.51 141.27,62.05 142.54,62.05 v7(142.84,61.75)
DDR_A_MA5: length 65.4
  TOP w0.122: v8(135.32,61.04) 135.33,61.05 138.7,61.05 UD3.P8 139.42,60.97 140.1,60.97 140.34,60.73 RD171.1 ; UD4.P8 128.3,61.05 124.93,61.05 v8(124.92,61.04)
  IN1 w0.086: v8(121,84.79) 121.13,84.91 121.64,84.91 121.88,85.15 121.88,85.8 122.28,86.2 122.28,86.63 122.19,86.72 121.28,86.72 121.08,86.51 121.08,86.16 120.65,85.73 120.65,84.75 120.09,84.19 120.09,82.61 120.04,82.56 120.04,73.43 120.52,72.95 120.52,63.25 122.59,61.18 124.12,61.18 124.26,61.04 v8(124.92,61.04) 124.93,61.05 127.24,61.05 v4(127.28,61.01) 127.94,61.01 128.22,60.73 128.51,60.73 128.6,60.65 128.6,60.52 128.69,60.43 128.86,60.43 128.94,60.52 128.94,60.65 129.03,60.73 129.2,60.73 129.29,60.65 129.29,60.52 129.38,60.43 129.55,60.43 129.64,60.52 129.64,60.65 129.72,60.73 132.9,60.73 133.33,61.17 134.49,61.17 134.7,60.96 134.85,60.96 135.05,61.17 135.23,61.17 135.32,61.08 v8(135.32,61.04) 135.36,61.08 137.61,61.08 v4(137.68,61.01)
  BOTTOM w0.122: v4(137.68,61.01) 134.66,61.01 UD1.P8 ; UD2.P8 124.26,61.01 v4(127.28,61.01)
DDR_A_MA6: length 56
  TOP w0.081: v6(121.41,85.82) 121.32,85.73 120.78,85.73 120.7,85.8 120.7,85.92 120.87,86.09 UC1.AP3
  IN4 w0.058: v6(121.41,85.82) 120.9,85.31 120.9,84.25 121.16,84
  IN4 w0.086: 121.16,84 121.17,83.99 121.17,82.69 121.28,82.59 122.54,82.59 122.66,82.48 122.66,82.27 122.54,82.16 122.31,82.16 122.19,82.04 121.84,82.04 121.67,82.21 121.28,82.21 121.16,82.1 121.16,81.9 121.26,81.8 121.74,81.8 121.84,81.69 121.84,81.56 121.73,81.45 121.26,81.45 121.17,81.37 121.17,81.09 121.26,81.01 121.27,81.01 121.36,80.92 121.36,80.75 121.27,80.66 121.26,80.66 121.17,80.58 121.17,80.4 121.26,80.32 121.27,80.32 121.36,80.23 121.36,80.06 121.27,79.97 121.26,79.97 121.17,79.88 121.17,79.71 121.26,79.63 121.27,79.63 121.36,79.54 121.36,79.37 121.27,79.28 121.26,79.28 121.17,79.19 121.17,79.02 121.26,78.93 121.33,78.93 121.41,78.85 121.41,78.68 121.33,78.59 121.26,78.59 121.17,78.5 121.17,78.33 121.26,78.24 121.27,78.24 121.36,78.16 121.36,77.98 121.27,77.9 121.26,77.9 121.17,77.81 121.17,77.64 121.26,77.55 121.33,77.55 121.41,77.47 121.41,77.29 121.33,77.21 121.26,77.21 121.17,77.12 121.17,76.95 121.26,76.86 121.35,76.86 121.44,76.78 121.44,76.6 121.35,76.52 121.26,76.52 121.17,76.43 121.17,76.26 121.26,76.17 121.28,76.17 121.37,76.08 121.37,75.91 121.28,75.83 121.26,75.83 121.17,75.74 121.17,63.92 121.26,63.83 121.48,63.83 121.64,63.67 121.64,62.06 122.76,60.94 123.81,60.94 123.9,60.85 v6(123.9,60.65) 124.17,60.92 125.18,60.92 125.4,61.14 126.75,61.14 127.18,60.71 127.46,60.71 127.79,60.38 128.02,60.38 128.29,60.65 v7(128.7,60.65) 129.16,60.65 129.25,60.74 129.25,60.8 129.33,60.89 129.51,60.89 129.59,60.8 129.59,60.74 129.68,60.65 129.85,60.65 129.94,60.74 129.94,60.83 130.02,60.91 130.2,60.91 130.28,60.83 130.28,60.74 130.37,60.65 130.54,60.65 130.63,60.74 130.63,60.85 130.71,60.94 130.89,60.94 130.97,60.85 130.97,60.74 131.06,60.65 131.23,60.65 131.32,60.74 131.32,60.8 131.43,60.91 131.55,60.91 131.66,60.8 131.66,60.74 131.75,60.65 131.88,60.65 131.97,60.74 131.97,60.8 132.05,60.89 132.23,60.89 132.31,60.8 132.31,60.74 132.4,60.65 v6(134.3,60.65) 134.56,60.91 137.37,60.91 137.57,60.71 137.85,60.71 138.17,60.39 138.43,60.39 138.69,60.65 v7(139.1,60.65) 141.33,60.65 141.38,60.7 142.74,60.7 v7(142.84,60.61)
DDR_A_MA7: length 67.7
  TOP w0.081: v8(119.84,84.73) 119.84,84.73 120.2,84.73 UC1.AN1
  TOP w0.122: RD173.1 141.72,57.88 140.89,58.7 139.76,58.7 139.42,59.04 139.42,59.53 UD3.R8 138.88,59.85 138.47,59.44 134.83,59.44 v8(134.76,59.36) ; v8(124.36,59.36) 124.43,59.44 128.07,59.44 128.48,59.85 UD4.R8
  IN1 w0.086: v4(137.16,59.43) 137.22,59.38 137.22,59.22 137.13,59.13 136.96,59.13 136.87,59.22 136.87,59.58 136.78,59.67 136.61,59.67 136.52,59.58 136.52,59.22 136.44,59.13 136.27,59.13 136.18,59.22 136.18,59.38 136.09,59.46 135.95,59.46 135.83,59.35 135.83,59.22 135.75,59.13 135.57,59.13 135.49,59.22 135.49,59.25 135.4,59.34 134.78,59.34 v8(134.76,59.36) 134.64,59.48 134.11,59.48 134.01,59.59 133.29,59.59 133.16,59.72 131.36,59.72 131.05,59.41 129.67,59.41 129.17,58.92 128.43,58.92 127.91,59.44 v4(127.28,59.44) 127.28,59.42 127.16,59.31 126.96,59.31 126.88,59.39 126.88,59.45 126.79,59.54 126.62,59.54 126.53,59.45 126.53,59.39 126.44,59.31 126.3,59.31 126.22,59.39 126.22,59.5 126.13,59.59 125.97,59.59 125.87,59.49 125.87,59.39 125.79,59.31 125.56,59.31 125.47,59.39 125.47,59.63 125.36,59.74 125.24,59.74 125.13,59.63 125.13,59.39 125.04,59.31 124.41,59.31 v8(124.36,59.36) 124.31,59.41 123.93,59.41 123.21,60.12 122.05,60.12 119.86,62.31 119.23,62.31 118.85,62.69 118.85,63.8 118.96,63.91 119.01,63.91 119.1,63.99 119.1,64.16 119.01,64.25 118.93,64.25 118.85,64.34 118.85,82.32 118.34,82.83 118.34,84.55 118.84,85.04 119.52,85.04 v8(119.84,84.73)
  BOTTOM w0.122: v4(137.16,59.43) 137.15,59.45 134.7,59.45 UD1.R8 ; UD2.R8 124.3,59.45 127.27,59.45 v4(127.28,59.44)
DDR_A_MA8: length 57.6
  TOP w0.081: v8(119.79,84.02) 120.47,84.02 120.59,84.14 120.59,85.54 120.26,85.86 UC1.AN3
  TOP w0.122: UD3.R2 v8(134.71,59.85) ; UD4.R2 v8(124.31,59.85)
  IN1 w0.086: v8(119.79,84.02) 119.79,84.02 119.64,84.02 119.54,84.12 119.54,84.34 119.45,84.43 118.71,84.43 118.63,84.34 118.63,84.22 118.71,84.13 119.12,84.13 119.2,84.05 119.2,83.87 119.12,83.79 118.71,83.79 118.63,83.7 118.63,83.48 118.71,83.4 119.07,83.4 119.15,83.31 119.15,67.74 119.24,67.66 119.56,67.66 119.65,67.57 119.65,67.39 119.57,67.31 119.24,67.31 119.15,67.22 119.15,67.05 119.24,66.96 119.57,66.96 119.65,66.88 119.65,66.7 119.57,66.62 119.24,66.62 119.15,66.53 119.15,66.36 119.24,66.27 119.57,66.27 119.65,66.19 119.65,66.01 119.57,65.93 119.24,65.93 119.15,65.84 119.15,65.67 119.24,65.58 119.57,65.58 119.65,65.49 119.65,65.32 119.57,65.24 119.49,65.24 119.41,65.15 119.41,64.98 119.49,64.89 119.57,64.89 119.65,64.8 119.65,62.89 122.11,60.43 123.32,60.43 UD4.R2 v8(124.31,59.85) 124.31,59.84 124.59,59.57 124.79,59.57 125.22,60 125.88,60 126.11,59.77 128.07,59.77 128.16,59.68 128.28,59.68 v4(128.3,59.69) 128.57,59.41 129.29,59.41 129.46,59.59 130.98,59.59 131.3,59.91 132.91,59.91 133.16,60.16 133.99,60.16 UD3.R2 v8(134.71,59.85) 134.99,59.57 135.32,59.57 135.75,60 136.42,60 136.58,59.84 138.39,59.84 v4(138.74,59.49) 139.9,59.49 140.59,58.81 141.73,58.81 v8(141.95,59.02)
  BOTTOM w0.122: UD2.R2 128.53,59.85 128.37,59.69 v4(128.3,59.69) ; UD1.R2 v4(138.74,59.49)
