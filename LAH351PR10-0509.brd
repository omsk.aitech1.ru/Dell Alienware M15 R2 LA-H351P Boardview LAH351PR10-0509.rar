# Allegro board LAH351PR10-0509.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS on BOTTOM (solid shape): 63.25,12.16 63.25,9.63 63.7,9.17 63.7,6.89 63.67,6.85 63.67,6.54 63.25,6.12 60.07,6.12 59.82,6.38 59.82,7.52 60.2,7.9 60.2,12.22 60.26,12.28 63.12,12.28
+5VS on IN4 (solid shape): 62.61,75.91 62.61,74.01 62.48,73.88 61.59,73.88 61.53,73.94 61.53,75.91 61.66,76.04 62.48,76.04
+5VS on TOP: 44.58,140.24 44.58,139.16 44.45,139.03 43.47,139.03 43.32,139.18 43.32,140.06 43.67,140.41 43.8,140.41 43.83,140.44 44.37,140.44
+5VS on BOTTOM: 76.67,2.76 76.67,7.82 76.56,7.94 74.36,7.94 74.25,7.82 74.25,6.05 75.69,4.6 75.69,2.5 75.88,2.31 79.06,2.31 79.18,2.44 79.18,2.63 79.06,2.76 78.49,2.76 78.31,2.58 76.85,2.58
+5VS on BOTTOM: 77.47,126.46 78.87,126.46 79.44,125.88 79.44,124.61 73.85,119.03 71.79,119.03 71.18,118.41 63.01,118.41 62.48,117.88 62.48,117.25 61.98,116.74 60.9,116.74 60.64,116.99 60.64,119.03 63.28,121.67 71.53,121.67 72.38,122.52 73.53,122.52
+5VS on BOTTOM: 40.01,150.9 40.13,150.78 40.26,150.78 40.39,150.9 40.39,151.79 40.64,152.05 40.64,153.11 40.63,153.12 40.63,153.59 40.5,153.72 40.16,153.72 40.01,153.57
+5VS on BOTTOM: 126.49,150.52 128.78,150.52 128.91,150.4 128.91,148.74 128.78,148.62 126.49,148.62 126.36,148.74 126.36,150.4
+5VS on BOTTOM: 112.01,141.96 112.11,142.07 113.76,142.07 113.8,142.11 113.8,143.24 113.53,143.51 111.82,143.51 111.33,144.01 110.31,144.01 110.25,143.94 110.25,143.35 110.96,142.64 110.96,142.1 111.02,142.04 111.02,141.99 111.05,141.96
+5VS on BOTTOM: 142.37,40.03 142.37,38.64 142.62,38.38 144.4,38.38 144.65,38.64 144.65,40.16 144.15,40.67 143,40.67
+5VS on IN1: 113.54,143.09 113.54,141.82 113.41,141.7 110.68,141.7 110.24,142.13 109.59,142.13 109.19,142.53 109.19,143.39 109.33,143.53 113.11,143.53
+5VS on IN1: 40.89,150.65 39.88,150.65 39.75,150.78 39.75,152.94 39.94,153.13 39.94,153.51 40.17,153.74 40.68,153.74 40.89,153.52
+5VS on IN2: 63.12,76.23 61.4,76.23 61.21,76.04 61.21,75.4 61.4,75.21 63.18,75.21 63.25,75.28 63.25,76.1
+5VS on IN2: 67.73,78.31 69.29,78.31 69.44,78.16 69.44,77.19 69.34,77.09 67.72,77.09 67.5,77.31 67.5,78.08
+5VS on IN2: 40.77,151.28 40.64,151.16 39.75,151.16 39.62,151.28 39.62,152.81 39.9,153.09 39.9,153.47 40.14,153.71 40.63,153.71 40.77,153.57
+5VS on IN2: 42.93,141.25 42.93,139.66 43.5,139.09 44.2,139.09 44.45,139.35 44.45,140.39 43.59,141.25
+5VS on VCC: 71.82,4.87 71.82,6.48 70.91,7.39 63.33,7.39 62.57,6.63 55.03,6.63 51.98,9.68 11.39,9.68 10.92,9.21 10.92,7.97 1.17,7.97 1.17,64.04 6.86,64.04 6.86,49.6 4.38,47.12 4.38,18.8 3.3,17.72 3.3,12.56 4.91,10.95 79.1,10.95 84.81,16.66 128.88,16.66 130.56,18.34 130.56,22.78 140.09,32.32 140.09,37.79 141.99,39.68 141.99,48.52 137.52,52.99 94.59,52.99 91.5,56.08 91.5,97.35 77.09,111.77 77.09,126.03 77.58,126.52 80.96,126.52 80.96,111.62 81.3,111.28 98.95,111.28 101.66,108.57 101.66,92.7 101.69,92.67 100.71,91.7 100.71,89.8 99.19,88.27 99.19,85.86 94.23,80.91 94.23,58.47 96.03,56.67 144.29,56.67 146.3,54.66 146.3,27.86 147.38,26.78 147.38,25.41 145.75,23.78 138.58,23.78 136.14,21.34 136.14,13.98 134.51,12.35 87.27,12.35 86.23,11.31 86.23,9.15 81.95,4.87
+5VS on IN3: 66.74,92.99 66.55,92.8 61.72,92.8 60.71,93.82 60.71,122.96 60.96,123.22 62.36,123.22 62.67,122.9 62.67,101.41 63.33,100.76 63.33,96.06 64.17,95.21 66.23,95.21 66.74,94.71
+5VS on IN3: 112.39,143.34 112.39,142.64 112.2,142.45 110.93,142.45 110.67,142.7 110.67,144.29 110.68,144.3 110.68,144.47 111.02,144.81 112.89,144.81 113.2,144.5 113.2,144.15
+5VS on IN3: 44.83,139.09 45.97,140.24 45.97,140.49 45.34,141.12 44.64,141.12 43.31,139.79 43.31,139.25 43.46,139.09
+5VS on IN4: 141.86,39.78 144.4,39.78 144.78,39.4 144.78,38.76 144.4,38.38 141.6,38.38 140.27,37.05 140.27,33.24 140.08,33.05 139.51,33.05 139.38,33.17 139.38,37.3
+5VS on IN4: 66.55,93.12 66.67,92.99 66.67,91.34 66.93,91.09 66.93,83.72 66.8,83.59 66.8,80.93 68.94,78.79 69.16,78.79 69.34,78.62 69.34,77.37 69.22,77.24 68.71,77.24 65.66,80.29 65.66,92.99 65.79,93.12
+5VS on IN4: 68.04,44.16 68.04,43.87 68.15,43.75 69.81,43.75 70.4,44.34 70.4,44.8 70.15,45.04 68.92,45.04
+12.6V_BATT on TOP: 23.37,11.2 24.14,11.2 24.47,11.53 24.47,12.02 24.6,12.14 25.45,12.14 25.65,11.94 25.65,11.01 25.91,10.76 27.24,10.76 27.71,11.23 27.71,12.9 27.98,13.16 28.93,13.16 29.38,12.71 29.38,11.7 29.15,11.46 29.15,9.11 29.16,9.1 30.62,9.1 32.33,7.38 35.53,7.38 35.65,7.27 35.65,6.21 35.84,6.02 36.69,6.02 36.77,5.95 36.77,4.71 36.52,4.47 31.18,4.47 31.05,4.6 31.05,5.11 30.86,5.3 29.84,5.3 29.48,4.94 27.57,4.94 27.53,4.98 27.53,5.2 27.18,5.55 27.18,6.31 26.67,6.82 26.16,6.82 25.91,7.08 25.91,8.98 25.65,9.24 25.15,9.24 24.13,10.25 23.37,10.25 23.24,10.38 23.24,11.08
+12.6V_BATT+ on TOP (solid shape): 39.1,12.21 39.1,11.89 38.91,11.7 38.06,11.7 37.78,11.42 37.78,8 37.75,7.92 37.17,7.75 36.95,7.28 36.95,6.72 36.99,6.51 37.1,6.32 37.12,6.21 37.02,6.15 35.98,6.15 35.75,6.38 35.75,7.38 35.61,7.52 32.45,7.52 30.8,9.17 28.96,9.17 28.3,9.83 28.3,11.7 28.38,11.79 28.97,11.79 28.98,11.78 29.12,11.75 29.27,11.78 29.28,11.79 32.42,11.79 32.85,11.36 35.39,11.36 36.39,12.35 38.96,12.35
+12.6V_BATT+ on BOTTOM: 33.27,10.7 36.58,10.7 36.89,10.38 36.89,6.45 36.79,6.35 33.82,6.35 32.96,7.22 32.96,10.38
+12V_FAN on TOP: 126.87,44.48 127.89,44.48 128.02,44.35 128.02,43.46 127.76,43.21 126.87,43.21 126.75,43.33 126.75,44.35
+12V_FAN on BOTTOM: 13.97,51.46 16.38,51.46 17.53,50.32 17.53,48.77 17.39,48.64 16.86,48.64 16.26,48.03 16.26,47.78 16.13,47.65 15.11,47.65 14.35,48.41 14.35,49.81 13.59,50.57 13.59,51.08
+12V_LX on TOP (solid shape): 136.18,43.37 136.18,42.54 137.1,41.62 137.1,37.09 136.89,36.88 134.37,36.88 134.23,37.02 134.23,38.27 133.86,38.64 133.86,43.46 134.05,43.65 135.89,43.65
+12V_LX on BOTTOM (solid shape): 135.57,41.62 135.57,39.84 135.83,39.59 136.33,39.59 136.53,39.4 136.53,38.51 136.4,38.38 134.01,38.38 133.29,39.11 133.29,40.48 133.54,40.73 133.71,40.73 133.71,40.9 133.82,41.01 133.82,41.58 133.95,41.71 135.48,41.71
+12V_SNUB on BOTTOM (solid shape): 135.12,37.76 135.12,35.98 134.91,35.78 133.39,35.78 133.2,35.97 133.2,37.86 133.3,37.96 134.91,37.96
+12V_SS on BOTTOM (solid shape): 139.51,39.14 139.51,38 139.38,37.87 138.87,37.87 138.75,38 138.75,38.19 138.56,38.38 137.73,38.38 137.67,38.45 137.67,39.31 137.76,39.4 139.26,39.4
+12V_VIN on TOP (solid shape): 140.39,39.63 140.39,37.04 140.35,36.88 140.34,36.71 140.32,36.69 138.42,36.69 138.33,36.78 138.33,39.59 138.46,39.72 140.3,39.72
+12V_VIN on BOTTOM (solid shape): 138.06,40.99 139.42,40.53 140.87,40.58 141.6,39.84 141.6,38.75 141.5,38.65 140.2,38.65 139.32,39.52 138.01,39.52 137.85,39.59 137.68,39.52 137.54,39.52 137.48,39.46 137.48,38.45 137.41,38.38 136.78,38.38 136.72,38.45 136.72,40.54 137.16,40.99
+12V_VIN on GND4 (solid shape): 140.88,39.68 140.88,38.67 140.78,38.57 138.87,38.57 138.68,38.76 138.68,39.91 138.81,40.03 140.53,40.03
+12V_VIN on GND2: 140.46,40.03 140.59,39.91 140.59,38.64 140.46,38.51 138.94,38.51 138.68,38.76 138.68,39.91 138.81,40.03
+12VP on TOP (solid shape): 129.48,43.97 132.52,43.97 132.72,43.78 132.72,41.68 132.52,41.49 128.65,41.49 128.56,41.58 128.56,42.13 128.27,42.42 128.27,43.71 128.75,43.71 128.75,44.19 128.2,44.19 128.2,44.48 128.26,44.54 128.91,44.54
+12VP on BOTTOM (solid shape): 132.54,43.77 132.54,40.9 132.31,40.67 130.81,40.67 130.56,40.92 130.56,43.65 130.87,43.97 132.33,43.97
+19V_ADPIN on BOTTOM (solid shape): 10.99,37.11 10.99,34.51 11.37,34.13 17.53,34.13 17.91,33.75 17.91,31.08 17.59,30.76 13.06,30.76 12.78,30.94 12.48,30.82 12.43,30.79 12.39,30.76 10.16,30.76 9.59,30.19 8.45,30.19 8.13,30.51 8.13,36.98 8.51,37.37 10.73,37.37
+19V_VIN on TOP: 19.34,25.63 19.24,25.73 19.24,27.26 19.61,27.63 19.95,27.63 20.18,27.41 20.18,26.65 19.86,26.33 19.86,25.76 19.74,25.63
+19V_VIN on BOTTOM: 10.99,26.38 10.29,27.08 10.29,30 10.48,30.19 12.51,30.19 12.6,30.18 12.69,30.19 17.78,30.19 17.81,30.22 17.92,30.24 17.98,30.15 18.59,29.89 18.33,30.5 18.24,30.56 18.26,30.67 18.67,31.08 29.15,31.08 29.4,30.83 29.4,26.57 29.21,26.38
+19VB on TOP (solid shape): 36.69,143.84 37.13,143.84 37.26,143.72 37.26,143.46 37.08,143.28 35.75,143.28 35.53,143.5 35.53,144.1 35.75,144.31 36.23,144.31
+19VB on TOP (solid shape): 151.64,72.35 151.64,70.89 151.32,70.58 150.5,70.58 150.3,70.39 150.3,68.73 150.18,68.61 144.65,68.61 144.27,69 144.27,72.41 144.4,72.54 151.45,72.54
+19VB on TOP (solid shape): 137.62,48.16 137.62,47.48 136.36,46.22 136.36,45.56 135.8,45 131.18,45 130.86,45.32 130.86,46.29 130.89,46.33 131.97,46.33 132.02,46.28 132.02,46.08 132.05,46.04 132.54,46.04 132.59,46.09 132.59,46.17 132.69,46.27 134.28,46.27 134.67,46.66 135.48,46.66 135.88,47.06 135.88,47.43 136.73,48.28 137.5,48.28
+19VB on TOP (solid shape): 44.13,7.65 44.28,7.65 44.84,7.09 45.12,7.09 45.28,6.94 45.28,6.73 45.17,6.63 44.65,6.63 44.48,6.46 40.56,6.46 40.45,6.57 40.45,7.39 40.48,7.43 40.55,7.45 40.61,7.48 40.95,7.4 41.27,7.55 42.32,7.55 42.5,7.73 44.05,7.73
+19VB on BOTTOM (solid shape): 140.97,50.07 140.97,48.8 140.84,48.67 138.37,48.67 136.36,46.66 135.79,46.66 135.5,46.95 135.5,47.83 135.58,47.91 135.83,47.91 136.08,48.16 136.08,50 136.14,50.07 137.6,50.07 137.86,50.32 140.72,50.32
+19VB on BOTTOM (solid shape): 56.26,38.13 65.53,38.13 66.03,37.63 66.03,35.54 66.61,34.95 67.75,34.95 67.82,34.89 67.82,34.13 67.37,33.68 64.11,33.68 64.1,33.68 62.11,33.68 61.58,34.2 60.74,34.2 59.8,35.14 59.77,35.14 59.51,35.27 59.22,35.26 59.19,35.25 59.15,35.3 55.51,35.3 55.46,35.25 55.04,35.25 54.93,35.14 54.04,35.14 53.91,35.27 53.91,38.57 54.04,38.7 55.69,38.7
+19VB on BOTTOM (solid shape): 16.95,24.41 17.1,24.41 17.87,23.64 18.11,23.64 18.3,23.45 18.3,22.01 18.07,21.78 17.87,21.78 17.64,21.55 17.11,21.55 17.09,21.57 17.09,22.09 16.76,22.42 16.43,22.09 16.43,21.55 15.93,21.55 15.46,21.08 13.68,21.08 13.49,21.28 13.49,23.99 13.91,24.41 16.95,24.41
+19VB on TOP: 23.56,22.89 24.32,22.13 24.32,14.89 23.81,14.38 16.45,14.38 16.07,14 16.07,13.97 12.61,13.97 12,14.58 12,21.11 13.37,22.48 13.37,23.94 13.72,24.28 17.53,24.28 18.92,22.89
+19VB on TOP: 149.99,20.87 149.99,20.92 136.27,20.92 136.08,21.11 136.08,22.57 136.27,22.76 148.97,22.76 149.99,23.78 149.99,36.1 150.56,36.67 151.83,36.67 151.83,20.87
+19VB on TOP: 61.59,35.78 63.25,35.78 63.69,35.33 67.44,35.33 67.59,35.18 67.59,33.66 66.66,32.73 59.88,32.73 59.59,33.02 59.59,35.12 59.13,35.58 59.13,36.76 59.31,36.93 61.14,36.93 61.24,36.83 61.24,36.13
+19VB on TOP: 29.5,32.9 29.73,32.67 29.73,31.11 29.5,30.88 29.5,29.46 29,28.96 27.34,28.96 27.14,29.16 27.14,32.29 27.75,32.9
+19VB on BOTTOM: 60.52,127.23 60.52,136.82 59.91,137.43 59.16,137.43 54.56,142.03 36.7,142.03 35.13,143.6 35.13,144.86 35.34,145.07 35.84,145.07 36.26,145.49 54,145.49 54,145.49 55.63,145.49 63.71,137.42 63.71,128.1 68.01,123.8 70.41,123.8 70.75,123.46 70.75,122.67 70.74,122.66 70.74,122.21 70.41,121.88 65.86,121.88
+19VB on BOTTOM: 150.11,20.87 150.11,36.41 150.43,36.73 151.83,36.73 151.83,20.87
+19VB on BOTTOM: 84.39,1.68 84.52,1.55 84.52,1.3 84.39,1.17 66.23,1.17 66.17,1.23 66.17,2.06 66.42,2.31 75.12,2.31 75.63,1.81 79.44,1.81 79.57,1.68
+19VB on BOTTOM: 85.34,94.01 85.34,52.42 81.6,48.67 76.39,48.67 76.2,48.86 76.2,53.11 76.71,53.62 81.22,53.62 82.17,54.57 82.17,89.18 75.63,95.72 75.63,96.8 75.37,97.06 75.37,98.71 75.63,98.96 76.9,98.96 77.41,98.45 80.9,98.45 83.88,101.44 83.88,103.88 71.63,116.13 71.63,117.76 72.14,118.26 73.57,118.26 85.67,106.16 85.67,105.74 86.17,105.25 86.17,99.93 85.31,99.06 85.31,94.05
+19VB on IN1: 79.12,2.06 84.33,2.06 84.52,1.87 84.52,1.36 84.33,1.17 66.36,1.17 66.23,1.3 66.23,2.25 66.36,2.38 78.8,2.38
+19VB on IN1: 23.76,32.29 25.02,32.29 26.48,30.83 30.61,30.83 32.07,32.29 50.04,32.29 51.12,33.37 63.06,33.37 63.63,33.94 63.63,39.08 62.36,40.35 21.08,40.35 17.37,36.64 17.37,34.74 15.35,32.72 15.35,27.1 13.55,25.3 13.55,20.74 14.82,19.47 21.42,19.47 22.29,20.34 22.29,24.6 22.71,25.02 22.71,31.23
+19VB on GND2: 1.17,1.17 1.17,4.6 8.28,4.6 9.29,3.58 14.46,3.58 15.47,4.6 28.6,4.6 28.98,4.22 31.16,4.22 32.43,5.49 65.68,5.49 68.03,3.14 84.16,3.14 84.39,2.91 84.39,1.17
+19VB on IN2: 66.36,1.17 66.23,1.3 66.23,1.55 66.36,1.68 71.12,1.68 71.5,2.06 71.5,8.92 73.41,10.82 73.41,20.47 80.26,27.33 80.26,33.17 80.07,33.37 77.47,33.37 76.77,34.06 69.22,34.06 68.45,33.3 61.09,33.3 60.39,34 60.39,34.78 59.84,35.32 59.84,36.55 60.22,36.93 61.65,36.93 62.74,35.84 63.12,35.84 63.88,35.08 65.98,35.08 67.5,36.6 77.47,36.6 77.72,36.86 77.72,47.02 76.07,48.67 76.07,51.34 76.33,51.59 79.38,51.59 79.88,51.08 79.88,36.86 80.14,36.6 83.76,36.6 84.33,36.03 84.33,26.95 77.22,19.84 77.22,16.54 77.6,16.16 77.6,10.7 76.71,9.81 76.71,6.25 77.34,5.62 77.34,3.65 77.85,3.14 84.07,3.14 84.45,2.76 84.45,1.36 84.26,1.17
+19VB on GND3: 1.17,1.17 1.17,4.6 28.6,4.6 28.98,4.22 31.16,4.22 32.43,5.49 75.78,5.49 78.13,3.14 84.16,3.14 84.39,2.91 84.39,1.17
+19VB on VCC: 79.69,1.17 79.69,4.33 79.71,4.34 82.15,4.34 86.74,8.94 86.74,11.1 87.48,11.84 134.73,11.84 136.65,13.77 136.65,21.13 138.79,23.27 145.96,23.27 147.89,25.2 147.89,26.99 146.81,28.07 146.81,54.87 144.65,57.03 144.65,72.8 151.83,72.8 151.83,20.87 140.7,20.87 139.52,20.38 139.03,19.2 139.03,9.93 92.86,9.93 92.05,9.13 92.05,8.54 90.67,7.76 90.81,6.18 90.81,3.16 90.17,2.55 89.93,1.69 89.93,1.29 89.93,1.17
+19VB on IN3: 84.33,1.87 84.45,1.74 84.45,1.3 84.33,1.17 66.26,1.17 66.12,1.31 66.12,1.63 66.36,1.87
+19VB on IN3: 146.81,46.51 145.41,47.91 138.05,47.91 136.72,46.57 135.95,46.57 134.37,48.16 134.37,50.19 137.79,53.62 146.18,53.62 146.81,54.26 146.81,57.54 146.8,57.55 146.8,61.19 145.92,62.07 145.92,70.2 146.37,70.64 151.07,70.64 151.83,69.88 151.83,20.87 148.02,20.87 146.81,22.08
+19VB on IN3: 63.58,33.78 63.13,33.33 61.57,33.33 61.11,33.78 58.38,33.78 56.59,35.58 51.82,35.58 50.48,34.24 43.24,34.24 37.58,28.58 33.52,28.58 32.45,29.64 31.65,29.64 30.87,28.87 30.87,27.65 22.77,19.55 15.18,19.55 13.5,21.22 13.5,23.23 14.12,23.85 14.12,25.76 15.91,27.55 15.91,34.17 19.04,37.29 29.72,37.29 30.42,37.99 32.79,37.99 35.39,40.59 51.08,40.59 53.78,37.89 62.37,37.89 63.58,36.67
+19VB on GND4: 89.49,1.17 89.49,1.17 79.69,1.17 79.69,4.05 89.01,13.36 133.33,13.36 136.65,16.69 136.65,21.13 138.79,23.27 146.05,23.27 147.89,25.11 147.89,27.08 146.81,28.16 146.81,36.22 144.65,38.38 144.65,72.06 145.39,72.8 151.83,72.8 151.83,20.87 140.7,20.87 139.52,20.38 139.03,19.2 139.03,9.93 92.86,9.93 91.98,9.06 91.98,8.54 91.28,8.36 90.74,7.87 90.5,7.01 90.81,6.18 90.81,3.16 90.17,2.55 89.93,1.69 89.93,1.17
+19VB on IN4: 14.99,1.17 14.92,1.23 1.78,1.23 1.27,1.74 1.27,24.41 1.59,24.73 18.03,24.73 18.35,24.41 18.35,12.85 20.51,10.7 37.72,10.7 39.88,8.54 51.33,8.54 55.14,4.73 81.53,4.73 82.68,5.87 83.69,5.87 91.06,13.24 134.39,13.24 134.82,13.67 134.82,21.44 137.48,24.1 143.26,24.1 146.81,27.66 146.81,53.75 144.65,55.91 144.65,69.94 145.35,70.64 151.45,70.64 151.83,70.26 151.83,20.87 139.03,20.87 139.03,11.65 137.7,10.31 91.19,10.31 90.64,9.77 90.64,7.25 90.63,6.99 90.67,6.73 90.67,5.82 89.79,4.94 87.37,4.94 85.39,4.37 84.53,2.5 84.53,1.17 ; 1 cut-out
+19VB on IN4: 73.32,121.99 71.11,124.2 70.28,124.2 69.96,123.88 69.96,122.94 71.6,121.3 71.6,117.99 72.15,117.44 73.16,117.44 73.32,117.6
+19VB_1.0VS_VGAP on BOTTOM (solid shape): 73.82,105.18 78.39,105.18 78.77,104.8 78.77,99.95 78.68,99.85 78.65,99.85 78.44,99.63 75.69,99.63 75.45,99.88 75.45,100.79 75.88,101.22 75.88,102.1 75.91,102.14 75.91,102.74 75.69,102.96 73.31,102.96 72.34,103.93 72.23,104.04 72.23,105.12 72.29,105.18 73.82,105.18
+19VB_1.2V on BOTTOM (solid shape): 151.07,57.3 151.07,52.92 150.5,52.35 141.8,52.35 140.46,51.02 137.99,51.02 137.86,51.15 137.86,53.62 138.81,54.57 143.83,54.57 144.53,55.27 144.53,56.92 145.03,57.43 150.94,57.43
+19VB_1.8VGS on TOP: 42.74,10.31 48.58,10.31 48.77,10.12 48.77,9.11 48.39,8.73 48.39,7.33 48.26,7.2 47.37,7.2 46.48,8.09 45.41,8.09 45.18,8.33 44.87,8.33 44.69,8.5 42.63,8.5 42.48,8.65 42.48,10.06
+19VB_1VALWP on TOP (solid shape): 132.97,26.44 132.97,25.68 133.29,25.36 138.43,25.36 138.56,25.24 138.56,23.78 138.3,23.52 135.57,23.52 135.32,23.27 131.83,23.27 131.64,23.46 131.64,26.57 131.83,26.76 132.65,26.76
+19VB_1VALWP on BOTTOM (solid shape): 133.48,30.25 133.48,27.59 133.35,27.46 133.35,24.95 132.98,24.58 131.79,24.58 131.57,24.79 131.57,28.86 131.13,29.3 129.79,29.3 129.67,29.43 129.67,31.52 129.98,31.84 131.89,31.84
+19VB_3V on TOP (solid shape): 67.56,31.27 67.56,25.12 67.39,24.95 65.18,24.95 65.04,25.09 65.04,26.05 65.28,26.29 65.28,27.59 65.02,27.84 65.02,30.19 64.83,30.38 64.45,30.38 64.39,30.44 63.82,30.44 63.75,30.51 63.75,31.78 63.94,31.97 66.87,31.97
+19VB_3V on BOTTOM (solid shape): 66.45,29.97 66.45,28.25 66.33,28.13 65.06,28.13 64.99,28.19 64.99,29.97 65.12,30.1 66.33,30.1
+19VB_5V on TOP (solid shape): 62.61,31.78 62.61,30.19 60.01,27.59 60.01,25.25 59.9,25.14 59.6,25.14 59.6,25.14 59.46,25.14 58.74,24.41 58.74,22.96 58.47,22.7 56.96,22.7 56.39,23.27 56.39,27.71 58.93,30.25 58.93,31.4 59.5,31.97 62.42,31.97
+19VB_CHG on TOP: 23.32,14.19 23.74,13.77 23.74,12.87 23.6,12.73 19.45,12.73 19.44,12.73 18.99,12.73 18.86,12.85 18.86,14 19.05,14.19
+19VB_CHG on TOP: 14.22,18.89 16.76,18.89 16.95,18.7 16.95,16.66 16.83,16.54 14.22,16.54 14.03,16.73 14.03,18.7
+19VB_CHG on BOTTOM: 36.58,12.92 36.38,12.72 18.86,12.72 18.54,13.04 18.54,14.82 18.92,15.2 30.29,15.2 31.62,16.54 31.62,18.82 31.81,19.01 36.32,19.01 36.58,18.76
+19VB_CHG on IN1: 15.24,18.51 21.72,18.51 22.48,17.74 22.48,13.11 22.23,12.85 15.49,12.85 14.86,13.49 14.86,18.13
+19VB_CPU on TOP (solid shape): 151.7,82.58 151.7,74.64 151.45,74.39 144.4,74.39 144.21,74.58 144.21,76.16 144.34,76.29 149.22,76.29 149.48,76.55 149.48,79.34 150.43,80.29 150.43,82.58 150.56,82.7 151.57,82.7
+19VB_CPU on BOTTOM (solid shape): 126.33,134.74 127.73,134.74 127.91,134.56 127.91,133.03 127.8,132.91 125.17,132.91 125.1,132.99 125.1,134.89 125.17,134.96 126.11,134.96
+19VB_CPU on BOTTOM (solid shape): 100.16,132 100.16,129.35 100.05,129.23 97.87,129.23 97.79,129.31 97.79,130.35 97.84,130.41 98.48,130.41 98.62,130.56 98.62,132.18 98.68,132.24 99.93,132.24
+19VB_CPU on BOTTOM (solid shape): 108.22,131.4 108.22,129.51 108.1,129.39 106.27,129.39 106.16,129.5 106.16,130.43 106.24,130.51 106.91,130.51 107.03,130.63 107.03,131.51 107.09,131.57 108.05,131.57
+19VB_CPU on TOP: 106.93,132.11 107.09,132.26 109.27,132.26 109.33,132.2 109.33,131.43 109.52,131.24 110.79,131.24 110.86,131.18 110.86,130.04 110.73,129.91 108.04,129.91 107.63,129.5 106.3,129.5 106.24,129.57 106.24,130.33 106.36,130.46 106.74,130.46 106.93,130.65
+19VB_CPU on TOP: 98.42,132.04 98.64,132.26 100.95,132.26 101.02,132.2 101.02,131.43 101.21,131.24 102.48,131.24 102.54,131.18 102.54,130.04 102.41,129.91 99.76,129.91 99.16,129.31 97.85,129.31 97.73,129.44 97.73,130.2 97.85,130.33 98.3,130.33 98.42,130.46
+19VB_CPU on TOP: 90.04,131.65 90.67,131.65 91.24,132.22 92.32,132.22 92.38,132.16 92.38,131.4 92.57,131.21 93.84,131.21 93.9,131.14 93.9,130 93.78,129.87 90.04,129.87 89.92,130 89.92,131.52
+19VB_CPU on TOP: 127,126.27 128.21,126.27 128.4,126.08 128.4,125.25 129.79,123.85 129.79,121.82 129.6,121.63 128.97,121.63 128.84,121.5 128.84,120.3 128.71,120.17 127.7,120.17 127.57,120.3 127.57,124.74 126.81,125.5 126.81,126.08
+19VB_CPU on TOP: 81.47,131.54 83.19,131.54 83.76,132.11 84.84,132.11 84.9,132.04 84.9,131.28 85.09,131.09 86.36,131.09 86.42,131.03 86.42,129.89 86.3,129.76 81.47,129.76 81.41,129.82 81.41,131.47
+19VB_CPU on TOP: 111.76,138.33 113.98,138.33 114.3,138.01 114.3,134.9 113.98,134.58 111.89,134.58 111.51,134.97 111.51,138.08
+19VB_CPU on TOP: 148.91,105.3 151.13,105.3 151.32,105.11 151.32,103.77 151.19,103.65 150.3,103.65 150.05,103.39 148.78,103.39 148.65,103.52 148.65,105.04
+19VB_CPU on TOP: 125.29,134.97 126.24,134.97 126.56,134.65 128.14,134.65 128.27,134.52 128.27,131.83 128.15,131.71 127.43,131.71 127.25,131.53 127.25,130.39 127.06,130.2 126.17,130.2 125.98,130.39 125.98,132.68 125.16,133.5 125.16,134.84
+19VB_CPU on TOP: 102.36,138.39 104.58,138.39 104.9,138.08 104.9,134.97 104.58,134.65 102.49,134.65 102.11,135.03 102.11,138.14
+19VB_CPU on BOTTOM: 79.97,131.52 79.97,129.76 80.04,129.69 91.68,129.69 91.86,129.86 91.86,131.52 91.71,131.67 85.33,131.67 85.26,131.6 80.04,131.6
+19VB_CPU on IN2: 146.05,81.69 144.78,82.96 144.78,105.31 145.41,105.95 151.13,105.95 151.83,105.25 151.83,78.96 151.51,78.64 146.75,78.64 146.05,79.34
+19VB_CPU on VCC: 144.65,73.31 144.65,90.75 142.54,92.86 140.65,92.86 140.65,105.61 132.63,113.63 121.67,113.63 121.67,123.13 119.04,125.76 81.47,125.76 81.47,129.21 88.18,135.92 126.13,135.92 130.56,131.49 130.56,128.07 140.67,117.95 151.83,117.95 151.83,73.31
+19VB_VCCGT on TOP (solid shape): 151.7,86.74 151.7,83.95 150.61,82.86 149.99,82.86 149.67,82.54 149.67,80.61 149.54,80.48 148.53,80.48 148.4,80.61 148.4,81.63 146.53,83.5 146.53,83.77 149.62,83.77 149.62,84.42 150.84,84.42 150.84,85.18 150,85.18 150,84.42 149.62,84.42 149.62,84.66 148.47,84.66 148.47,83.77 146.53,83.77 146.53,84.77 146.37,84.93 145.22,84.93 145.03,85.12 145.03,85.94 145.29,86.2 147.64,86.2 148.26,86.82 148.26,87.18 148.3,87.21 151.23,87.21
+19VB_VCCIO on TOP (solid shape): 135.95,51.27 135.95,49.57 135.05,48.67 135.05,48.14 135,48.08 134.67,48.08 134.5,47.91 134.5,47.21 134.34,47.06 133.43,47.06 133.2,46.83 130.99,46.83 130.8,47.03 130.8,47.97 131.83,49 133.06,49 133.39,49.33 133.39,49.67 133.63,49.91 134.33,49.91 134.75,50.32 134.75,51.27 134.87,51.4 135.83,51.4
+19VB_VCCIO on BOTTOM (solid shape): 134.81,48.92 134.81,47.48 133.7,46.37 132.81,46.37 132.14,47.04 132.14,48.99 132.4,49.24 134.49,49.24
+19VB_VCCSA on TOP: 148.15,97.75 148.02,97.88 148.02,98.71 147.89,98.83 146.94,98.83 146.75,99.02 146.75,99.98 146.62,100.1 145.35,100.1 145.16,100.29 145.16,101.25 145.29,101.37 147.89,101.37 148.27,101.75 148.27,102.9 148.59,103.22 150.18,103.22 150.47,102.92 150.47,101.6 149.99,101.12 149.99,97.88 149.86,97.75
+VCC_CORE on TOP: outline of 429 points within 84.58,104.7 121.28,127.85
+VCC_CORE on TOP: outline of 141 points within 100.94,92.27 121.02,93.97
+VCC_CORE on BOTTOM: 88.52,120.74 100.08,120.74 100.58,120.23 105.54,120.23 105.98,119.79 105.98,117.83 105.99,117.83 106.25,117.58 110.11,117.58 111.12,118.6 111.12,121.9 114.6,125.38 118.92,125.38 119.46,124.84 119.46,117.48 119.13,117.15 114,117.15 113.31,116.46 98.27,116.46 98.12,116.61 88.71,116.61 88.07,117.25 88.07,120.3
+VCC_CORE on BOTTOM: 121.69,105.95 121.69,107.29 121.42,107.56 120.99,107.58 120.97,108 120.69,108.29 120.69,111.15 119.19,112.64 119.19,113.56 118.36,114.39 104.9,114.39 104.5,113.99 104.5,111.54 104.54,111.44 104.64,111.41 105.03,111.09 104.64,110.76 104.54,110.73 104.5,110.63 104.5,109.11 104.36,108.97 104.36,108.81 104.42,108.72 104.53,108.73 105.05,108.48 104.53,108.24 104.42,108.25 104.36,108.16 104.36,106.8 105.09,106.07 105.09,100.61 104.27,99.79 104.27,93.56 104.52,93.31 122.58,93.31 123.19,93.92 123.19,104.44
+VCC_CORE on IN1: 103.07,95.46 103.63,94.9 123.44,94.9 123.85,95.3 123.85,97.3 122.69,98.46 122.69,105.72 122.16,106.26 122.13,106.25 121.81,106.33 121.73,106.65 121.74,106.67 120.79,107.63 120.79,118.64 119.44,119.98 118.11,119.98 117.86,120.23 117.86,121.88 120.59,124.61 120.59,127.98 119.7,128.87 115.76,128.87 115.25,128.36 115.25,122.71 113.16,120.61 88.39,120.61 87.88,120.11 87.88,117.63 88.52,116.99 91.12,116.99 91.19,117.06 99.95,117.06 103.85,113.15 103.85,101.89 103.07,101.11
+VCC_CORE on IN2: 113.14,92.38 113.44,92.68 118.11,92.68 118.19,92.73 118.21,92.82 118.51,93.24 118.81,92.82 118.82,92.73 118.9,92.68 120.85,92.68 120.94,92.73 120.95,92.82 121.25,93.24 121.55,92.82 121.56,92.73 121.65,92.68 121.77,92.68 121.85,92.73 121.86,92.82 121.85,93 121.94,93.15 121.94,105.97 121.58,106.33 121.51,106.36 121.43,106.33 120.98,106.32 120.98,106.78 121.02,106.85 120.99,106.92 120.81,107.09 120.81,111.03 119.68,112.16 117.74,112.16 115.76,114.14 115.76,114.14 115.44,114.45 104.9,114.45 103.82,113.38 103.82,94.45 103.16,93.79 102.3,93.79 102.3,93.77 102.21,93.58 102.02,93.49 102,93.49 101.71,93.2 101.71,92.61 101.94,92.38
+VCC_CORE on VCC: 102.17,92.86 102.17,108.78 99.17,111.79 81.51,111.79 81.47,111.83 81.47,125.25 118.83,125.25 121.16,122.92 121.16,92.86
+VCC_CORE on IN3: 110.36,92.41 110.36,92.41 113.17,92.41 113.2,92.44 120.21,92.44 121.84,94.07 121.84,106.07 121.58,106.33 121.51,106.36 121.43,106.33 120.98,106.32 120.98,106.78 121.02,106.85 120.99,106.92 120.62,107.28 120.62,111.21 119.66,112.17 116.31,112.17 115.91,112.57 115.9,112.57 115.79,112.65 115.71,112.76 115.71,112.77 113.51,114.97 106.69,114.97 104.4,112.69 104.4,111.46 104.45,111.37 104.55,111.37 105.01,111.09 104.55,110.8 104.45,110.8 104.4,110.71 104.4,108.83 104.45,108.75 104.56,108.75 105.05,108.48 104.56,108.22 104.45,108.22 104.4,108.13 104.4,99.1 104.29,98.99 104.29,98.78 103.95,98.44 103.95,98.42 103.85,98.2 103.63,98.1 103.61,98.1 102.78,97.28 102.78,94.02 101.67,92.91 101.67,92.51 101.77,92.41
+VCC_CORE on IN4: 121.65,106.76 120.77,107.64 120.77,123.28 118.81,125.25 115.7,125.25 110.68,120.23 88.65,120.23 88.14,119.73 88.14,112.61 88.96,111.79 99.19,111.79 103.82,107.16 103.82,92.87 104.47,92.22 121.21,92.22 121.65,92.66
+VCCGT on TOP: outline of 352 points within 121.79,91.72 144.91,113.18 ; 2 cut-outs
+VCCGT on BOTTOM: 140.84,97.25 142.88,97.25 143.19,96.93 143.19,94.2 142.88,93.88 133.12,93.88 131.83,92.59 129.57,92.59 129.57,92.59 129.41,92.6 129.28,92.53 128.83,92.53 128.58,92.65 128.33,92.53 127.74,92.53 127.73,92.54 127.65,92.55 127.57,92.54 127.56,92.53 126.94,92.53 126.74,92.6 126.53,92.53 126.05,92.53 125.93,92.6 125.8,92.62 125.78,92.62 125.66,92.74 123.83,92.74 123.44,93.12 123.44,104.36 121.81,106 121.81,106.91 121.79,106.93 121.79,106.95 121.79,112.8 122.3,113.31 138.05,113.31 139.51,111.85 139.51,98.58
+VCCGT on IN1: 121.63,107.12 121.9,106.84 121.93,106.86 122.15,106.85 122.32,106.7 122.41,106.65 122.5,106.7 123.05,106.7 122.77,106.22 122.77,98.88 124.04,97.6 124.04,95.31 124.33,95.02 128.08,95.02 129.1,94.01 133.7,94.01 134.27,94.58 134.27,96.2 133.67,96.8 133.67,103.55 132.68,104.54 131.74,104.54 131.63,104.55 131.52,104.6 131.51,104.6 131.33,105.08 131.74,105.38 131.88,105.38 131.88,107.66 131.87,107.68 131.82,107.88 131.87,108.08 131.88,108.09 131.88,108.97 131.95,109.04 131.94,109.1 131.94,109.13 132.14,109.43 132.49,109.34 133.54,109.34 133.63,109.4 133.62,109.51 133.87,110.02 134.12,109.51 134.11,109.4 134.2,109.34 135.14,109.34 136.26,110.47 136.26,113.31 135.72,113.85 122.39,113.85 121.63,113.08
+VCCGT on IN2: outline of 94 points within 117.41,92.51 136.57,113.34
+VCCGT on VCC: 121.67,92.86 121.67,113.12 132.42,113.12 140.14,105.4 140.14,92.86
+VCCGT on IN3: 131.94,92.51 131.96,92.55 132.21,92.75 132.51,92.62 132.59,92.58 132.67,92.61 132.76,92.7 133.75,92.7 133.76,92.71 133.89,92.74 134.01,92.71 134.02,92.7 134.29,92.7 134.44,92.86 134.44,92.94 134.68,93.19 134.68,102.45 133.6,103.53 133.6,108.72 134.35,109.47 135.75,109.47 135.83,109.55 135.83,111.66 134.18,113.31 121.98,113.31 121.77,113.1 121.77,106.81 121.8,106.79 121.84,106.8 122.1,106.87 122.32,106.7 122.41,106.65 122.5,106.7 123.09,106.54 122.49,106.39 122.49,93.77 123.75,92.51 123.75,92.51 123.97,92.6 124.18,92.51 124.65,92.51 124.9,92.63 125.15,92.51 125.59,92.51 125.82,92.61 126.05,92.51 126.53,92.51 126.74,92.59 126.94,92.51 127.54,92.51 127.55,92.52 127.65,92.53 127.75,92.52 127.76,92.51 128.33,92.51 128.58,92.64 128.83,92.51 129.27,92.51 129.48,92.59 129.69,92.51 130.18,92.51 130.19,92.52 130.35,92.56 130.51,92.52 130.52,92.51 131.03,92.51 131.12,92.58 131.09,92.69 131.31,93.25 131.52,92.69 131.49,92.58 131.59,92.51
+VCCGT on IN4: 123.75,92.93 123.99,92.69 130.91,92.69 130.99,92.73 131.01,92.82 131.19,93.22 131.59,93.06 131.67,93.01 131.76,93.03 134.13,93.03 134.21,93.07 134.29,93.44 134.54,93.56 134.61,93.59 134.64,93.66 134.64,95.8 133.54,96.89 133.54,97.53 133.42,97.65 133.39,97.63 132.92,97.89 133.35,98.21 133.38,98.2 133.56,98.38 133.56,100.69 133.52,100.76 133.44,100.79 132.93,101.01 133.34,101.38 133.38,101.37 133.42,101.36 133.51,101.37 133.56,101.45 133.56,102.6 133.57,102.75 133.64,102.87 133.64,104.01 133.58,104.11 133.56,104.23 133.57,104.24 133.57,104.26 133.66,104.45 133.86,104.55 133.86,112.87 133.29,113.44 122.24,113.44 121.74,112.94 121.74,107.16 122.02,106.87 122.04,106.87 122.04,100.93 122.58,100.4 122.58,98.78 122.63,98.72 122.63,93.36 123.06,92.93
+VCCIO on BOTTOM (solid shape): 119.89,55.78 119.89,55.15 119.89,55.14 119.89,54.59 119.59,54.3 119.59,53.36 119.05,53.36 119.05,50.75 119,50.7 117.35,50.7 117.03,51.02 117.03,53.37 116.97,53.43 116.97,55.91 117.09,56.03 119.63,56.03
+VCCIO on BOTTOM (solid shape): 102.23,103.09 102.23,95.83 101.92,95.51 100.34,95.51 100.15,95.7 100.15,96.23 100.12,96.26 100.12,96.73 99.52,97.33 99.52,97.72 99.57,97.82 99.68,97.84 100.09,98.16 99.68,98.48 99.57,98.5 99.52,98.6 99.52,98.98 100.9,100.36 100.9,103.09 101.09,103.28 102.04,103.28
+VCCIO on TOP: outline of 134 points within 99.47,94.39 102.94,104.33
+VCCIO on IN3: outline of 85 points within 90.68,50.45 119.32,103.28
+VCCIOP on TOP (solid shape): 124.51,54.32 125.35,54.32 125.86,53.81 125.86,50.38 125.6,50.13 121.67,50.13 121.41,50.38 121.41,53.88 121.86,54.32 121.88,54.32 121.98,54.42 124.41,54.42
+VCCIOP on BOTTOM (solid shape): 123.79,54.26 123.79,50.98 123.25,50.45 120.02,50.45 119.76,50.7 119.76,54.07 120.02,54.32 122.44,54.32 122.58,54.46 123.58,54.46
+VCCSA on TOP: 140.14,117.76 146.11,117.76 146.24,117.63 146.24,113.38 144.78,111.91 144.78,110.07 145.35,109.5 145.35,106.71 145.16,106.52 142.94,106.52 142.62,106.83 142.62,111.53 141.54,112.61 140.72,112.61 137.67,115.66 137.67,118.58 137.79,118.71 139.19,118.71
+VCCSA on TOP: outline of 102 points within 101.15,104.9 104.07,114.18
+VCCSA on BOTTOM: 104.82,100.78 104.82,103.45 104.82,103.46 104.82,106.18 104.12,106.88 104.12,113.51 103.37,114.26 101.79,114.26 101.28,113.76 101.28,107.68 101.46,107.5 101.5,107.51 101.53,107.51 101.74,107.46 101.88,107.29 101.88,107.27 102.2,106.95 102.49,106.95 102.58,106.86 102.58,106.81 103.76,105.63 103.76,100.87 104.01,100.61 104.65,100.61
+VCCSA on IN3: 103.5,106.39 103.95,106.83 103.95,113.88 105.28,115.22 137.16,115.22 137.92,114.45 140.4,114.45 141.54,115.6 141.54,118.58 140.21,119.92 103.12,119.92 100.97,117.76 100.97,107.98 102.55,106.39
+VCCST on BOTTOM (solid shape): 100.9,106.06 101.26,106.06 101.37,105.95 101.37,105.44 101.54,105.27 101.93,105.27 102.21,104.99 102.21,104.19 102.1,104.08 101.22,104.08 100.99,104.31 100.99,104.89 100.7,105.18 100.7,105.21 100.65,105.4 100.51,105.53 100.47,105.53 100.37,105.55 100.27,105.53 100.26,105.53 99.9,105.53 99.82,105.56 99.74,105.56 99.71,105.56 99.13,105.56 99,105.69 99,106.2 99.16,106.36 100.6,106.36
+VCCST on TOP: 89.09,108.74 92.2,108.74 92.46,108.49 92.46,107.22 92.14,106.9 89.09,106.9 88.84,107.15 88.84,108.49
+VCCST on IN3: 91.5,108.49 93.41,108.49 95.31,106.58 100.46,106.58 100.58,106.45 100.58,105.82 100.46,105.69 100.08,105.69 99.95,105.56 99.95,104.99 100.14,104.8 101.98,104.8 102.23,104.55 102.23,103.98 100.9,102.64 96.08,102.64 91.31,107.41 91.31,108.3
+VCCSTG on TOP (solid shape): 141.92,105.06 141.92,102.67 141.75,102.5 139.98,102.5 139.88,102.6 139.88,104.84 139.98,104.95 140.8,104.95 141.03,105.18 141.8,105.18
+VCCSTG on TOP: 88.9,114.14 89.28,114.14 89.47,113.95 89.47,112.99 89.98,112.49 92.2,112.49 92.46,112.23 92.46,111.03 92.27,110.84 88.96,110.84 88.77,111.03 88.77,114.01
+VCCSTG on IN3: 90.23,111.09 93.47,111.09 95.85,108.71 95.85,107.5 96.77,106.58 100.71,106.58 100.9,106.39 100.9,105.76 100.71,105.56 100.2,105.56 100.08,105.44 100.08,105.06 100.27,104.87 101.73,104.87 101.92,105.06 101.92,106.77 95.25,113.44 90.11,113.44 89.79,113.12 89.79,111.53
+VIN_DGPU on TOP: 52.32,30.32 53.09,30.32 53.16,30.24 53.16,29.76 53.52,29.4 53.52,28.83 53.49,28.79 52.39,28.79 52.26,28.92 52.26,30.25
+VIN_DGPU on TOP: 24.6,25.67 24.47,25.8 24.47,25.96 23.6,25.96 23.46,26.1 23.46,26.56 23.34,26.67 22.61,26.67 22.45,26.82 22.45,29.39 21.91,29.94 16.76,29.94 16.45,30.25 16.45,30.26 16.28,30.43 16.06,30.43 16.05,30.43 15.24,30.43 15.14,30.53 15.14,33.16 15.59,33.61 17.61,33.61 17.86,33.87 20.89,33.87 21.09,34.07 24.55,34.07 24.75,34.27 29.85,34.27 30.04,34.45 30.04,38.12 30.29,38.38 31.9,38.38 31.97,38.31 33.63,38.31 34.29,37.65 34.29,27.43 34.28,27.43 34.28,27.09 34.06,26.86 30.71,26.86 30.34,26.49 30.34,26.04 29.97,25.67
+VIN_DGPU on BOTTOM: 30.33,34.76 30.33,37.47 30.67,37.81 34.09,37.81 34.32,37.58 34.32,27.08 34.07,26.84 30.58,26.84 30.26,27.16 30.26,27.22 29.76,27.73 29.76,32.77 29.57,32.96 29.57,32.97 29.16,33.38 29.16,33.98 29.35,34.17 29.73,34.17 ; 2 cut-outs
+VIN_DGPU on IN2: 25.36,26.91 24.35,27.93 17.21,27.93 16.21,28.93 16.21,35.14 16.43,35.37 16.43,36.03 16.97,36.57 25.55,36.57 26.16,35.96 28.51,35.96 29.4,36.85 29.4,36.86 29.76,37.21 29.76,37.79 30.39,38.42 32.4,38.42 32.59,38.23 32.59,36.31 31.64,35.36 31.64,27.82 30.77,26.95 30.77,26.91
GND on TOP (solid shape): 124.08,150.9 124.08,148.32 123.23,146.27 120.51,146.27 120.51,152.89 123.04,152.89
GND on TOP (solid shape): 22.2,29.14 22.2,28.07 21.97,27.84 19.49,27.84 19.3,28.03 19.3,29.56 19.43,29.68 21.65,29.68
GND on TOP (solid shape): 29.98,40.79 29.98,38.69 29.88,38.59 29.29,38.59 29.2,38.67 29.2,40.79 29.26,40.86 29.92,40.86
GND on TOP (solid shape): 37.6,40.83 37.6,38.78 37.43,38.6 36.74,38.6 36.63,38.71 36.63,40.73 36.79,40.9 37.54,40.9
GND on TOP (solid shape): 45.2,40.55 45.2,38.55 45.12,38.47 44.46,38.47 44.31,38.62 44.31,40.55 44.42,40.67 45.09,40.67
GND on TOP (solid shape): 49.54,41.28 49.54,38.75 49.36,38.57 48.45,38.57 48.35,38.67 48.35,40.73 49.01,41.39 49.43,41.39
GND on TOP (solid shape): 53.2,40.79 53.2,38.71 53.05,38.56 52.37,38.56 52.31,38.62 52.31,40.83 52.4,40.92 53.07,40.92
GND on TOP (solid shape): 57.25,41.32 57.25,38.65 57.12,38.52 56.16,38.52 56.01,38.67 56.01,40.64 56.76,41.39 57.18,41.39
GND on TOP (solid shape): 59.44,10.82 59.44,10.31 59.31,10.19 55.88,10.19 55.82,10.25 55.82,10.89 55.88,10.95 59.31,10.95
GND on TOP (solid shape): 122.7,56.11 122.7,54.86 122.57,54.72 121.62,54.72 121.46,54.88 121.46,55.99 121.7,56.23 122.58,56.23
GND on TOP (solid shape): 123.57,49.65 123.57,48.88 123.28,48.59 121.99,48.59 121.47,49.11 121.47,49.82 121.57,49.92 123.3,49.92
GND on TOP (solid shape): 138.24,33.62 138.24,28.29 138.11,28.16 136.78,28.16 136.59,28.35 136.59,33.68 136.72,33.81 138.05,33.81
GND on TOP (solid shape): 18.7,68.4 18.7,64.82 18.47,64.59 16,64.59 15.76,64.83 15.76,68.41 15.93,68.58 18.52,68.58
GND on TOP (solid shape): 34.16,41.25 34.16,38.71 34.09,38.64 33.01,38.64 32.96,38.69 32.96,39.89 33.6,40.54 33.6,41.23 33.68,41.3 34.11,41.3
GND on TOP (solid shape): 41.78,41.16 41.78,39.69 41.63,39.54 41.63,38.61 41.48,38.46 40.6,38.46 40.51,38.55 40.51,40.62 41.14,41.24 41.71,41.24
GND on TOP (solid shape): 48.78,11.9 48.78,10.56 48.64,10.43 44.7,10.43 44.67,10.46 44.67,11.82 44.72,11.88 45.28,11.88 45.61,12.21 48.46,12.21
GND on TOP (solid shape): 16.76,29.68 18.8,29.68 18.86,29.62 18.86,28.98 18.8,28.92 16.54,28.92 16.31,29.15 15.46,29.15 15.24,29.36 15.24,29.99 15.44,30.19 16.26,30.19
GND on TOP (solid shape): 26.39,41.21 26.39,39.75 25.74,39.11 25.74,38.57 25.64,38.47 24.98,38.47 24.87,38.59 24.87,39.46 25.57,40.16 25.57,41.15 25.67,41.25 26.35,41.25
GND on TOP (solid shape): 58.99,36.13 58.99,35.56 59.3,35.26 59.3,34.74 59.25,34.69 58.79,34.69 58.74,34.74 58.74,35.19 58.39,35.54 58.39,36.11 58.48,36.2 58.93,36.2
GND on TOP (solid shape): 22.05,38.9 22.05,36.58 21.07,35.6 18.49,35.6 18.28,35.82 18.28,36.38 18.64,36.74 20.68,36.74 21.15,37.21 21.15,38.28 21.08,38.34 21.08,38.98 21.15,39.04 21.91,39.04
GND on TOP (solid shape): 151.46,50.49 151.46,48.97 151.21,48.72 150.22,48.72 150.15,48.78 150.15,49.51 150.42,49.77 150.48,49.77 150.76,50.05 150.76,50.5 150.89,50.62 151.32,50.62
GND on TOP (solid shape): 129.43,106.58 129.62,106.58 129.82,106.78 129.97,106.78 130.11,106.64 130.11,106.45 129.73,106.06 129.73,105.35 129.66,105.29 129.41,105.29 129.28,105.42 129.28,106.05 128.9,106.43 128.9,106.62 129.06,106.78 129.22,106.78
GND on TOP (solid shape): 25.78,37.85 25.78,34.7 25.51,34.43 24.77,34.43 24.51,34.17 21.16,34.17 21.15,34.18 19.06,34.18 19.04,34.2 17.68,34.2 17.5,34.38 17.5,35.21 17.61,35.32 21.08,35.32 22.2,36.44 22.2,37.94 22.52,38.26 25.37,38.26
GND on TOP (solid shape): 116.35,26.12 116.48,26.12 116.54,26.1 116.6,26.09 116.62,26.09 116.66,26.04 116.93,26.04 117.17,25.8 117.17,24.48 117.07,24.39 116.34,24.39 116.09,24.64 116.09,25.68 115.93,25.83 115.93,26.09 115.98,26.14 116.33,26.14
GND on TOP (solid shape): 148.46,52.61 148.46,51.34 148.21,51.08 146.3,51.08 146.1,50.88 145.84,50.78 145.73,50.51 145.22,50.51 144.59,51.15 144.59,52.67 144.78,52.86 148.21,52.86
GND on TOP (solid shape): 147.87,48.08 147.87,47.89 147.99,47.77 148.95,47.77 149.01,47.7 149.01,47.58 148.95,47.51 147.99,47.51 147.87,47.39 147.87,46.5 147.8,46.43 146.22,46.43 146.15,46.5 146.15,47.01 146.02,47.13 145.07,47.13 145.01,47.2 145.01,47.39 145.07,47.45 146.02,47.45 146.15,47.58 146.15,47.89 146.09,47.96 145.07,47.96 145.01,48.02 145.01,48.15 145.07,48.21 147.74,48.21
GND on TOP (solid shape): 108.1,106.62 108.24,106.62 108.39,106.62 108.52,106.75 108.71,106.75 108.83,106.62 108.83,106.43 108.45,106.05 108.45,105.42 108.56,105.31 108.56,104.83 108.5,104.77 107.61,104.77 107.55,104.83 107.55,105.02 107.67,105.15 107.8,105.15 108.01,105.35 108.01,106.05 107.6,106.46 107.6,106.65 107.73,106.78 107.94,106.78
GND on TOP (solid shape): 7.33,62.64 7.33,61.1 7.44,60.99 8.03,60.99 8.1,61.06 8.1,61.69 8.17,61.75 9.16,61.75 9.21,61.7 9.21,58.04 9.36,57.89 9.36,57.28 9.26,57.18 7.54,57.18 7.47,57.25 7.47,57.61 7.42,57.66 7.1,57.66 7.09,57.67 7.09,60.06 6.93,60.21 5.71,60.21 5.59,60.34 5.59,61.71 5.65,61.78 6.83,61.78 6.99,61.93 6.99,62.63 7.05,62.69 7.28,62.69
GND on TOP (solid shape): 106.47,106.68 106.47,106.41 106.19,106.13 106.19,104.98 106.19,104.8 106.09,104.7 105.77,104.7 105.66,104.81 105.66,106.05 105.28,106.43 105.28,106.62 105.4,106.75 105.6,106.75 105.72,106.62 105.88,106.62 105.98,106.62 106.03,106.67 106.07,106.71 106.16,106.8 106.35,106.8
GND on TOP (solid shape): 74.61,79.53 74.61,78.2 74.74,78.07 75.12,78.07 75.31,78.26 75.31,78.58 75.37,78.64 76.26,78.64 76.39,78.51 76.39,75.02 77.15,74.26 77.15,71.47 76.9,71.21 75.12,71.21 75.06,71.27 75.06,73.24 74.55,73.75 74.55,73.94 74.36,74.13 74.36,76.86 74.23,76.99 73.14,76.99 72.96,77.17 72.96,78.58 73.03,78.64 74.17,78.64 74.3,78.77 74.3,79.53 74.36,79.59 74.55,79.59
GND on TOP (solid shape): 21.56,45.65 21.68,45.65 21.92,45.41 21.92,43.46 21.7,43.25 21.06,43.25 20.29,42.48 17.74,42.48 17.67,42.41 17.67,41.21 17.45,41 16.05,41 15.95,41.1 15.95,42.23 15.8,42.38 15.18,42.38 15.1,42.46 15.1,42.65 15.2,42.75 16.66,42.75 16.87,42.95 16.87,43.36 16.71,43.51 16.09,43.51 16.03,43.58 16.03,44.45 16.17,44.59 19.79,44.59 19.83,44.63 19.83,44.74 20.74,45.65 21.56,45.65
GND on TOP (solid shape): 114.75,91.9 114.94,91.9 115.49,91.34 115.49,91.14 115.49,91.13 115.45,90.97 115.49,90.81 115.49,90.8 115.49,90.58 115.41,90.49 115.2,90.49 115.16,90.53 115.15,90.55 115.08,90.68 114.94,90.76 114.93,90.76 114.9,90.79 114.71,90.79 114.61,90.9 114.61,91.14 114.63,91.16 114.63,91.21 114.63,91.22 114.65,91.3 114.63,91.38 114.63,91.38 114.63,91.48 114.61,91.51 114.54,91.51 114.53,91.51 114.47,91.54 114.41,91.55 114.39,91.55 114.19,91.76 114.19,91.99 114.29,92.09 114.56,92.09
GND on TOP (solid shape): outline of 201 points within 142.41,27.8 147.9,33.68
GND on TOP (solid shape): outline of 199 points within 23.1,43.02 79.57,49.77
GND on TOP (solid shape): 143.8,156.8 144.01,156.71 144.1,156.5 144.1,151.4 144.01,151.19 143.8,151.1 142.89,151.1 141.39,149.6 142.89,148.1 143.8,148.1 144.01,148.01 144.1,147.8 144.1,147.08 143.46,146.87 142.79,146.81 142.57,146.58 142.57,145.81 142.16,145.41 141.43,145.41 141.25,145.59 140.29,145.59 139.9,145.2 138.81,145.2 138.56,145.46 138.56,150.45 126.15,150.45 126.15,144.97 124.26,144.97 122.57,146.66 119.66,146.66 119.63,146.69 118.97,146.69 118.28,147.39 118.28,149.96 118.55,150.24 118.55,150.77 118.59,150.85 118.68,150.87 119.88,151.82 118.68,152.78 118.59,152.8 118.55,152.88 118.55,153.56 110.78,153.56 109.69,152.47 109.69,151.67 107.72,149.7 101.02,149.7 100.72,150.02 100.29,150.07 100.2,150.09 100.16,150.17 100.16,152.11 93.38,152.11 93.38,150.14 93.37,150.1 93.33,150.09 93.14,150.09 92.79,149.98 92.56,149.7 90.59,149.7 90.37,149.48 86.4,149.48 84.58,151.3 84.58,154.78 86.6,156.8
GND on TOP (solid shape): outline of 242 points within 2.5,8.1 10.59,13.6
GND on TOP (solid shape): outline of 179 points within 0.2,0.2 152.8,156.8
GND on TOP (solid shape): outline of 10799 points within 0.2,63.93 58.06,142.93
GND on BOTTOM (solid shape): 16.21,46.93 16.21,44.55 15.94,44.29 15.33,44.29 15,44.62 15,46.87 15.29,47.16 15.98,47.16
GND on BOTTOM (solid shape): 64.86,29.91 64.86,28.12 64.77,28.03 63.32,28.03 63.03,28.32 63.03,29.29 63.8,30.06 64.71,30.06
GND on BOTTOM (solid shape): 71.13,115.9 71.13,115.15 70.98,115 64.48,115 64.36,115.12 64.36,116.04 64.47,116.14 70.89,116.14
GND on BOTTOM (solid shape): 75.62,102.75 75.62,101.27 75.54,101.2 74.07,101.2 73.66,101.6 73.66,102.42 74.04,102.8 75.56,102.8
GND on BOTTOM (solid shape): 80.81,99.35 80.81,98.81 80.73,98.73 79.3,98.73 79.16,98.87 79.16,99.27 79.29,99.39 80.77,99.39
GND on BOTTOM (solid shape): 86.68,120.49 86.68,117.88 86.55,117.76 83.25,117.76 82.87,118.14 82.87,120.36 83.19,120.68 86.49,120.68
GND on BOTTOM (solid shape): 14.67,62.38 14.67,58.92 7.92,58.92 7.75,59.09 7.75,61 7.42,61.32 7.42,62.45 7.62,62.64 14.41,62.64
GND on BOTTOM (solid shape): 58.79,34.94 58.79,34.41 58.72,34.34 56.43,34.34 56.39,34.38 56.39,34.85 56.43,34.89 58.13,34.89 58.23,34.99 58.74,34.99
GND on BOTTOM (solid shape): 64.28,21.3 66.05,21.3 66.29,21.05 66.29,19.99 65.87,19.56 60.3,19.56 60.1,19.76 60.1,20.78 61.19,21.87 63.71,21.87
GND on BOTTOM (solid shape): 108.97,121.82 108.97,120.87 109.41,120.42 109.41,118.14 109.09,117.82 106.87,117.82 106.55,118.14 106.55,121.63 106.93,122.01 108.78,122.01
GND on BOTTOM (solid shape): 130.94,38.72 130.94,37.01 130.81,36.88 128.49,36.88 128.33,37.04 128.33,38.72 128.46,38.85 130.81,38.85
GND on BOTTOM (solid shape): 7.9,58.36 13.13,58.36 13.37,58.12 13.37,56.7 13.28,56.61 7.1,56.61 6.79,56.91 6.79,58.74 7.52,58.74
GND on BOTTOM (solid shape): 100,96.69 100,95.45 100.1,95.35 102.11,95.35 102.26,95.19 102.26,94.36 102.23,94.33 100.02,94.33 99.49,94.86 99.49,96.69 99.62,96.82 99.87,96.82
GND on BOTTOM (solid shape): 66.42,108.61 66.42,106.07 66.1,105.76 66.1,101.31 66.14,101.28 65.15,100.29 65.15,98.01 65.02,97.88 64.52,97.88 64.33,98.07 64.33,105.63 65.66,106.96 65.66,108.61 65.72,108.68 66.36,108.68
GND on BOTTOM (solid shape): 75.06,78.7 76.39,78.7 76.96,78.13 76.96,72.98 76.48,72.49 75.44,72.49 75.07,72.86 75.07,73.29 74.42,73.94 74.42,76.48 73.96,76.94 73.3,76.94 73.05,77.19 73.05,78.46 73.06,78.46 73.06,78.82 73.13,78.88 74.88,78.88
GND on BOTTOM (solid shape): 17.21,46.8 17.21,46.41 17.56,46.05 21.51,46.05 21.82,45.75 21.82,42.42 21.73,42.33 21.07,42.33 20.85,42.55 16.97,42.55 16.84,42.67 16.84,43.08 16.45,43.47 16.45,46.9 16.56,47.02 16.99,47.02
GND on BOTTOM (solid shape): 103.63,105.32 103.63,99.89 103.81,99.72 103.81,98.32 103.71,98.22 103.27,98.22 103.25,98.2 102.53,98.2 102.4,98.33 102.4,100.95 102.4,100.96 102.4,105.21 102.21,105.4 101.7,105.4 101.64,105.47 101.64,105.97 101.77,106.1 102.85,106.1
GND on BOTTOM (solid shape): 146.22,52.09 146.22,50.99 146.1,50.88 145.84,50.78 145.73,50.51 145.67,50.45 144.84,50.45 144.4,50.89 141.35,50.89 141.29,50.95 141.29,51.53 141.99,52.22 146.08,52.22
GND on BOTTOM (solid shape): 132.79,53.46 132.79,53.25 133.06,52.99 135.72,52.99 135.8,52.91 135.8,51.21 135.67,51.08 134.37,51.08 134.35,51.09 134.21,51.09 133.93,51.37 133.31,51.37 133.02,51.08 132.47,51.08 132.32,51.23 132.32,52.07 132.21,52.19 132.21,53.38 132.4,53.57 132.68,53.57
GND on BOTTOM (solid shape): 57.87,16.65 57.87,16.1 57.73,15.97 56.58,15.97 56.52,15.9 53.02,15.9 52.83,15.71 52.83,12.41 53.02,12.22 56.32,12.22 56.52,12.03 56.52,11.39 55.47,10.35 53.28,10.35 52.45,11.17 52.45,13.6 52.07,13.99 52.07,16.58 52.41,16.92 57.6,16.92
GND on BOTTOM (solid shape): 57.72,32.48 57.72,31.65 57.85,31.52 58.86,31.52 58.93,31.46 58.93,31.33 58.86,31.27 57.85,31.27 57.72,31.14 57.72,29.81 57.91,29.62 57.91,28.73 57.85,28.67 57.72,28.67 57.66,28.73 57.66,29.56 57.34,29.87 55.44,29.87 55.12,29.56 55.12,28.73 55.05,28.67 54.93,28.67 54.86,28.73 54.86,29.63 54.91,29.69 54.94,29.76 55.05,29.87 55.05,32.48 55.12,32.54 57.66,32.54
GND on BOTTOM (solid shape): 80.01,47.02 80.01,44.8 79.69,44.48 70.8,44.48 70.42,44.86 68.33,44.86 68.01,44.54 65.38,44.54 65.21,44.71 63.11,44.71 62.89,44.92 60.9,44.92 60.52,44.54 48.65,44.54 48.4,44.8 45.28,44.8 45.02,44.54 41.31,44.54 41,44.86 37.85,44.86 37.4,44.41 33.71,44.41 33.63,44.49 31.11,44.49 30.49,45.11 29.9,45.11 29.26,44.48 24.89,44.48 24.57,44.8 23.3,44.8 22.99,45.11 22.99,47.08 23.37,47.46 79.57,47.46
GND on BOTTOM (solid shape): 71.31,107.48 71.31,105.63 71.42,105.51 71.96,105.51 72.1,105.37 72.1,104.26 72.01,104.17 71.86,104.17 71.75,104.07 71.75,103.04 71.86,102.94 71.91,102.94 71.92,102.92 72.89,102.92 73.01,102.8 74.51,102.8 74.84,102.47 74.84,101.59 74.63,101.37 73.89,101.37 73.13,102.14 72.16,102.14 72.06,102.24 71.86,102.24 71.44,102.66 71.44,103.94 71.3,104.08 70.73,104.08 70.68,104.13 70.68,105.43 70.78,105.53 70.94,105.53 70.99,105.59 70.99,106.61 70.61,106.99 70.61,107.62 70.71,107.72 71.07,107.72
GND on BOTTOM (solid shape): outline of 393 points within 77.52,145.18 144.3,157
GND on BOTTOM (solid shape): outline of 171 points within 0.2,0.2 152.8,156.8
GND on IN1 (solid shape): 18.59,68.57 18.59,62.94 18.43,62.78 16.12,62.78 15.4,63.5 15.39,63.5 15.27,63.63 7.1,63.63 6.97,63.5 5.7,63.5 3.78,65.42 3.78,69.03 5.04,70.28 16.88,70.28
GND on IN1 (solid shape): 125.28,55.6 125.28,49.5 124.61,48.83 122.95,48.83 122.83,48.95 122.83,49.74 123.01,49.91 123.36,49.91 123.72,50.28 123.72,54.27 123.27,54.72 121.62,54.72 121.46,54.88 121.46,55.99 121.7,56.23 124.64,56.23
GND on IN1 (solid shape): outline of 176 points within 0.2,0.2 152.8,156.8
GND on IN2 (solid shape): outline of 176 points within 0.2,0.2 152.8,156.8
GND on IN3 (solid shape): 125.28,55.6 125.28,49.5 124.61,48.83 121.68,48.83 121.49,49.02 121.49,49.8 121.6,49.91 123.36,49.91 123.72,50.28 123.72,54.27 123.27,54.72 121.62,54.72 121.46,54.88 121.46,55.99 121.7,56.23 124.64,56.23
GND on IN3 (solid shape): outline of 271 points within 131.74,47.13 139.32,55.15
GND on IN3 (solid shape): outline of 176 points within 0.2,0.2 152.8,156.8
GND on IN4 (solid shape): 125.28,55.6 125.28,49.5 124.61,48.83 121.68,48.83 121.49,49.02 121.49,49.8 121.6,49.91 123.36,49.91 123.72,50.28 123.72,54.27 123.27,54.72 121.62,54.72 121.46,54.88 121.46,55.99 121.7,56.23 124.64,56.23
GND on IN4 (solid shape): 71.69,107.38 71.69,103.76 71.48,103.55 70.56,103.55 70.34,103.76 70.34,106.8 70.09,107.04 68.91,107.04 68.78,106.9 68.78,104.16 67.63,103.02 65.07,103.02 64.79,103.29 64.79,108.56 64.92,108.68 66.12,108.68 66.36,108.44 66.36,104.58 66.45,104.49 66.82,104.49 66.88,104.54 66.88,108.57 67.26,108.96 70.12,108.96
GND on IN4 (solid shape): outline of 384 points within 131.74,47.13 138.63,55.15
GND on IN4 (solid shape): outline of 178 points within 0.2,0.2 152.8,156.8
GND on TOP: 117.98,138.33 120.21,138.33 120.52,138.01 120.52,134.9 120.21,134.58 118.11,134.58 117.73,134.97 117.73,138.08
GND on TOP: 25.66,1.17 25.53,1.3 25.53,1.69 25.78,1.95 28.77,1.95 29.02,1.69 29.02,1.3 28.89,1.17
GND on TOP: 111.12,132.33 111.25,132.33 111.32,132.27 111.32,131.38 111.51,131.19 112.59,131.19 112.71,131.06 112.71,130.17 112.97,129.92 113.73,129.92 113.79,129.85 113.79,129.6 113.73,129.54 112.14,129.54 112.01,129.41 112.01,129.03 112.14,128.9 112.52,128.9 112.65,128.77 112.65,127.82 112.39,127.57 108.54,127.57 107.54,126.57 107.54,126.04 107.29,125.78 105.66,125.78 105.54,125.91 105.54,128.78 105.66,128.91 106.05,128.91 106.05,128.9 107.57,128.9 108.39,129.73 110.93,129.73 111.06,129.85 111.06,132.27
GND on TOP: 85.01,67.59 84.33,67.59 84.15,67.41 84.15,63.02 84.43,62.74 88.72,62.74 88.85,62.87 88.85,65.15 88.47,65.53 85.67,65.53 85.14,66.07 85.14,67.46
GND on TOP: 128.17,129.95 128.17,129.82 128.11,129.76 127.22,129.76 127.03,129.57 127.03,128.49 126.9,128.36 126.02,128.36 125.76,128.11 125.76,127.35 125.7,127.28 125.44,127.28 125.38,127.35 125.38,128.93 125.25,129.06 124.87,129.06 124.75,128.93 124.75,128.55 124.62,128.42 123.67,128.42 123.41,128.68 123.41,133.84 122.43,134.83 122.43,135.84 122.63,136.04 124.56,136.04 124.8,135.81 124.8,133.23 125.09,132.93 125.35,132.93 125.57,132.71 125.57,130.14 125.7,130.01 128.11,130.01
GND on TOP: 143.48,88.67 147.73,88.67 147.75,88.66 147.96,88.86 148.97,88.86 149.29,89.18 149.29,89.63 149.48,89.82 151.26,89.82 151.64,89.44 151.64,87.47 151.49,87.32 148.28,87.32 147.42,86.45 145.07,86.45 144.75,86.13 144.75,84.99 144.94,84.8 144.94,84.04 144.88,83.97 144.68,83.97 144.62,84.04 144.62,84.61 144.49,84.74 144.05,84.74 143.92,84.61 143.92,84.04 143.86,83.97 143.67,83.97 143.61,84.04 143.61,84.61 143.29,84.93 143.29,86.13 143.1,86.32 142.27,86.32 142.21,86.39 142.21,86.58 142.27,86.64 143.8,86.64 143.99,86.83 143.99,87.15 143.8,87.34 143.41,87.34 143.29,87.47 143.29,88.48
GND on TOP: 46.66,31.71 46.51,31.87 46.04,31.87 45.78,32.12 45.78,35.49 45.68,35.59 45.24,35.59 44.69,36.13 44.69,37.51 45.28,38.09 47.31,38.09 47.46,37.94 47.46,35.68 47.71,35.42 48.35,35.42 48.51,35.26 48.51,30.32 48.96,29.87 48.96,25.44 48.86,25.34 47.59,25.34 47.47,25.45 47.47,26.37 47.36,26.48 46.58,26.48 46.43,26.63 46.43,29.96 46.28,30.11 46.28,30.62 46.66,31
GND on TOP: 48.41,6.73 45.82,6.73 45.44,6.35 44.98,6.35 44.5,5.87 44.5,5.62 45.16,4.96 45.19,4.96 45.26,4.88 45.77,4.88 45.82,4.93 45.82,5.31 45.67,5.46 45.67,5.95 46.18,6.45 47.12,6.45 47.57,6 49.94,6 50.37,5.57 50.37,5.39 50.44,5.31 51.03,5.31 51.08,5.36 51.08,6.07 50.8,6.35 49.94,6.35 49.89,6.3 48.84,6.3
