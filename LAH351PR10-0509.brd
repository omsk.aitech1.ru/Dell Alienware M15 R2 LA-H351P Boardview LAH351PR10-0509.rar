# Allegro board LAH351PR10-0509.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+12.6V_BATT: length 28.4
  TOP w0.081: 36.59,5.7 37.72,5.7 38.14,5.29 v10(38.68,5.29)
  IN2 w0.508: v5(42.67,23.65) 35.24,16.22 35.24,12.58 34.31,11.65 29.55,11.65 v5(29.12,12.08) 25.91,12.08 v5(24.94,11.12)
  BOTTOM w0.203: PRB26.2 42.85,23.47 v5(42.67,23.65)
+12.6V_BATT+: length 1.5
  TOP w0.081: v10(38.68,8.35) 38.56,8.47 37.25,8.47
  vias: v1(33.49,8.22) v1(34.07,8.22) v1(34.66,8.22) v1(35.24,8.22) v1(35.83,8.22) v1(36.41,8.22) v5(33.27,7.72) v5(33.85,7.72) v5(34.42,7.72) v5(34.99,7.75) v5(35.56,7.75) v5(36.13,7.75) v5(36.13,7.17) v5(36.13,6.58) v5(36.7,7.75) v5(36.7,7.17) v5(36.7,6.58) v10(36.92,12.08) v10(38.86,12.17)
+12V_COMP: length 2.7
  BOTTOM w0.254: PR2512.1 139.24,34.74 139.24,35.47 v2(139.13,35.59) 138.94,35.4 138.15,35.4 137.89,35.65 PU2502.1
+12V_COMP_1: length 2.2
  BOTTOM w0.081: v2(140.34,32.74) 140.34,33.36 139.94,33.76 PC2515.1
  BOTTOM w0.254: PC2515.1 139.18,33.76 PR2512.2
+12V_ENA: length 2
  BOTTOM w0.254: PU2502.3 136.89,34.99 136.84,34.94 PR2507.1 PR2508.2
+12V_FAN: length 230
  TOP w0.081: v5(127.13,44.22) 127.13,45.77 v10(127.2,45.85)
  IN2 w0.508: v5(15.75,48.92) 14.17,47.35 14.17,38.63 13.82,38.27 13.82,30.14 13.67,29.99 13.67,28.91 11.17,26.42 11.17,21.7 13.26,19.61 13.26,15.42 15.39,13.29 15.39,8.13 16.37,7.16 17.09,7.16 18.54,8.61 30.1,8.61 v4(30.28,8.44)
  IN3 w0.508: v9(32.64,4.17) 34.47,4.17 36.7,1.93 38,1.93 38.66,2.59 38.66,3.66 40.64,5.64 42.66,5.64 42.71,5.64 43.32,5.52 43.89,5.28 43.97,5.23 44.4,4.94 46.47,2.87 48.49,2.87 49.41,1.95 65.02,1.95 65.59,2.52 70.35,2.52 70.47,2.63 75.53,2.63 76.05,2.12 78.34,2.12 79.21,2.99 83.4,2.99 84.94,4.52 84.94,6.02 88.14,9.22 89.55,9.22 94.96,14.63 97.41,14.63 97.85,15.08 105.98,15.08 108.1,17.2 113.06,17.2 114.6,18.75 114.6,21.29 114.81,21.49 v9(114.81,22.13) ; v5(127.13,43.59) 128.89,43.59 135.86,36.62 139.59,36.62 141.22,38.25 142.52,38.25 v9(142.82,37.95)
  GND4 w0.508: v6(115.44,22.13) v9(114.81,22.13) ; v9(142.82,37.95) 143.13,37.65 v4(143.13,37.52) ; v9(32.64,4.17) v4(32.21,4.17)
  IN4 w0.508: v6(115.44,22.13) 116.2,22.13 116.81,22.74 121.41,22.74 123.49,24.82 123.49,33.45 124.23,34.19 124.23,36.65 123.75,37.14 123.75,41.86 125.48,43.59 v5(127.13,43.59)
  BOTTOM w0.508: v4(32.21,4.17) 32.21,5.16 30.28,7.09 v4(30.28,8.44) ; JFAN2.1 145.88,46.43 146.81,45.49 146.81,39.14 145.19,37.52 v4(143.13,37.52)
+12V_FB: length 8.4
  BOTTOM w0.254: PU2502.2 137.39,35.28 137.65,35.03 138.01,35.03 138.46,34.58 138.46,32.78 v2(138.38,32.71) 138.07,32.71 137.76,33.02 136.36,33.02 136.08,33.3 PR2510.1 136.07,33.62 135.27,33.62 PR2511.2 PC2514.2
+12V_LX: length 2.6
  TOP w0.081: 135.59,38.45 134.75,39.28 v2(133.34,39.28)
  vias: v5(134.3,40.9) v5(134.89,40.91)
+12V_SNUB:
  vias: v2(133.52,36.03)
+12V_SS: length 1.7
  BOTTOM w0.081: PC2513.1 140.18,37.09 v2(140.18,36.88)
+12V_VIN:
  vias: v1(139.04,39.31) v1(139.04,38.99) v1(139.04,38.65) v1(139.42,39.31) v1(139.42,38.99) v1(139.42,38.65) v2(138.42,40.34) v3(138.87,39.84) v3(139.38,39.84) v3(139.89,39.84) v3(140.08,39.4) v3(140.07,38.84) v3(140.4,39.84) v4(140.44,39.08) v4(140.44,38.76) v4(140.75,39.08) v4(140.75,38.76)
+12VP: length 9.2
  BOTTOM w0.254: PC2519.1 131.48,39.55 132.94,38.08 132.94,35.79 PC2514.1 PR2511.1
  vias: v2(128.79,41.67) v5(132.32,43.55) v5(132.32,42.98) v5(132.32,42.41) v5(132.32,41.84)
+19V_ADPIN: length 0.8
  TOP w0.081: v5(8.94,36.95) 8.94,37.05 9.14,37.25 v10(9.51,37.25)
  vias: v5(12.78,31.7)
+19V_VIN: length 75.6
  TOP w0.254: v5(16.94,8.08) 16.94,7.29 16.63,6.98 16.37,6.98 15.95,6.57 PR31.1 ; v5(50.86,20.6) 48.07,20.6 47.24,19.78 v10(47.24,19.28) 47.24,16.27 46.95,15.98 45.69,15.98 45.47,16.2 v10(44.82,16.2) 44.64,16.01 PDB1.3
  IN1 w0.254: v5(19.89,26.76) 24.4,26.76 24.84,27.21 34.46,27.21 39.23,22.43 48.27,22.43 50.1,20.6 v5(50.86,20.6)
  IN2 w0.254: v5(19.89,27.4) 14.86,27.4 13.23,25.77 13.23,20.53 13.77,19.99 13.77,16.08 15.88,13.97 15.88,9.15 v5(16.94,8.08)
  BOTTOM w0.254: v5(50.86,20.6) 50.67,20.79 PRB39.1
  vias: v10(14.25,26.57)
+19VB: length 22
  TOP w0.254: v8(30.4,145) 30.39,145.01 29.67,145.01 29.62,144.96 RV9.1
  IN1 w0.254: v8(30.4,145) 30.78,144.62 35.32,144.62 v4(35.78,144.16)
  IN3 w0.254: v5(60.77,34.78) 60.77,28.16 59.26,26.65 54.67,26.65 54.04,26.01 v9(53.9,26.01)
  GND4 w0.254: v4(53.47,26.01) v9(53.9,26.01)
  BOTTOM w0.254: PR308.2 53.04,26.43 53.46,26.01 v4(53.47,26.01)
  vias: v1(35.64,143.61) v1(36.08,143.61) v1(36.18,144.16) v1(36.49,143.63) v1(44.74,6.82) v1(45.15,6.84) v2(15.72,14.35) v3(35.64,143.61) v3(36.08,143.61) v3(36.18,144.16) v3(36.49,143.63) v3(44.74,6.82) v3(45.15,6.84) v4(35.64,143.61) v4(36.08,143.61) v4(36.18,144.16) v4(36.49,143.63) v5(2.92,1.49) v5(3.49,1.49) v5(4.06,1.49) v5(4.64,1.49) v5(5.21,1.49) v5(5.78,1.49) v5(13.77,23.17) v5(13.77,22.6) v5(13.77,21.88) v5(13.77,21.31) v5(14.35,24.16) v5(14.35,23.59) v5(14.92,24.16) v5(14.92,23.59) v5(14.95,20.67) v5(15.25,20.14) v5(15.49,24.16) v5(15.49,23.59) v5(15.52,20.65) v5(16.07,24.16) v5(16.07,23.59) v5(16.69,24.08) v5(16.68,23.5) v5(17.25,23.94) v5(17.4,23.4) v5(18.03,23.4) v5(18.03,22.76) v5(18.03,22.13) v5(27.75,32.03) v5(27.76,32.64) v5(27.76,31.45) v5(28.35,32.64) v5(28.33,32.03) v5(28.35,31.45) v5(28.93,32.64) v5(28.92,32.03) v5(28.93,31.45) v5(29.51,32.64) v5(29.5,32.03) v5(29.51,31.45) v5(60.77,35.93) v5(60.77,35.36) v5(61.4,35.52) v5(61.4,34.95) v5(61.4,34.37) v5(61.98,35.52) v5(61.98,34.95) v5(61.98,34.37) v5(62.27,33.85) v5(62.55,35.52) v5(62.55,34.95) v5(62.55,34.37) v5(62.84,33.85) v5(63.12,35.52) v5(63.12,34.95) v5(63.12,34.37) v5(66.48,1.42) v5(67.06,1.42) v5(67.63,1.42) v5(68.2,1.42) v5(68.77,1.42) v5(76.47,51.18) v5(76.47,50.61) v5(76.47,50.04) v5(76.47,49.47) v5(76.47,48.9) v5(77.1,51.18) v5(77.1,50.61) v5(77.1,50.04) v5(77.1,49.47) v5(77.1,48.9) v5(78.91,1.44) v5(79.49,1.42) v5(80.07,1.42) v5(81.47,1.42) v5(82.04,1.42) v5(82.61,1.42) v5(83.19,1.42) v5(83.76,1.42) v5(84.33,1.42) v5(136.32,47.42) v5(136.32,46.85) v5(136.82,48.02) v5(136.89,47.42) v5(137.39,48.02) v5(139.7,21.62) v5(140.59,21.62) v5(141.54,21.62) v5(142.43,21.62) v5(143.38,21.68) v5(146.24,70.13) v5(146.24,69.5) v5(146.24,68.86) v5(146.88,70.13) v5(146.88,69.5) v5(146.88,68.86) v5(147.51,70.13) v5(147.51,69.5) v5(147.51,68.86) v5(148.08,69.5) v5(148.08,68.86) v5(148.72,69.5) v5(148.72,68.86) v5(150.43,36.16) v5(150.43,35.59) v5(150.43,35.02) v5(150.43,34.44) v5(150.43,33.87) v5(150.43,33.3) v5(150.37,22.38) v5(150.37,21.81) v5(150.37,21.24) v5(150.94,22.38) v5(150.94,21.81) v5(150.94,21.24) v5(151,36.16) v5(151,35.59) v5(151,35.02) v5(151,34.44) v5(151,33.87) v5(151,33.3) v5(151.51,22.38) v5(151.51,21.81) v5(151.51,21.24) v5(151.57,36.16) v5(151.57,35.59) v5(151.57,35.02) v5(151.57,34.44) v5(151.57,33.87) v5(151.57,33.3) v6(44.74,6.82) v6(45.15,6.84) v7(70.31,123.62) v7(70.31,123.29) v7(70.31,122.93) v7(70.62,123.12) v7(72.25,117.92) v7(72.62,117.92) v7(72.82,117.66) v7(73.04,117.92) v10(82.17,94.1)
+19VB_1.0VS_VGAP:
  vias: v2(78.19,103.58)
+19VB_1.2V: length 14.4
  IN1 w0.254: v1(148.39,42.97) 148.39,43.33 148.13,43.59 145.69,43.59 144.27,45.01 144.27,49.18 142.88,50.57 142.88,52.99 v4(142.43,53.43)
  vias: v2(138.62,53.49)
+19VB_1.8VGS:
  vias: v2(43.09,10.1)
+19VB_1VALWP:
  vias: v2(132.42,23.89) v5(131.95,26.51) v5(131.95,25.94) v5(131.95,25.36) v5(131.95,24.79) v5(132.52,26.51) v5(132.52,25.94) v5(132.52,25.36) v5(132.52,24.79)
+19VB_3V:
  vias: v2(66.62,28.13) v5(66.1,29.56) v5(66.1,28.92)
+19VB_5V:
  vias: v2(59.31,29.02)
+19VB_CHG: length 0.5
  TOP w0.081: v5(19.18,13.05) 19.15,13.02 v2(19.15,12.55)
  vias: v5(19.18,13.62) v5(19.75,13.62) v5(19.75,13.05) v5(20.32,13.62) v5(20.32,13.05) v5(20.89,13.62) v5(20.89,13.05) v5(21.46,13.62) v5(21.46,13.05) v5(22.03,13.62) v5(22.03,13.05) v8(15.11,18.13) v8(15.11,17.74) v8(15.11,17.36) v8(15.11,16.98) v8(15.43,18.13) v8(15.43,17.73) v8(15.43,17.36) v8(15.43,16.97) v8(15.75,18.13) v8(15.75,17.74) v8(15.75,17.36) v8(15.75,16.98) v8(16.07,18.13) v8(16.07,17.74) v8(16.07,17.36) v8(16.07,16.98) v8(16.38,18.13) v8(16.38,17.73) v8(16.38,17.36) v8(16.38,16.97) v8(16.7,18.13) v8(16.7,17.74) v8(16.7,17.36) v8(16.7,16.98)
+19VB_CPU: length 2.4
  BOTTOM w0.508: PCZ130.1 v5(129.9,125.77) ; PCZ47.1 v5(127.08,126.61) ; PCZ50.1 v5(128.74,124.29)
  vias: v1(83.88,130.84) v1(83.88,130.46) v1(83.88,130.08) v1(84.26,130.84) v1(84.26,130.08) v1(84.45,130.46) v1(84.65,130.84) v1(84.65,130.08) v1(85.03,130.84) v1(85.03,130.46) v1(85.03,130.08) v1(85.41,130.84) v1(85.41,130.08) v1(85.6,130.46) v1(85.79,130.84) v1(85.79,130.08) v1(86.17,130.84) v1(86.17,130.46) v1(86.17,130.08) v1(91.36,130.95) v1(91.36,130.57) v1(91.36,130.19) v1(91.74,130.95) v1(91.74,130.19) v1(91.94,130.57) v1(92.13,130.95) v1(92.13,130.19) v1(92.51,130.95) v1(92.51,130.57) v1(92.51,130.19) v1(92.89,130.95) v1(92.89,130.19) v1(93.08,130.57) v1(93.27,130.95) v1(93.27,130.19) v1(93.65,130.95) v1(93.65,130.57) v1(93.65,130.19) v1(100,130.99) v1(100,130.61) v1(100,130.23) v1(100.38,130.99) v1(100.38,130.23) v1(100.57,130.61) v1(100.76,130.99) v1(100.76,130.23) v1(101.14,130.99) v1(101.14,130.61) v1(101.14,130.23) v1(101.52,130.99) v1(101.52,130.23) v1(101.71,130.61) v1(101.9,130.99) v1(101.9,130.23) v1(102.29,130.99) v1(102.29,130.61) v1(102.29,130.23) v1(108.32,130.99) v1(108.32,130.61) v1(108.32,130.23) v1(108.7,130.99) v1(108.7,130.23) v1(108.89,130.61) v1(109.08,130.99) v1(109.08,130.23) v1(109.46,130.99) v1(109.46,130.61) v1(109.46,130.23) v1(109.84,130.99) v1(109.84,130.23) v1(110.03,130.61) v1(110.22,130.99) v1(110.22,130.23) v1(110.6,130.99) v1(110.6,130.61) v1(110.6,130.23) v1(126.14,132.74) v1(126.14,132.36) v1(126.14,131.98) v1(126.14,131.6) v1(126.14,131.22) v1(126.14,130.84) v1(126.14,130.46) v1(126.51,132.73) v1(126.51,132.16) v1(126.51,131.59) v1(126.51,131.02) v1(126.51,130.45) v1(126.9,132.74) v1(126.9,132.36) v1(126.9,131.98) v1(126.9,131.6) v1(126.9,131.22) v1(126.9,130.84) v1(126.9,130.46) v1(127.73,122.64) v1(127.73,122.26) v1(127.73,121.88) v1(127.73,121.5) v1(127.73,121.12) v1(127.73,120.74) v1(127.73,120.36) v1(128.09,122.64) v1(128.09,122.06) v1(128.09,121.49) v1(128.09,120.92) v1(128.09,120.35) v1(128.49,122.64) v1(128.49,122.26) v1(128.49,121.88) v1(128.49,121.5) v1(128.49,121.12) v1(128.49,120.74) v1(128.49,120.36) v2(85.47,130.74) v3(83.88,130.46) v3(84.45,130.46) v3(85.03,130.46) v3(85.6,130.46) v3(86.17,130.46) v3(90.93,129.97) v3(91.36,130.57) v3(91.94,130.57) v3(92.51,130.57) v3(93.08,130.57) v3(93.65,130.57) v3(99.49,131.09) v3(99.49,130.69) v3(99.49,130.28) v3(100,130.61) v3(100.57,130.61) v3(101.14,130.61) v3(101.71,130.61) v3(102.29,130.61) v3(107.26,130.56) v3(107.72,130.56) v3(108.32,130.61) v3(108.89,130.61) v3(109.46,130.61) v3(110.03,130.61) v3(110.6,130.61) v3(126.51,132.73) v3(126.51,132.16) v3(126.51,131.59) v3(126.51,131.02) v3(126.51,130.45) v3(128.09,122.64) v3(128.09,122.06) v3(128.09,121.49) v3(128.09,120.92) v3(128.09,120.35) v4(90.93,129.97) v4(99.49,131.09) v4(99.49,130.69) v4(99.49,130.28) v4(107.26,130.56) v4(107.72,130.56) v5(102.49,135.47) v5(102.49,134.9) v5(103.06,135.47) v5(103.06,134.9) v5(103.63,135.47) v5(103.63,134.9) v5(104.2,135.47) v5(104.2,134.9) v5(112.08,135.47) v5(112.08,134.9) v5(112.65,135.47) v5(112.65,134.9) v5(113.22,135.47) v5(113.22,134.9) v5(113.79,135.47) v5(113.79,134.9) v5(126.42,133.73) v5(127.05,133.73) v5(127.69,133.73) v5(148.97,105.04) v5(148.97,104.47) v5(149.54,105.04) v5(149.54,104.47) v5(150.11,105.04) v5(150.11,104.47) v5(151,82.45) v5(151,81.88) v5(151,81.31) v5(151,80.74) v5(151,80.16) v5(151,79.59) v5(151,79.02) v5(151.51,82.2) v5(151.51,81.63) v5(151.51,81.05) v5(151.51,80.42) v5(151.51,79.85) v5(151.51,79.28)
+19VB_VCCGT:
  vias: v10(147.42,83.19)
+19VB_VCCIO: length 1.1
  TOP w0.081: 131.01,47.54 130.63,47.16 v2(130.07,47.16)
  vias: v5(132.37,48.08) v5(133.48,47.18) v5(134.12,48.75) v5(134.12,48.11)
+19VB_VCCSA: length 2.3
  TOP w0.081: 149.82,97.92 151.13,97.92 v2(151.83,98.62)
+V18R: length 2.5
  TOP w0.081: RE715.1 84.57,10.57 83.96,10.57 UE5.N1
+VCC_CORE: length 54.9
  TOP w0.203: UC1.AA13 110.87,92.6 v5(111.19,92.92) ; v5(109.34,93.58) 109.24,93.58 UC1.W14 UC1.W13 ; v5(111.19,92.92) 111.52,93.25 UC1.AC14 ; v5(111.19,92.92) 111.52,92.6 UC1.AC13 ; v5(102.01,92.77) 102.18,92.6 UC1.L13 ; v5(102.01,92.77) 101.47,92.77 UC1.K13 ; v5(102.01,92.77) 102.01,93.08 UC1.K14 ; v5(105.7,92.92) 105.38,93.25 UC1.P14 ; v5(105.7,92.92) 105.38,92.6 UC1.P13 ; v5(105.7,92.92) 106.03,92.6 UC1.R13 ; UC1.AD14 112.47,93.25 v5(112.14,92.92) 112.47,92.6 UC1.AD13 ; UC1.N14 104.47,93.25 v5(104.81,92.91) 104.5,92.6 UC1.N13 ; UC1.V13 UC1.V14 107.66,93.58 v5(107.51,93.58) ; v5(102.92,92.93) 102.6,93.25 UC1.L14 ; UC1.AE14 113.34,93.25 v5(113,92.91) 113.31,92.6 UC1.AE13
  TOP w0.254: UC1.N38 104.63,111.75 v5(104.7,111.75) ; PRZ29.1 146.69,134.85 v8(146.25,134.42)
  IN1 w0.254: v8(146.25,134.42) 146.02,134.19 146.02,124.79 145.72,124.49 140.64,124.49 139.09,122.94 139.09,120.17 138.43,119.51 134.34,119.51 131.98,117.15 119.1,117.15 v5(118.87,117.38)
  vias: v5(88.46,119.34) v5(88.46,118.71) v5(88.46,118.07) v5(88.46,117.44) v5(89.03,119.34) v5(89.03,118.71) v5(89.03,118.07) v5(89.03,117.44) v5(89.6,119.34) v5(89.6,118.71) v5(89.6,118.07) v5(89.6,117.44) v5(90.17,119.34) v5(90.17,118.71) v5(90.17,118.07) v5(90.17,117.44) v5(96.25,119.37) v5(96.25,118.73) v5(96.25,118.1) v5(96.25,117.46) v5(96.82,119.37) v5(96.82,118.73) v5(96.82,118.1) v5(96.82,117.46) v5(97.4,119.37) v5(97.4,118.73) v5(97.4,118.1) v5(97.4,117.46) v5(97.97,119.37) v5(97.97,118.73) v5(97.97,118.1) v5(97.97,117.46) v5(103.89,119.09) v5(103.89,118.46) v5(103.89,117.82) v5(103.89,117.19) v5(104.46,119.09) v5(104.46,118.46) v5(104.46,117.82) v5(104.46,117.19) v5(104.68,110.44) v5(104.7,109.78) v5(104.71,107.84) v5(104.67,107.18) v5(105.03,119.09) v5(105.03,118.46) v5(105.03,117.82) v5(105.03,117.19) v5(104.95,112.77) v5(105.14,112.2) v5(105.52,112.83) v5(105.48,110.43) v5(105.51,109.8) v5(105.48,109.13) v5(105.49,108.46) v5(105.48,107.83) v5(105.47,107.16) v5(105.6,119.09) v5(105.6,118.46) v5(105.6,117.82) v5(105.6,117.19) v5(105.78,112.2) v5(106.11,112.87) v5(106.34,112.32) v5(106.27,111.74) v5(106.27,111.09) v5(106.27,109.78) v5(106.27,107.18) v5(106.67,112.88) v5(106.87,104.55) v5(106.87,102.96) v5(106.87,101.5) v5(107,113.5) v5(106.97,112.32) v5(107.06,110.43) v5(107.06,109.13) v5(107.06,107.83) v5(107.06,106.54) v5(107.3,114.09) v5(107.3,112.88) v5(107.61,113.53) v5(107.61,112.32) v5(107.57,98.2) v5(107.57,97.56) v5(107.57,96.93) v5(107.85,111.74) v5(107.85,111.09) v5(107.85,109.78) v5(107.85,108.48) v5(107.85,107.18) v5(107.94,114.09) v5(107.94,112.88) v5(108.24,113.53) v5(108.24,112.32) v5(108.39,100.1) v5(108.39,99.47) v5(108.39,98.83) v5(108.39,98.2) v5(108.39,97.56) v5(108.39,96.93) v5(108.39,96.29) v5(108.39,95.66) v5(108.57,114.09) v5(108.57,112.88) v5(108.63,111.74) v5(108.63,110.43) v5(108.63,109.13) v5(108.88,113.53) v5(108.88,112.32) v5(109.21,114.09) v5(109.21,112.88) v5(109.42,109.78) v5(109.41,108.47) v5(109.42,107.18) v5(109.44,106.54) v5(109.41,104.61) v5(109.51,113.53) v5(109.51,112.32) v5(109.47,102.96) v5(109.47,101.5) v5(109.84,114.09) v5(109.84,112.88) v5(110.15,113.53) v5(110.15,112.32) v5(110.21,111.74) v5(110.21,110.43) v5(110.21,109.13) v5(110.21,107.83) v5(110.48,114.09) v5(110.48,112.88) v5(110.78,113.53) v5(110.78,112.32) v5(110.99,111.09) v5(110.99,109.78) v5(110.99,107.18) v5(111.11,114.09) v5(111.11,112.88) v5(111.42,112.32) v5(111.75,112.88) v5(111.78,109.13) v5(111.78,107.83) v5(111.78,106.54) v5(112.05,112.32) v5(112.38,112.88) v5(112.52,102.77) v5(112.52,101.25) v5(112.57,111.09) v5(112.57,109.78) v5(112.57,108.48) v5(112.57,107.18) v5(112.59,104.55) v5(112.69,112.32) v5(113.02,112.88) v5(113.32,112.32) v5(113.36,111.74) v5(113.36,110.43) v5(113.36,109.13) v5(113.65,112.88) v5(113.96,112.32) v5(114.14,111.09) v5(114.14,109.78) v5(114.13,107.2) v5(114.17,102.83) v5(114.17,102.2) v5(114.17,101.56) v5(114.17,100.93) v5(115.38,104.55) v5(115.57,102.96) v5(115.57,101.63) v5(115.71,124.83) v5(115.7,124.23) v5(115.7,123.6) v5(115.7,122.96) v5(116.28,124.83) v5(116.27,124.23) v5(116.27,123.6) v5(116.27,122.96) v5(116.51,109.13) v5(116.51,107.83) v5(116.51,106.54) v5(116.84,124.23) v5(116.84,123.6) v5(116.84,122.96) v5(116.85,124.83) v5(117.16,119.28) v5(117.16,118.65) v5(117.16,118.01) v5(117.16,117.38) v5(117.29,109.78) v5(117.29,108.48) v5(117.29,107.18) v5(117.42,124.83) v5(117.41,124.23) v5(117.41,123.6) v5(117.41,122.96) v5(117.73,119.28) v5(117.73,118.65) v5(117.73,118.01) v5(117.73,117.38) v5(118,124.83) v5(117.98,124.23) v5(117.98,123.6) v5(117.98,122.96) v5(118.08,111.09) v5(118.08,110.43) v5(118.08,109.13) v5(118.08,107.83) v5(118.3,119.28) v5(118.3,118.65) v5(118.3,118.01) v5(118.3,117.38) v5(118.57,124.83) v5(118.55,124.23) v5(118.55,123.6) v5(118.55,122.96) v5(118.55,104.55) v5(118.55,103.02) v5(118.55,101.75) v5(118.87,119.28) v5(118.87,118.65) v5(118.87,118.01) v5(118.87,111.74) v5(118.87,109.78) v5(118.87,107.18) v5(119.44,100.42) v5(119.44,99.72) v5(119.44,99.02) v5(119.44,98.39) v5(119.44,97.75) v5(119.44,97.18) v5(119.44,96.48) v5(119.44,95.85) v5(119.66,111.74) v5(119.66,110.43) v5(119.66,109.13) v5(119.66,107.83) v5(119.67,107.2) v5(120.27,100.42) v5(120.27,99.72) v5(120.27,99.02) v5(120.27,98.39) v5(120.27,97.75) v5(120.27,97.18) v5(120.27,96.48) v5(120.27,95.85) v5(120.44,111.09) v5(120.44,109.78) v5(120.44,107.18) v5(121.28,104.61) v5(121.28,102.9) v10(100.85,119.01)
+VCCGT: length 17.4
  TOP w0.508: RH203.2 117.77,113.08 v5(117.79,113.06)
  IN3 w0.254: v3(147.45,119.65) 147.45,119.53 146.08,118.16 145.43,118.16 143.99,116.73 143.99,114.33 141.53,111.86 137.44,111.86 136.7,111.13 135.74,111.13
  vias: v5(122.02,111.09) v5(122.02,109.78) v5(122.02,108.48) v5(122.02,107.18) v5(122.11,112.31) v5(122.4,112.8) v5(122.75,112.32) v5(122.81,111.74) v5(122.81,110.43) v5(123.06,112.82) v5(123.38,112.32) v5(123.59,109.78) v5(123.59,108.48) v5(123.59,107.18) v5(123.58,106.55) v5(123.7,112.83) v5(124.02,112.32) v5(123.99,92.92) v5(124.33,112.83) v5(124.27,103.98) v5(124.27,103.28) v5(124.27,102.58) v5(124.27,101.95) v5(124.27,101.31) v5(124.27,100.74) v5(124.27,100.04) v5(124.27,99.41) v5(124.38,111.74) v5(124.38,110.43) v5(124.38,109.13) v5(124.38,107.83) v5(124.52,95.6) v5(124.65,112.32) v5(124.97,112.83) v5(125.03,103.98) v5(125.03,103.28) v5(125.03,102.58) v5(125.03,101.95) v5(125.03,101.31) v5(125.03,100.74) v5(125.03,100.04) v5(125.03,99.41) v5(125.17,111.09) v5(125.17,109.78) v5(125.17,107.18) v5(125.16,95.6) v5(125.29,112.32) v5(125.6,112.83) v5(125.73,95.6) v5(125.92,112.32) v5(125.96,109.13) v5(125.96,107.83) v5(125.96,106.54) v5(126.24,112.83) v5(126.3,95.6) v5(126.56,112.32) v5(126.74,111.09) v5(126.74,109.78) v5(126.74,108.48) v5(126.74,107.18) v5(126.75,92.97) v5(126.87,112.83) v5(126.87,95.6) v5(127.19,112.32) v5(127.44,95.6) v5(127.51,112.83) v5(127.53,111.74) v5(127.53,110.43) v5(127.83,112.32) v5(128.14,112.83) v5(128.32,109.78) v5(128.32,108.48) v5(128.32,107.18) v5(128.32,106.54) v5(128.46,112.32) v5(128.56,92.92) v5(128.78,112.83) v5(129.1,112.32) v5(129.1,111.74) v5(129.1,110.43) v5(129.1,109.13) v5(129.1,107.83) v5(129.16,94.9) v5(129.67,112.32) v5(129.89,111.09) v5(129.89,109.78) v5(129.89,107.18) v5(129.86,94.9) v5(129.98,103.91) v5(129.98,103.22) v5(129.98,102.52) v5(129.98,101.88) v5(129.98,101.25) v5(129.98,100.68) v5(129.98,99.98) v5(129.98,99.34) v5(129.98,98.71) v5(129.98,98.07) v5(129.98,97.5) v5(129.98,96.8) v5(129.98,96.17) v5(130.3,112.32) v5(130.49,94.9) v5(130.68,109.13) v5(130.68,107.83) v5(130.68,106.54) v5(130.94,112.32) v5(131.51,112.32) v5(131.47,111.09) v5(131.46,110.4) v5(131.47,109.78) v5(131.47,109.13) v5(131.47,107.18) v5(131.71,99.12) v5(131.7,98.52) v5(131.7,97.94) v5(131.7,97.37) v5(131.76,96.74) v5(131.76,96.1) v5(131.76,95.47) v5(132.14,112.32) v5(132.25,111.07) v5(132.78,112.32) v5(133.25,103.44) v5(133.22,101.87) v5(133.25,98.7) v5(133.25,95.58) v5(133.26,101.06) v5(133.26,100.3) v5(133.26,99.52) v5(133.88,95.56) v5(133.88,94.76) v10(135.24,112.38)
+VCCIO: length 21.9
  TOP w0.203: UC1.AG12 114.98,92.27 v5(114.85,92.3)
  TOP w0.381: RC2.1 97.96,80.86 96.04,80.86 94.83,82.07 v5(94.42,82.07)
  TOP w0.508: v5(93.85,109.73) 93.92,109.79 93.92,111.14 93.38,111.68 RC30.2
  IN4 w0.254: 99.39,107.7 100.84,106.25 101.24,106.25
  IN4 w0.381: v5(93.85,109.73) 96.09,109.73 97.26,108.56 97.84,108.56 98.7,107.7 99.39,107.7 ; v5(101.98,102.96) 102.46,103.44 102.46,105.03 101.24,106.25
  BOTTOM w0.081: 117.49,55.84 v10(116.15,55.84)
  vias: v5(99.75,97.4) v5(100.41,98.19) v5(100.41,95.76) v5(101.92,97.63) v5(101.92,96.99) v5(101.98,102.39) v5(101.98,101.82) v5(101.98,101.18) v5(101.98,100.55) v5(118.14,55.56) v5(118.14,54.98) v5(118.71,55.56) v5(118.71,54.98) v5(119.28,55.56) v5(119.28,54.98)
+VCCIOP: length 13.4
  TOP w0.254: v5(122.94,54.21) 122.94,54.76 123.39,55.22 131.86,55.22 133.22,56.58 PCH26.1 133.71,56.78 PRH16.1
  vias: v5(121.63,53.05) v5(121.64,52.48) v5(122.21,53.05) v5(122.21,52.47) v5(122.8,53.05) v5(122.8,52.47) v5(122.97,53.65) v5(123.3,52.73) v5(123.3,52.15) v10(123.55,53.76)
+VCCRTCEXT: length 0.5
  TOP w0.254: UH1.BF47 UH1.BG47
+VCCSA: length 25.3
  TOP w0.508: v5(95.1,114.23) 95.47,114.6 RH201.2
  IN3 w0.508: 101.88,114.85 101.87,114.84 96.63,114.84 96.03,114.23 v5(95.1,114.23)
  IN4 w0.254: v6(145.58,116.65) 150.29,121.36 150.29,128.49 149.94,128.84 149.94,131.03 v7(150.62,131.71)
  vias: v1(145.58,116.65) v5(101.55,107.83) v5(102.33,110.43) v5(102.3,109.14) v5(102.33,107.83) v5(102.33,107.18) v5(103.04,113.21) v5(103.04,112.58) v5(103.1,113.83) v5(103.11,110.42) v5(103.12,109.78) v5(103.11,109.15) v5(103.12,108.48) v5(103.11,107.82) v5(103.12,107.18) v5(103.11,106.55) v5(137.92,118.52) v5(137.92,117.88) v5(137.92,117.19) v5(137.92,116.55) v5(138.56,116.61) v5(138.56,115.98) v5(139.13,116.61) v5(139.13,115.98) v5(139.13,115.34) v5(139.7,116.61) v5(139.7,115.98) v5(139.7,115.34) v10(101.97,113.08)
+VCCST: length 198.8
  TOP w0.203: UC1.J28 UC1.H28 ; v5(100.35,106.03) 100.38,106.03 UC1.H30
  TOP w0.254: RH613.2 86.54,13.15 86.54,13.58 86.8,13.85 87.19,13.85 87.72,14.38 87.72,14.73 87.82,14.83 87.82,17.24 87.66,17.4 87.66,22.5 87.86,22.71 87.96,22.71 88.14,22.89 88.14,24.22 87.29,25.07 87.29,25.43 87.55,25.68 87.82,25.68 88.2,26.06 88.2,26.63 86.64,28.2 86.64,29.54 86.3,29.88 86.3,37.15 84.04,39.42 84.04,43.31 82.29,45.07 82.29,52.87 80.37,54.78 80.37,60.08 81.11,60.82 81.11,68.83 83.19,70.91 83.19,72.89 83.86,73.56 88.75,73.56 89.58,74.38 89.58,80 88.93,80.64 88.93,81.74 87.56,83.11 87.56,85.68 v4(90.02,88.14) ; v5(101.85,104.55) 101.55,104.85 UC1.J28
  TOP w0.381: v4(140.92,106.33) 140.87,106.28 140.27,106.28 RC693.1
  TOP w0.508: RH152.1 v3(140.92,109.95) ; RH156.1 RC693.1
  IN3 w0.254: v9(147.57,123.34) 147.57,122.66 146.94,122.02 145.47,122.02 144.45,121.01 144.45,120.47 141.92,117.94 141.92,115.99 140.37,114.44 139.55,114.44 v9(139.47,114.35)
  GND4 w0.254: v4(147.62,123.79) 147.62,123.4 v9(147.57,123.34) ; v4(139.29,114.17) 139.45,114.33 139.45,114.35 v9(139.47,114.35)
  GND4 w0.508: v3(140.92,109.95) v4(140.92,109.94)
  IN4 w0.254: v5(101.85,104.55) 101.17,103.86 101.17,99.44 100.41,98.68 99.44,98.68 98.98,98.22 98.98,97.46 98.48,96.95 97.38,96.95 96.37,95.94 96.37,91.98 v5(95.05,90.66)
  BOTTOM w0.254: v4(90.02,88.14) 90.32,88.14 90.98,87.48 92.28,87.48 93.22,88.42 93.22,89.46 94.41,90.66 v5(95.05,90.66) ; v4(147.62,123.79) PRZ35.2 PRZ6.1 PRZ7.1 147.31,126.39 PCZ10.2
  BOTTOM w0.381: v5(100.35,106.03) 100.27,106.11 100.27,114.14 v5(101.6,115.47) 113.73,115.47 114.68,116.42 137.03,116.42 v4(139.29,114.17) v10(140.92,112.54) v4(140.92,109.94) 140.92,109.93 v4(140.92,106.33) ; v5(95.05,90.66) 95.05,89.71 96.54,88.22 RH164.1
  BOTTOM w0.508: 100.93,105.71 100.98,105.71 101.23,105.96 RH163.1
  vias: v5(91.63,108.1) v5(91.63,107.47) v5(92.2,108.1) v5(92.2,107.47)
+VCCST_PECI: length 9.1
  TOP w0.508: RH613.1 86.22,11.69 86.39,11.52 v1(86.39,10.95)
  GND2 w0.254: v3(80.87,12.52) 80.87,12.66 v1(80.67,12.86) ; v1(86.39,10.95) v12(86.1,10.66)
  IN2 w0.254: v3(82.88,12.6) 83.27,12.21 83.27,11.04 84.28,10.04 85.12,10.04 85.74,10.66 v12(86.1,10.66)
  IN3 w0.254: v3(82.88,12.6) 82.8,12.52 v3(80.87,12.52)
+VCCSTG: length 59.4
  TOP w0.254: UC1.H29 100.74,105.6 v5(100.37,105.23) ; UC1.G30 100.09,106.46 v5(100.79,107.17)
  BOTTOM w0.356: CH105.1 97.18,107.63 v5(97.16,107.61)
  BOTTOM w0.381: v5(100.79,107.17) 100.79,113.78 101.92,114.9 113.92,114.9 114.87,115.85 v10(136.72,115.85) 140.31,112.26 140.31,105.89 141.6,104.6 v5(141.6,104.1)
  vias: v5(90.55,111.22) v5(91.12,111.22) v5(91.69,111.22) v5(92.27,111.22)
+VDDA: length 14
  IN4 w0.508: v7(128.52,25.19) 128.91,24.81 128.91,19.54 129.94,18.5 v7(129.94,17.98) 129.24,17.98 127.64,19.58 v7(126.52,19.58)
  BOTTOM w0.081: CE169.1 v2(132.07,17.98)
  BOTTOM w0.508: v7(129.94,17.98) CE169.1
+VIN_DGPU: length 40
  TOP w0.254: v5(53.64,28.21) 53.77,28.34 53.77,29.02 53.55,29.24 53.28,29.24
  IN1 w0.254: v5(53.64,28.21) 53.06,28.21 52.81,27.96 52.81,25.59 51.89,24.68 46.2,24.68 45.67,24.15 38.04,24.15 34.58,27.6 28.78,27.6 24.79,31.59 v8(24.26,31.59)
  BOTTOM w0.254: PRV97.2 PRV83.2 53.98,27.07 53.98,27.96 53.72,28.21 v5(53.64,28.21)
  vias: v1(23.29,30.52) v1(23.29,29.82) v1(23.29,29.1) v1(25.07,30.51) v1(25.1,29.83) v1(25.06,29.12) v1(30.51,37.68) v1(30.53,36.92) v1(31.29,37.71) v1(31.28,36.92) v1(32.19,37.73) v1(32.23,36.92) v3(23.29,30.52) v3(23.29,29.82) v3(23.29,29.1) v3(25.07,30.51) v3(25.1,29.83) v3(25.06,29.12) v5(18.26,32.43) v5(18.34,30.14) v5(18.57,31.51) v5(23.89,30.5) v5(23.9,29.83) v5(23.9,29.2) v5(24.5,30.5) v5(24.5,29.86) v5(24.5,29.19) v5(26.57,33.56) v5(26.62,32.79) v5(29.39,33.89) v5(29.9,33.28) v5(29.96,33.89) v5(30.05,28.59) v5(30.18,29.36) v5(30.25,30.62) v5(30.75,35.44) v5(30.75,34.8) v5(30.75,34.17) v5(30.75,33.53) v5(30.75,32.88) v5(30.75,32.25) v5(30.75,31.61) v5(30.75,30.98) v5(30.75,30.34) v5(30.75,29.71) v5(30.75,29.07) v5(30.75,28.41) v5(31.43,35.64) v5(31.43,33.72) v5(31.43,33.09) v5(31.43,32.45) v5(31.43,31.82) v5(31.43,31.18) v5(31.43,30.55) v5(31.45,29.91) v5(33.46,37.56) v5(33.46,36.31) v5(33.46,35.07) v5(33.46,33.82) v10(32.82,30.43) v12(30.51,37.68) v12(30.53,36.92) v12(31.29,37.71) v12(31.28,36.92) v12(32.19,37.73) v12(32.23,36.92)
GND: length 4079.1
  TOP w0.076: v5(133.04,108.48) 133.36,108.16 UC1.BL33 ; UC1.BM33 134.21,107.84 v5(134.54,108.17)
  TOP w0.089: v14(116.59,38.76) 116.61,38.74 UH1.AA49 ; UG1.D19 v3(24.96,95.98) ; UH1.M49 116.97,42.9 v14(117.04,42.83) ; UH1.AP4 94.59,31.97 93.95,31.97 93.83,32.1 93.57,32.1 93.37,31.9 v5(92.42,31.9)
  TOP w0.127: RH590.1 89.22,39.97 v14(89.22,40.29) 89.2,40.3 89.2,40.72 89.43,40.95 90.98,40.95 91.28,40.65 92.2,40.65 92.71,41.16 v5(92.71,41.17) ; v1(97.82,140.83) 100.61,140.83 v10(100.67,140.9) ; v5(105.73,56.98) 105.25,56.98 v10(104.86,56.59) ; UC1.B37 96.54,110.69 96.33,110.48 95.8,110.48 v5(95.76,110.43) ; v10(80.44,131.71) 80.91,132.18 v18(81.72,132.18) ; v10(90.72,64) 90.68,64.04 88.37,64.04 ; v14(91.77,46.03) 90.27,47.53 89.13,47.53 88.87,47.27 v14(88.87,46.87) 88.87,46.15 89.97,45.06 v14(92.48,45.06) ; v14(114.86,43.97) 115.25,43.97 UH1.J47 ; v5(126.48,115.23) v10(125.67,115.23) ; v14(82.04,126.9) 81.29,126.9 v10(80.92,127.27) ; v14(136.94,132.3) v10(136.94,133.5)
  TOP w0.152: UH1.AG1 91.46,35.12 v5(91.44,35.1) ; v5(100.55,24.78) 100.55,25.12 UH1.BG17 ; v5(104.49,25.01) 104.49,25.18 UH1.BG25 ; v5(97.6,48.22) 97.88,47.94 97.88,47.73 UH1.C12 98.59,47.03 UH1.D12 98.59,46.37 UH1.E13 ; v3(105.38,46.36) 105.3,46.36 104.8,46.86 UH1.C25 ; v14(116.94,32.92) 116.94,32.93 UH1.AM49 ; UH1.BG22 103.12,25.23 v5(103.29,25.05) ; v5(92.53,36.93) 92.53,36.93 92.66,36.8 UH1.AD1 UH1.AD2 ; UH1.BG37 110.87,24.7 v5(111.21,24.36) ; UC1.G28 100.09,104.61 100.4,104.29 100.4,104.2 100.4,104.2 100.4,103.93 100.4,103.59 UC1.G26 ; v1(92.67,32.93) UH1.AM1 ; UH1.A37 110.87,48.35 v5(111.06,48.54) ; v5(106.54,25.03) 106.54,25.09 106.48,25.15 UH1.BG28 ; v5(106.04,48.33) 106.33,48.33 106.48,48.18 UH1.A28 ; v5(108.34,48.53) 108.34,48.34 108.56,48.11 UH1.A33 ; UH1.AD49 116.48,36.67 v5(116.48,35.65) 116.48,35.25 UH1.AG49 ; UH1.J47 115.53,44.08 115.68,43.92 UH1.J48 ; UH1.T49 v14(116.94,40.67) ; UH1.C48 116.29,46.88 116.29,46.29 UH1.F47 ; UH1.BG33 108.67,25.13 108.63,25.09 v5(108.63,24.92) ; UH1.AJ31 107.51,34.86
  TOP w0.203: UX1.3 121.16,137.57 121.16,137.57 v1(121.16,137.55) ; UC1.AH6 v14(115.18,88.04) ; 100.75,107.83 101.09,108.16 v14(101.15,108.16) ; 100.75,107.83 101.07,107.51 UC1.J32 ; 100.75,107.83 100.44,107.51 UC1.H32 100.1,107.24 99.47,107.24 UC1.F31 ; 134.54,96.35 134.86,96.68 UC1.BN18 UC1.BP18 UC1.BR18 UC1.BT18 v5(137.62,96.75) ; UC1.BG37 131.01,110.76 v5(130.68,110.43) ; UC1.T34 106.6,108.81 v5(106.27,108.48) UC1.T33 ; UC1.AM37 119.19,110.76 v5(118.87,111.09) 119.2,111.41 UC1.AM38 ; v4(134.21,92.02) 133.89,92.35 133.89,92.49 v3(133.56,92.81) 133.24,93.13 133.18,93.13 ; v14(118.05,90.65) v14(118.05,90) v14(118.05,89.35) v14(118.05,88.7) ; UC1.BG13 130.5,92.25 v5(130.35,92.25) 130.23,92.25 UC1.BF12 ; UC1.BG13 UC1.BG14 ; UC1.BG13 v4(130.85,91.95) ; v8(45.01,150.37) 45.05,150.33 JCDRA.23 ; 135.17,98.7 134.86,98.39 UC1.BN20 ; 135.17,98.7 135.51,99.04 UC1.BP21 UC1.BR21 UC1.BT21 ; 135.17,98.7 134.86,99 UC1.BN21 134.72,99.11 134.66,99.05 134.34,99.05 134.28,99.11 UC1.BM21 133.9,99.42 v5(133.9,99.5) ; v5(121.23,110.43) 121.56,110.76 UC1.AR37 ; v5(95.44,98.55) UC1.A20 ; UC1.AY34 125.5,108.81 v5(125.17,108.48) 125.49,108.16 UC1.AY33 ; UC1.Y14 109.72,93.25 v5(109.39,92.92) 109.72,92.6 UC1.Y13 ; v5(127.65,92.22) 127.46,92.22 UC1.BB12 126.87,92.27 v5(126.74,92.27) 126.41,91.95 UC1.BA12 125.93,92.29 v5(125.82,92.29) 125.71,92.29 UC1.AY12 125.27,91.95 v5(124.9,92.31) 124.8,92.31 124.45,91.96 UC1.AW12 124.12,92.28 v5(123.97,92.28) 123.64,91.95 UC1.AU12 123.45,91.95 v5(123.09,92.31) ; UC1.AB34 v5(110.99,108.48) UC1.AB33 ; v5(100.41,91.86) 100.74,91.54 UC1.H11 ; v5(100.41,91.86) 100.09,92.19 UC1.G12 99.82,92.52 99.82,92.66 UC1.F13 ; v5(100.41,91.86) 100.74,92.19 UC1.H12 ; 104.72,108.48 104.33,108.16 UC1.N33 ; 104.72,108.48 v5(104.73,108.48) ; 104.72,108.48 104.33,108.81 UC1.N34 ; UC1.W33 v5(108.63,107.83) ; v5(97.16,102.1) 97.49,102.42 UC1.C25 97.88,102.89 97.88,103.03 UC1.D26 ; UC1.AV38 123.92,111.41 v5(123.59,111.09) 123.91,110.76 UC1.AV37 ; UC1.Y38 v5(109.42,111.09) UC1.Y37 ; v8(37.81,148.15) 37.85,148.19 JCDRA.41 ; UC1.AC38 v5(111.78,111.74) ; 137.11,109.69 137.11,109.89 136.91,110.1 UC1.BT36 136.7,109.98 UC1.BR36 ; 137.11,109.69 v5(137.18,109.69) ; 137.11,109.69 137.11,109.49 136.91,109.28 UC1.BT35 ; UC1.P37 v5(104.7,111.09) UC1.P38 ; UC1.D16 97.88,95.15 97.88,95.01 UC1.C15 97.16,94.29 v5(97.16,94.22) ; JCDRA.8 v1(51.05,147.82) ; v8(39.01,148.15) 39.05,148.19 JCDRA.38 ; UC1.BG38 v5(130.68,111.74) ; v8(40.21,148.15) 40.25,148.19 JCDRA.35 ; UH1.C4 94.44,47.29 94.68,47.53 v5(94.97,47.53) ; v5(113.36,107.83) UC1.AE33 UC1.AE34 ; UC1.AL33 118.55,108.16 v5(118.87,108.48) 118.54,108.81 UC1.AL34 ; UC1.AR38 121.55,111.41 v5(121.23,111.74) ; UC1.U38 v5(107.06,111.09) UC1.U37 ; v14(95.62,90.64) 95.65,90.68 UC1.A10 ; 97.88,90.29 97.88,90.43 UC1.D10 ; 97.88,90.29 UC1.D9 ; 97.88,90.29 v14(97.49,89.89) 97.49,89.82 97.16,89.5 ; UC1.AU34 123.13,108.81 v5(122.81,109.13) ; UC1.F19 99.44,97.84 v5(99.76,98.16) 100.09,98.49 UC1.G20 ; UC1.G5 100.2,87.39 100.53,87.06 ; UC1.G5 99.99,87.53 UC1.F5 ; UC1.G5 100.13,87.46 100.08,87.51 100.08,87.89 100.13,87.95 UC1.G6 ; 133.18,93.13 132.91,92.87 v14(132.91,92.68) ; 133.18,93.13 132.91,93.39 UC1.BK14 ; UC1.A4 UC1.A3 96.76,86.04 UC1.B3 ; UC1.D22 97.88,99.88 97.88,99.74 UC1.C21 97.16,99.01 v5(97.16,98.92) ; v1(49.75,147.81) 49.78,147.84 49.78,148.3 49.85,148.37 JCDRA.11 ; v5(95.55,109.15) 96.09,109.15 UC1.A34 ; 100.53,87.06 100.2,86.74 UC1.G4 UC1.F4 ; 100.53,87.06 100.61,87.06 UC1.J4 v1(101.77,86.74) ; 97.16,89.5 97,89.66 97,89.73 UC1.B9 UC1.A9 ; 97.16,89.5 97.16,89.43 UC1.C8 UC1.D6 ; v5(99.11,89.5) 98.79,89.82 UC1.E9 ; v5(99.11,89.5) 99.44,89.82 UC1.F9 99.44,89.96 v5(99.76,90.29) ; v5(99.11,89.5) 99.44,89.17 UC1.F8 UC1.G8 100.51,88.68 UC1.J7 ; UC1.AU33 123.13,108.16 v5(122.81,107.83) ; v5(115.76,92.26) 116.07,91.95 UC1.AH12 ; UC1.BM29 UC1.BM28 134.21,104.55 v5(133.89,104.23) 133.89,104.16 UC1.BM27 ; UC1.BM29 UC1.BL29 133.35,105.62 UC1.BK29 132.51,106.02 UC1.BJ30 132.65,106.14 v5(133.04,106.53) 132.71,106.86 UC1.BJ31 ; UC1.BM29 UC1.BN29 UC1.BP29 UC1.BR29 ; v5(99.76,101.31) 100.09,100.99 UC1.G23 ; v5(99.76,101.31) 100.09,101.64 UC1.G24 ; v5(99.76,101.31) 99.76,101.24 UC1.F23 ; v5(98.32,87.04) 97.98,87.04 UC1.C5 97.35,87.53 96.99,87.89 96.63,87.89 96.19,88.33 UC1.A6 ; JCDRA.14 48.65,148.39 48.44,148.17 v1(48.44,148.1) ; v5(95.37,100.13) UC1.A22 ; v5(117.29,110.44) 116.97,110.76 UC1.AJ37 116.9,110.83 116.96,110.9 116.96,111.27 116.9,111.34 UC1.AJ38 ; UC1.K38 102.36,111.83 v5(102.4,111.83) ; UH1.A5 UH1.A4 UH1.A3 UH1.A2 ; UC1.AH34 116.05,108.81 v5(115.72,108.48) 116.04,108.16 UC1.AH33 ; v5(122.15,92.27) 122.04,92.27 UC1.AR13 ; v14(100.79,102.49) UC1.J25 ; JCDRA.5 52.25,148.36 52.27,148.34 52.27,147.88 v1(52.32,147.83) ; v8(46.21,148.15) 46.21,149.21 JCDRA.20 ; UC1.D18 97.8,96.64 97.8,96.5 UC1.C17 97.16,95.87 v5(97.16,95.8) ; UH1.E24 103.4,46.36 v3(103.2,46.16) ; UC1.AR13 121.39,92.28 v5(121.25,92.28) 121.12,92.28 UC1.AP12 120.43,92.31 v5(120.32,92.31) 120.24,92.31 UC1.AN12 119.62,92.21 119.22,92.21 UC1.AM12 118.7,92.21 118.31,92.21 UC1.AL12 ; UC1.AR13 121.38,92.92 v5(121.25,92.92) 121.57,93.25 UC1.AR14 121.84,93.25 v5(122.16,92.92) ; UC1.BN34 134.86,108.49 v5(135.19,108.17) 135.19,108.23 UC1.BP34 UC1.BR34 ; v5(127.53,109.13) 127.85,108.81 UC1.BC34 ; UC1.AF12 UC1.AF13 UC1.AF14 ; UC1.BM35 134.21,109.36 v5(133.87,109.7) 133.63,109.46 UC1.BL35 ; v5(99.4,27.06) 99.39,27.1 UH1.BC13 ; UC1.BM23 134.21,100.75 134.54,101.08 134.54,101.15 UC1.BN24 ; v5(127.53,107.83) 127.86,108.16 UC1.BC33 ; v5(95.18,101.7) UC1.A24 ; UC1.G14 100.09,93.97 UC1.F15 99.44,94.69 v5(99.76,95.01) 100.09,95.34 UC1.G16 ; v5(97.16,97.37) 97.49,97.7 UC1.C19 97.88,98.16 97.88,98.3 UC1.D20 ; v5(125.96,110.43) 126.28,110.76 UC1.BA37 126.35,110.83 126.29,110.9 126.29,111.27 126.35,111.34 UC1.BA38 ; UC1.T14 107.17,93.25 v5(107.52,92.9) 107.22,92.6 UC1.T13 ; UC1.D14 97.88,93.58 97.88,93.44 v14(97.49,93.04) ; UC1.D24 97.88,101.45 97.88,101.31 UC1.C23 97.49,100.85 v5(97.16,100.52) ; UC1.F27 99.51,104.06 99.75,103.83 v5(99.75,103.65) 100.09,103.31 UC1.G26 ; JCDRA.29 42.65,148.19 v8(42.61,148.15) ; UC1.BP33 135.26,107.52 135.26,107.38 v14(134.86,106.98) 134.55,106.67 134.55,106.51 UC1.BN30 ; UC1.F4 99.35,86.63 UC1.F3 ; UC1.F4 UC1.E4 ; UC1.F21 99.44,99.41 v5(99.76,99.74) 100.09,100.06 UC1.G22 ; v5(97.39,112.32) 97.82,112.32 98.28,111.86 UC1.D38 ; v5(132.25,108.48) 132.58,108.16 UC1.BJ33 ; v5(108.62,108.47) 108.96,108.81 UC1.W34 ; UC1.L29 v14(102.73,106.16) ; v5(95.55,92.25) UC1.A12 ; UC1.F25 99.75,102.18 v5(99.75,102.11) ; UC1.AY14 125.5,93.25 v5(125.82,93.57) ; v3(134.21,92.81) 134.21,92.74 134.54,92.41 134.54,92.34 v4(134.86,92.02) v3(135.51,92.02) v3(136.16,92.02) v3(136.81,92.02) ; v5(91,30.32) 91.38,30.7 UH1.AT1 ; UC1.BD38 128.65,111.41 v5(128.32,111.09) 128.64,110.76 UC1.BD37 ; v14(98.14,92.25) 97.77,91.89 97.77,91.75 UC1.C11 ; UC1.AL14 118.18,93.25 v5(118.51,92.92) ; JCDRA.17 47.45,148.19 v8(47.41,148.15) ; v4(103.42,91.95) UC1.M13 v14(103.42,93.25) ; UC1.C37 UC1.B37 ; JCDRA.32 41.45,148.19 v8(41.41,148.15) ; JCDRA.44 36.65,148.19 v8(36.61,148.15) ; v5(95.55,95.4) UC1.A16 ; UH1.Y33 108.83,39.36 v5(108.83,39.36) 108.93,39.46 UH1.U33 ; v5(95.58,97.08) 95.62,97.08 95.72,96.98 UC1.A18 ; UC1.J18 UC1.H18 100.7,96.89 100.17,96.89 UC1.G18 100.09,96.91 v5(99.76,96.59) 99.44,96.26 UC1.F17 99.75,95.87 v5(99.75,95.79) ; UC1.L34 102.66,108.81 v5(102.33,108.48) 102.65,108.16 UC1.L33 ; UC1.BR38 v5(136.63,111.83) ; v5(133.04,107.83) 132.72,107.51 UC1.BJ32 ; UH1.A8 96.62,48 96.62,46.97 96.39,46.74 UH1.D8 96.49,46.52 97.05,46.52 v5(97.08,46.54) ; UC1.F11 99.44,91.46 100.09,90.81 UC1.G10 ; UC1.AG7 UC1.AG8 ; UC1.D30 98.14,106.45 97.82,106.77 v5(97.82,106.83) ; UC1.BM38 134.07,111.42 v5(133.7,111.79) 133.36,111.45 UC1.BL38 ; UC1.BM26 134.21,102.98 v5(133.89,102.65) ; UC1.BF33 130.21,108.16 v5(129.89,108.48) 130.22,108.81 UC1.BF34 ; UH1.AL17 100.58,33.62 100.58,34.05 v5(100.77,34.24) 100.77,34.24 UH1.AH17 ; UC1.AC37 v5(111.78,110.43) ; UC1.E38 99.16,111.33 99.16,110.67 99.58,110.26 UC1.F36 99.91,109.78 99.97,109.78 100.29,109.46 UC1.H35 100.76,109.86 100.9,109.86 UC1.J36 ; v5(94.97,93.83) UC1.A14 ; UC1.BC12 UC1.BC13 128.3,92.6 v5(128.58,92.32)
  TOP w0.254: UH1.AJ27 v5(105.19,34.09) ; UH1.AJ27 v5(105.96,34.09) ; UH1.AJ27 105.19,34.86 ; UH1.AJ27 105.96,34.86 ; v5(105.19,34.09) UH1.AK27 ; v5(105.19,34.09) UH1.AJ25 ; v5(105.19,34.09) UH1.AK25 ; v5(43.05,134.2) 42.86,134.4 CG6528.2 ; UC1.BC14 UC1.BC13 ; v5(106.74,38.74) UH1.W28 v5(105.96,38.74) ; v5(106.74,38.74) UH1.W30 ; v5(106.74,38.74) UH1.AA30 v5(107.51,37.96) ; v5(106.74,38.74) UH1.AA28 v5(105.96,38.74) ; UC1.BL19 133.23,97.87 v5(133.23,97.91) ; UC1.BK22 132.81,100 132.45,100 132.35,99.9 v14(132.26,99.9) ; UH1.BG4 94.34,25.45 93.85,24.96 92.99,24.96 v14(92.95,25) ; UH1.BG4 UH1.BG3 ; UH1.BG4 UH1.BF3 ; UH1.AJ30 107.51,34.86 UH1.AG30 106.74,34.86 ; UH1.AJ30 v5(106.74,34.09) ; UH1.AJ30 v5(107.51,34.09) ; UH1.AJ30 106.74,34.86 ; v5(99.77,100.51) 99.98,100.31 99.98,100.24 UC1.G22 100.19,100.03 100.69,100.03 UC1.H22 100.94,99.98 101.29,99.98 UC1.J22 ; v5(98.1,41.73) 98.36,41.48 UH1.R12 ; UD8.E3 99.01,67.85 v1(99.26,67.6) ; 104.79,41.1 104.83,41.14 v5(104.83,41.71) 104.83,42.29 v5(104.83,42.29) 104.5,42.63 UH1.M24 ; 104.79,41.1 UH1.R26 ; 104.79,41.1 104.22,40.53 UH1.U24 ; v5(104.41,35.64) UH1.AF25 104.41,36.41 UH1.AD25 104.41,37.19 UH1.AB25 v5(105.19,37.96) ; v5(104.41,35.64) UH1.AG25 ; v5(104.41,35.64) UH1.AG23 104.41,34.86 ; v5(105.19,38.74) UH1.W27 v5(105.96,38.74) ; v5(105.19,38.74) UH1.AA27 ; v5(105.19,38.74) UH1.W25 v5(104.41,38.74) ; v5(105.19,38.74) UH1.AA25 ; v1(109.15,42.74) 109.22,42.74 UH1.N35 ; UH1.AM32 108.06,33.54 UH1.AK31 v5(107.51,34.09) ; UH1.AE4 95.16,36.64 95.16,36.86 v5(95.24,36.95) 95.17,36.95 UH1.AC4 ; v5(100.13,28.72) 100.08,28.72 100.04,28.67 99.79,28.67 99.78,28.67 UH1.BA14 ; v14(135.51,103.05) 135.65,103.18 136.03,103.18 v14(136.16,103.05) v14(136.81,103.05) ; UC1.J7 100.98,88.68 101.26,88.96 101.52,88.7 v1(101.74,88.7) ; UC1.A26 96.19,103.26 96.51,102.94 v5(96.51,102.91) ; v5(99.16,111.94) 99.08,111.86 UC1.E38 ; UH1.AL26 105.38,33.51 UH1.AK27 ; v3(36.13,138.01) 36.13,138.01 UG11.C10 ; v5(102.24,30.9) UH1.AT21 102.93,31.04 104.15,31.04 UH1.AT24 ; v5(99.76,105.25) 99.44,105.57 UC1.F29 ; UH1.AB31 v5(107.51,37.96) ; v5(107.51,37.96) UH1.AA31 ; UH1.V4 94.74,40.05 v5(94.66,40.12) ; UH1.T5 v5(94.66,40.12) ; v5(94.66,40.12) UH1.T4 ; UH1.AA25 v5(104.41,38.74) ; UH1.AA25 v5(105.19,37.96) ; v5(104.41,38.74) v5(103.64,38.74) v5(102.86,38.74) UH1.AA20 ; UH1.AK20 102.86,34.09 UH1.AJ20 ; UH1.AK20 102.79,33.39 UH1.AL21 ; UH1.AK20 v5(102.09,34.09) ; v18(108.4,68.65) 108.4,68.68 v5(108.78,69.05) ; UG1.H43 v14(28.39,112.79) ; v5(110.32,27.16) 109.85,27.16 UH1.BC35 ; v5(102.49,69.05) 102.8,68.74 UD8.D8 ; UH1.BC26 105.38,27.33 105.81,27.76 v5(106.08,27.76) ; v5(98.97,39.49) 98.4,38.92 UH1.Y12 ; UH1.AG27 105.19,34.86 ; UH1.AG27 105.96,34.86 ; UH1.AG27 v5(105.96,35.64) ; 105.19,34.86 UH1.AG25 ; 105.19,34.86 UH1.AJ25 ; 105.96,34.86 UH1.AJ28 ; 105.96,34.86 UH1.AG28 ; v5(97.44,86.12) 96.94,86.12 UC1.B3 ; v5(97.44,86.12) 97.54,86.02 UC1.D3 ; v5(97.44,86.12) 97.44,85.59 UC1.C2 ; UH1.AL24 104.31,33.21 UH1.AK25 ; UH1.U38 111.44,40.28 v14(111.44,40.6) ; UH1.AT29 107.4,30.9 v5(107.4,30.89) ; UH1.BC40 112.05,27.16 v5(112.52,27.16) 112.47,27.28 112.71,27.97 UH1.BB41 ; v14(111.32,39.4) 111.2,39.28 UH1.Y38 ; UC1.BL22 133.56,99.85 133.7,99.71 133.7,99.69 v5(133.9,99.5) 134.05,99.64 134.05,99.69 134.21,99.86 UC1.BM22 ; UH1.AE38 v5(111.13,35.67) ; UC1.AH36 116.24,110.11 v5(116.55,109.8) 116.21,109.46 UC1.AH35 ; v14(118.55,89.69) 118.49,89.69 118.15,89.35 v14(118.05,89.35) ; UC1.BJ15 132.26,94.36 132.61,94.01 ; UH1.AK4 94.94,34.02 95.16,33.8 v5(95.16,33.8) ; v5(96.16,41.25) UH1.T7 96.16,40.45 96.88,39.73 v5(96.88,39.55) ; UC1.BK29 132.59,105.28 UC1.BJ29 ; UH1.BG2 93.03,25.02 v14(92.95,25) ; UH1.BG2 UH1.BF2 ; UH1.BG2 UH1.BG3 ; UH1.M18 v5(100.99,42.72) 100.85,42.73 UH1.M16 UH1.N16 UH1.R16 ; UC1.BK15 132.91,94.31 132.61,94.01 ; UH1.AG25 104.41,34.86 ; v1(101.67,90) 101.54,90 v1(101.22,89.68) 101.55,89.35 v1(101.67,89.35) ; UH1.D17 v5(101.48,46.44) ; v5(101.48,46.44) 101.55,46.36 UH1.E19 ; v5(101.48,46.44) UH1.E17 ; UH1.D16 UH1.E15 99.75,46.44 v5(99.28,46.44) UH1.E13 ; v5(105.96,38.74) UH1.AA27 ; v18(136.96,126.01) v14(136.96,126.77) ; UH1.AL37 UH1.AL38 v5(111.22,33) ; v3(105.38,44.15) 105.77,44.15 105.83,44.22 UH1.J29 ; 108.12,46.44 107.65,46.44 v14(107.58,46.36) ; 108.12,46.44 v14(108.6,46.16) ; 108.12,46.44 UH1.D33 ; v5(105.19,37.96) UH1.AA27 ; UH1.G44 113.79,45.14 113.26,45.14 UH1.F41 112.61,45.67 112.61,46.18 112.56,46.32 112.56,46.32 112.55,46.36 v5(112.54,46.37) ; v5(113.76,29.09) 113.76,29.08 113.75,29.08 113.76,29.07 113.76,28.76 UH1.BA44 ; 104.41,34.86 UH1.AJ25 ; UH1.AJ25 104.41,34.09 UH1.AK25 ; v5(132.25,109.13) 132.58,108.81 UC1.BJ34 ; v5(99.16,108.42) UC1.E34 98.79,108.79 UC1.E35 99.17,109.84 99.31,109.84 UC1.F36 ; v14(132.26,102.26) UC1.BK25 ; UH1.BC45 v5(113.89,27.55) ; v5(113.89,27.55) UH1.BD43 UH1.BE44 ; v5(113.89,27.55) UH1.BB43 ; UC1.G10 100.09,90.61 v5(99.76,90.29) 99.76,90.22 UC1.G9 ; v5(105.96,34.09) UH1.AK28 v5(106.74,34.09) ; v5(105.96,34.09) UH1.AK27 ; v5(105.96,34.09) UH1.AJ28 ; v14(112.06,44.31) 112.06,43.96 v1(111.88,43.78) ; UH1.R34 UH1.N34 109.15,42.19 108.62,42.72 v3(108.06,42.72) ; v1(113.98,31.97) 114.62,31.97 114.77,31.83 UH1.AP46 ; UH1.AR38 111.1,31.36 110.7,31.76 v5(110.7,31.93) 110.7,32.1 111.04,32.45 UH1.AN38 ; v5(107.51,34.09) UH1.AK30 ; v5(107.51,34.09) UH1.AJ31 ; UH1.AK30 106.81,33.39 UH1.AL29 ; UH1.AK30 v5(106.74,34.09) ; v1(15.43,42.57) 14.84,42.57 14.64,42.76 PCW31.2 ; UH1.BC24 104.22,27.37 103.48,28.12 v5(103.41,28.12) ; v18(107.6,65.45) 107.59,65.45 v5(107.22,65.08) ; UH1.AL33 108.93,34.14 v5(108.83,34.24) 108.83,34.24 UH1.AH33 108.84,34.8 UH1.AE33 ; v5(106.74,34.09) UH1.AJ28 ; UC1.AG13 115.21,92.6 v5(114.85,92.96) 114.85,92.99 114.59,93.25 ; v14(92.95,25) 92.84,25.12 92.84,25.69 UH1.BF1 UH1.BF2 ; v5(102.09,34.09) UH1.AJ20 ; v5(102.09,34.09) UH1.AK19 ; v5(102.09,34.09) UH1.AJ19 102.09,34.86 UH1.AJ20 ; UH1.AJ20 UH1.AG22 102.86,35.64 UH1.AF22 102.86,36.41 UH1.AD22 ; UH1.BC19 102.02,27.32 102,27.32 101.2,28.12 v5(101.11,28.12) ; v5(112.54,46.37) 112.61,46.38 UH1.E42 113.35,45.8 UH1.F43 ; v5(112.54,46.37) 112.44,46.37 112.44,46.36 UH1.E40 ; UC1.BL18 133.27,96.46 v5(133.27,96.36) ; UG12.E4 v4(55.62,128.63) ; v5(113.47,30.7) 113.54,30.63 114.49,30.63 UH1.AT45 114.66,30.37 114.48,30.19 114.48,29.84 114.68,29.63 UH1.AW46 ; UH1.AT32 108.32,30.88 v5(108.58,31.14) ; v5(133.89,102.65) UC1.BM25 ; UC1.BN24 134.91,101.52 135.37,101.52 135.42,101.47 v8(135.51,101.47) 135.55,101.47 135.64,101.56 136.07,101.56 UC1.BR24 UC1.BT24 ; UH1.B49 UH1.A48 UH1.A47 UH1.A46 ; UH1.B49 116.53,47.68 116.18,47.68 UH1.B48 ; UH1.B49 116.61,47.93 116.64,47.96 116.64,48.27 116.61,48.3 116.61,48.66 v5(117.13,49.18) ; v14(115.18,88.04) 115.31,88.16 UC1.AG7 ; PUH2.14 v14(133.01,52.44) ; UH1.U33 108.51,40.48 UH1.T32 ; UH1.U15 UH1.U17 100.67,40.16 UH1.T17 UH1.T18 101.89,40.48 UH1.V20 v5(102.86,39.51) UH1.V22 102.79,40.36 UH1.U21 ; v5(97.13,27.12) 97.51,27.12 UH1.BC10 ; v5(97.13,27.12) 97.13,27.55 96.78,27.91 UH1.BB9 ; v5(97.13,27.12) 96.86,27.12 96.61,27.38 UH1.BC8 ; v5(105.96,35.64) UH1.AF28 ; v5(105.96,35.64) UH1.AG28 ; UH1.AN16 UH1.AR16 UH1.AT16 100.85,30.87 v5(100.99,30.88) UH1.AT18 ; UC1.D33 98.14,107.95 v5(97.79,107.6) ; v5(96.88,39.55) 97.43,39.55 v5(97.62,39.36) ; v5(96.88,39.55) UH1.Y9 ; v4(51.25,138.07) 50.8,137.62 UG12.T10 ; UC1.D28 98.14,104.79 v5(97.8,104.46) 97.49,104.14 UC1.C27 ; v5(106.26,31.12) 106.16,31.21 105.62,31.21 UH1.AT26 ; UC1.BK14 132.91,93.71 132.61,94.01 ; v5(112.19,30.19) 112.05,30.05 112.05,29.96 112.01,29.96 UH1.AV39 111.88,29.47 UH1.AW40 ; CG6530.2 42.86,136.81 v5(43.05,136.62) ; v5(103.25,68.23) 102.87,67.85 UD8.E8 ; UH1.AJ28 106.74,34.86 ; UD8.E1 v1(97.2,67.05) ; v5(135.19,97.93) 134.86,97.6 UC1.BN19 ; UH1.AN34 UH1.AR34 109.06,31.62 v5(108.58,31.14) ; UC1.J10 100.89,90.68 v5(101.2,90.99) 101.36,90.99 v1(101.67,91.3) ; UH1.P29 107.32,41.86 v5(107.38,41.8) ; UH1.AM18 101.09,33.12 UH1.AL17 ; v5(43.05,135.41) 42.86,135.61 CG6529.2 ; UG18.R14 39.44,65.03 v4(39.8,65.39) ; v14(107.58,46.36) UH1.C30 ; v14(107.58,46.36) v14(107.07,46.4) ; 106.74,34.86 UH1.AG28 ; UC1.BN14 UC1.BP14 135.51,93.67 v5(135.84,93.99) 136.16,93.67 UC1.BR14 UC1.BT14 ; UH1.B48 116.17,47.59 UH1.C48 ; UH1.B48 115.56,47.63 UH1.B47 115.26,47.93 UH1.A46 ; UC1.BJ35 132.74,109.46 v5(133.08,109.8) 132.77,110.11 UC1.BJ36 ; UH1.BF3 UH1.BF2 ; UH1.BF3 UH1.BG3 ; PU1802.14 50.09,6.15 v5(50.18,6.24) ; UC1.A3 96.19,85.52 v5(96.27,85.44) ; UC1.BF12 129.8,91.95 v5(129.48,92.27) ; UC1.C31 97.82,106.88 v5(97.82,106.83) ; v5(97.62,39.36) 98.32,40.06 UH1.U12 98.38,40.55 v5(98.46,40.63) ; v5(97.62,39.36) UH1.Y10 ; UH1.R29 v5(106.45,41.45) ; UH1.AE12 v5(98.47,35.67) ; UH1.A45 UH1.A46 ; UH1.AC38 v5(111.13,37.93) ; UH1.BA6 v14(94.94,28.61) ; v3(22.71,102.75) 22.71,102.75 UG1.A29 ; UH1.AE46 114.75,36.22 114.49,35.97 v5(114.49,35.88) ; UC1.BL21 133.91,98.77 v5(133.91,98.72) 133.56,98.37 UC1.BL20 ; UH1.AC12 v5(98.47,37.93) ; UH1.BF49 UH1.BF48 UH1.BG48 116.26,25.48 ; v5(95.31,38.08) 95.23,38.08 94.94,38.36 UH1.AA5 ; UH1.M21 v5(103.15,42.34) ; v5(108.58,31.14) 108.83,30.87 UH1.AT34 ; v3(36.02,113.36) 36.02,113.78 UG1.W45 ; UH1.BC15 99.69,27.1 99.45,27.1 v5(99.4,27.06) ; v5(102.09,37.96) UH1.AA20 ; v5(102.09,37.96) UH1.AA19 ; v5(102.09,37.96) UH1.AB19 ; UH1.AA20 v5(102.86,37.96) ; PUZ7.8 134.62,133.13 134.77,133.29 v5(134.89,133.29) ; UH1.AN12 v5(98.36,31.9) ; UC1.BG14 130.99,93.25 v5(131.31,92.93) 131.63,93.25 UC1.BH14 ; RG518.2 62.3,100.25 v8(62.36,100.31) ; v5(108.18,27.09) 108.04,27.24 UH1.BC31 ; UH1.P26 v5(105.93,41.86) ; UH1.R3 UH1.R4 UH1.P4 94.74,42.24 v5(94.66,42.32) UH1.M5 ; UC1.AP33 120.89,108.16 v5(121.21,108.48) 120.87,108.81 UC1.AP34 ; UH1.N12 98.36,42.52 v5(97.6,43.27) 97.72,43.39 UH1.K11 UH1.J10 v4(96.98,44.38) UH1.H8 96.11,44.65 95.72,44.85 UH1.G6 95.52,45 95.04,44.52 v5(94.66,44.52) 94.74,44.45 UH1.J4 ; UH1.A2 93.34,48.2 93.69,48.54 v5(93.69,48.63) ; UH1.Y17 v5(100.77,38.06) 100.77,37.39 UH1.AC17 101.12,37.38 UH1.AD19 ; UH1.AW10 UH1.AV11 98.36,30.46 v5(98.36,30.81) UH1.AR12 ; UH1.AL12 98.38,34.22 v5(98.4,34.24) UH1.AH12 ; UC1.AL12 117.94,91.95 v5(117.59,92.3) 117.29,92.6 UC1.AJ13 ; UC1.BM14 UC1.BL14 133.27,93.89 v5(133.27,94.01) ; UH1.E10 97.63,46.14 97.41,45.92 97.24,45.92 v5(97.16,45.84) 97.05,45.96 96.81,45.96 UH1.E8 ; UH1.AC33 v5(108.84,37.93) ; v14(132.26,96.75) UC1.BK18 ; v18(103.6,65.45) v5(104.12,65.45) ; UH1.BA12 v5(97.77,28.67) ; UG1.F28 v3(28.15,102.05) ; 134.54,96.35 UC1.BM18 ; UH1.AH38 v5(111.2,34.24)
  TOP w0.305: UC1.AF14 114.59,93.25 ; UH1.C5 94.83,46.61 v5(94.68,46.46)
  TOP w0.356: v5(121.54,58.19) 121.06,58.67 CD311.2 ; v5(103.7,72.61) 103.42,72.89 CD362.2 ; v5(105.73,56.98) 105.75,56.96 CD327.2 ; v5(96.11,65.79) 95.48,66.42 RD253.2 ; CD381.2 100.69,72.58 100.01,71.91 v5(99.93,71.91) ; CD370.2 116.24,58.6 116.73,58.12 CD347.2 ; v5(100.27,23.71) 100.35,23.63 RH26.2 100.96,22.98 RH30.2
  TOP w0.381: PCZ110.2 v5(89.52,132.31) ; RH590.1 89.74,38.92 v5(89.79,38.86) ; v5(3.89,16.91) 4.03,16.76 QG505.1 ; 150.49,37.6 150.32,37.43 PDM01.2
  TOP w0.406: v5(17.81,4.66) 17.7,4.77 PQ6.4 ; PQ6.1 v5(15.98,3.52)
  TOP w0.457: v5(57.46,30.12) 57.05,29.71 PRV102.2
  TOP w0.508: PCZ123.2 130.76,118.56 v5(130.76,117.88) ; PCZ118.2 123.65,125.1 v5(123.09,125.66) ; CD113.1 119.96,60.68 v5(119.96,60.23) ; 150.49,37.6 v5(150.81,37.92) ; v5(5.02,56.74) 5.02,56.37 PCW5.2 ; v5(139.93,143.93) 140.06,143.8 140.06,143.46 RH497.1 ; v1(92.13,147.86) 92.13,147.25 CT97.2 CT95.1 ; PRZ116.1 v5(131.83,127.68) ; v5(126.15,126.44) 126.11,126.41 PCZ48.2 ; v8(38.4,11.28) 38.42,11.27 PC9.2 PC8.2 ; v14(80.9,28.62) 80.85,28.67 PRV4.2 ; PRZ138.1 v5(135.64,118.39) ; v5(10.96,42.83) 14.07,42.83 PCW31.2 ; JWDB1.6 137.32,14.01 v5(136.83,13.52) ; PCZ70.2 v5(129.04,126.62) ; PRB32.1 41.03,22.94 v5(40.77,23.21) ; v1(46.66,4.4) PC1821.2 46.6,3.39 PR1815.2 ; v5(57.46,30.12) 57.66,30.32 PCV24.1 ; PQB18.3 19.86,8.92 19.62,8.68 19.62,8.22 v5(19.3,7.9) 19.15,7.75 PR28.2 ; PCZ125.2 v5(129.22,128.12) ; RX1.2 CX2.2 130.76,144.68 v5(130.45,144.99) ; JSSD1.76 v5(90.22,4.4) ; PRZ32.2 v5(145.54,121.31) PRZ68.2 ; v5(16,25.87) 14.88,25.87 PD1.1 ; PC1812.2 50.18,6.12 v5(50.18,6.24) ; PCZ98.2 v5(130.87,127.75) ; PCH6.2 v5(143.38,24.35) ; PRZ48.2 v5(135.75,129.82) ; CG7120.2 v5(3.81,40.88) ; PQ5.3 18.53,6.44 v5(18.43,6.54) ; v5(139.85,99.39) 140.22,99.03 RH188.2 ; v5(12.64,35.02) 12.51,34.89 CG7124.2 RG1569.1 ; v5(4.65,5.64) 4.83,5.82 CD402.2 ; CH187.2 92.45,52.22 v1(92.77,52.54) ; PR510.2 v5(49.97,22.51) ; RH469.2 97.22,114.07 v5(97.27,114.07) ; PCZ117.2 v5(126.48,115.23) ; v1(10.48,16.47) 10.11,16.11 CG240.2 ; JSSD3.77 v5(138.78,6.2) ; QX1.3 v5(131.69,140.36) ; PC1820.2 53.66,8.65 54,8.31 v5(54,8.28) ; v5(141.81,102.1) 140.37,102.1 RH59.2 RH184.2 ; JSSD1.77 v5(113.98,6.2) ; v5(140.27,144.67) 140.89,144.05 140.89,143.94 RC348.2 ; PCZ5.2 137.92,125.2 v5(137.57,124.84) ; CD256.2 120.27,58.51 v5(120.77,58.01) ; JSSD3.76 v5(116.02,6.16) ; PR33.1 v5(14.22,1.93) ; v5(116.84,57.3) CD347.2 ; PRB34.2 PRB42.2 v5(50.86,19.9) ; v5(105.74,131.63) 106.22,132.11 PCZ132.2 PCZ109.2 ; RH593.1 v5(92.25,109.13) ; v8(116.08,14.82) v10(116.08,15.61) 116.08,17.47 115.57,17.98 UH4.4 ; v1(17.14,75.15) 17.42,74.88 RG1489.1 ; QG525.3 10.31,21.15 v5(10.73,20.73) ; CX1.2 120.54,142.78 v5(120.15,143.16) ; PCB19.2 48.53,13.63 v5(48.64,13.74) ; PRZ2.2 v5(135.76,129.06) ; v5(89.09,41.49) 89.19,41.6 RH1021.1 ; RG1563.1 v5(4.7,40.88) ; v5(119.52,142.88) 119.24,142.6 RV18.1 ; CG517.2 41.42,140.12 v5(41.34,140.03) ; RH466.2 115.44,113.44 v5(116.01,112.87) 116.33,113.19 RH472.2 ; CD399.2 114.08,73.46 v1(113.92,73.62) ; RX8.2 v5(125.56,143.22) ; PCZ30.1 v5(135.76,130.65) ; PCZ71.2 PCZ133.2 98.03,132.22 v5(97.64,132.62) ; PCZ127.2 v5(130.61,122.52) ; PR29.2 v5(17.6,6.54)
  GND1 w0.203: 119.15,7.54 JSSD3.71 ; JSSD3.71 118.72,7.64 ; JSSD3.71 119.58,7.64 ; 118.66,154.55 JDP.23 ; JDP.23 120.26,155.7 ; JDP.23 119.46,153.39 ; JDP.23 120.26,153.39 ; JDP.23 118.66,153.39 ; JDP.23 120.26,154.55 ; JDP.23 119.46,155.7 ; JDP.23 118.66,155.7 ; H15.1 66.1,70.7 ; H15.1 66.1,65.9 ; H15.1 67.85,66.55 ; H15.1 68.5,68.3 ; H15.1 67.85,70.05 ; H15.1 64.35,70.05 ; H15.1 63.7,68.3 ; H15.1 64.35,66.55 ; JSSD3.21 131.65,9.4 ; JSSD3.21 131.22,9.3 ; JSSD3.21 132.08,9.3 ; 118.15,7.54 JSSD3.75 ; JSSD3.75 117.62,8.07 ; JSSD3.75 117.72,8.5 ; JSSD3.75 118.58,7.64 ; JSSD3.75 117.72,7.64 ; 5.05,64.44 H6.1 ; H6.1 5.05,66.7 ; H6.1 10.15,66.7 ; H6.1 5.05,68.96 ; H6.1 10.15,64.44 ; H6.1 10.15,68.96 ; H6.1 7.6,68.96 ; H6.1 7.6,64.44 ; JUSBC.2 92.23,155.35 ; JUSBC.2 91.53,155.35 ; JUSBC.2 92.93,155.35 ; JUSBC.2 92.23,152.65 ; JUSBC.2 91.53,152.65 ; JUSBC.2 92.93,152.65 ; JUSBC.2 91.53,153.85 ; JUSBC.2 92.93,153.85 ; PBATT1.14 23.5,2.57 ; PBATT1.14 22.15,3.53 ; PBATT1.14 23.5,4.48 ; PBATT1.14 22.15,2.57 ; PBATT1.14 22.15,4.48 ; PBATT1.14 23.5,3.53 ; PBATT1.14 22.82,2.57 ; PBATT1.14 22.82,4.48 ; 42.4,0.8 H4.1 ; H4.1 44.1,2.5 ; H4.1 43.65,3.75 ; H4.1 42.4,4.2 ; H4.1 40.7,2.5 ; H4.1 41.15,3.75 ; H4.1 41.15,1.25 ; H4.1 43.65,1.25 ; JSSD1.3 111.78,7.64 ; JSSD1.3 110.92,7.64 ; JSSD1.3 111.88,8.07 ; JSSD1.3 111.35,7.54 ; JCDRA.50 29.78,152.31 ; JCDRA.50 29.78,153.85 ; JCDRA.50 27.82,155.39 ; JCDRA.50 28.8,152.31 ; JCDRA.50 29.78,155.39 ; JCDRA.50 27.82,152.31 ; JCDRA.50 28.8,155.39 ; JCDRA.50 27.82,153.85 ; 104.75,151.45 H11.1 ; H11.1 106,154.4 ; H11.1 106,151 ; H11.1 107.7,152.7 ; H11.1 107.25,153.95 ; H11.1 104.3,152.7 ; H11.1 104.75,153.95 ; H11.1 107.25,151.45 ; JHDMI.22 139.55,153.7 ; JHDMI.22 140.5,153.7 ; JHDMI.22 138.6,152.54 ; JHDMI.22 140.5,151.38 ; JHDMI.22 138.6,151.38 ; JHDMI.22 140.5,152.54 ; JHDMI.22 139.55,151.38 ; JHDMI.22 138.6,153.7 ; PBATT1.13 23.5,6.05 ; PBATT1.13 23.5,7.95 ; PBATT1.13 22.15,7.95 ; PBATT1.13 22.82,7.95 ; PBATT1.13 22.15,6.05 ; PBATT1.13 22.15,7 ; PBATT1.13 22.82,6.05 ; PBATT1.13 23.5,7 ; 121.32,150.73 H12.1 ; H12.1 120.99,149.75 ; H12.1 123.28,150.73 ; H12.1 122.3,151.06 ; H12.1 123.61,149.75 ; H12.1 122.3,148.44 ; H12.1 123.28,148.77 ; H12.1 121.32,148.77 ; 124.1,145.03 JHDMI.20 ; JHDMI.20 126,146.58 ; JHDMI.20 124.1,146.58 ; JHDMI.20 125.05,145.03 ; JHDMI.20 124.1,148.13 ; JHDMI.20 126,145.03 ; JHDMI.20 125.05,148.13 ; JHDMI.20 126,148.13 ; PJPDC1.13 6.98,36.7 ; PJPDC1.13 5.02,38.05 ; PJPDC1.13 5.02,36.7 ; PJPDC1.13 6.98,37.38 ; PJPDC1.13 5.02,37.38 ; PJPDC1.13 6.98,38.05 ; PJPDC1.13 6,38.05 ; PJPDC1.13 6,36.7 ; JSSD3.9 134.65,9.4 ; JSSD3.9 134.22,9.3 ; JSSD3.9 135.08,9.3 ; 97.32,8.87 JSSD1.57 ; JSSD1.57 98.28,9.3 ; JSSD1.57 97.85,9.4 ; JSSD1.57 97.42,9.3 ; JSSD1.57 97.42,8.44 ; JCDRA.47 61.3,150.79 ; JCDRA.47 60.32,149.25 ; JCDRA.47 60.32,150.79 ; JCDRA.47 62.28,149.25 ; JCDRA.47 60.32,147.71 ; JCDRA.47 62.28,150.79 ; JCDRA.47 62.28,147.71 ; JCDRA.47 61.3,147.71 ; JHDMI.23 140.5,148.13 ; JHDMI.23 139.55,148.13 ; JHDMI.23 138.6,145.03 ; JHDMI.23 140.5,146.58 ; JHDMI.23 138.6,148.13 ; JHDMI.23 140.5,145.03 ; JHDMI.23 139.55,145.03 ; JHDMI.23 138.6,146.58 ; 27.82,150.79 JCDRA.49 ; JCDRA.49 28.8,147.71 ; JCDRA.49 29.78,149.25 ; JCDRA.49 27.82,149.25 ; JCDRA.49 28.8,150.79 ; JCDRA.49 29.78,147.71 ; JCDRA.49 29.78,150.79 ; JCDRA.49 27.82,147.71 ; 93.42,9.3 JSSD1.73 ; JSSD1.73 94.28,9.3 ; JSSD1.73 93.32,8.87 ; JSSD1.73 93.85,9.4 ; 92.92,7.64 JSSD1.75 ; JSSD1.75 92.92,8.5 ; JSSD1.75 93.78,7.64 ; JSSD1.75 93.35,7.54 ; JSSD1.75 92.82,8.07 ; H3.1 141.7,44.5 ; H3.1 141.25,43.25 ; H3.1 138.3,44.5 ; H3.1 141.25,45.75 ; H3.1 138.75,45.75 ; H3.1 138.75,43.25 ; H3.1 140,42.8 ; H3.1 140,46.2 ; 135.35,145.23 JHDMI.17 ; JHDMI.17 135.8,145.12 ; JHDMI.17 136.25,145.23 ; JHDMI.17 135.35,146.13 ; JHDMI.17 136.25,146.13 ; JHDMI.17 135.8,146.24 ; JPCMC.36 148.21,144.08 ; JPCMC.36 149.99,139.85 ; JPCMC.36 146.42,139.85 ; JPCMC.36 150.66,141.63 ; JPCMC.36 149.99,143.42 ; JPCMC.36 145.76,141.63 ; H1.1 151.25,116.15 ; H1.1 149.5,116.8 ; H1.1 147.75,112.65 ; H1.1 149.5,112 ; H1.1 147.75,116.15 ; H1.1 147.1,114.4 ; H1.1 151.9,114.4 ; H1.1 151.25,112.65 ; 115.9,147.59 JDP.14 ; JDP.14 115.9,148.68 ; JDP.14 115.35,148.13 ; JDP.14 115.46,147.7 ; JDP.14 116.34,148.57 ; JDP.14 115.46,148.57 ; JDP.14 116.34,147.7 ; JDP.24 119.66,150.08 ; JDP.24 118.06,147.39 ; JDP.24 119.66,147.39 ; JDP.24 118.86,150.08 ; JDP.24 118.86,147.39 ; JDP.24 118.06,150.08 ; JDP.24 119.66,148.74 ; JDP.24 118.06,148.74 ; H5.1 8.7,44.5 ; H5.1 8.25,43.25 ; H5.1 7,42.8 ; H5.1 7,46.2 ; H5.1 5.3,44.5 ; H5.1 5.75,43.25 ; H5.1 5.75,45.75 ; H5.1 8.25,45.75 ; 94.35,7.54 JSSD1.71 ; JSSD1.71 93.92,7.64 ; JSSD1.71 94.78,7.64 ; 122.22,9.3 JSSD3.57 ; JSSD3.57 122.12,8.87 ; JSSD3.57 122.22,8.44 ; JSSD3.57 122.65,9.4 ; JSSD3.57 123.08,9.3 ; JUSBC.4 92.93,150.85 ; JUSBC.4 91.53,150.85 ; JUSBC.4 92.93,152.06 ; JUSBC.4 92.23,152.06 ; JUSBC.4 92.23,149.64 ; JUSBC.4 91.53,152.06 ; JUSBC.4 91.53,149.64 ; JDP.22 111.14,154.55 ; JDP.22 109.54,155.7 ; JDP.22 109.54,153.39 ; JDP.22 110.34,155.7 ; JDP.22 111.14,155.7 ; JDP.22 109.54,154.55 ; JDP.22 110.34,153.39 ; JDP.22 111.14,153.39 ; JCDRA.48 62.28,152.31 ; JCDRA.48 60.32,155.39 ; JCDRA.48 60.32,153.85 ; JCDRA.48 62.28,155.39 ; JCDRA.48 60.32,152.31 ; JCDRA.48 61.3,155.39 ; JCDRA.48 62.28,153.85 ; JCDRA.48 61.3,152.31 ; JSSD1.45 101.28,9.3 ; JSSD1.45 100.42,9.3 ; JSSD1.45 100.85,9.4 ; 113.9,147.59 JDP.8 ; JDP.8 114.34,147.7 ; JDP.8 113.46,148.57 ; JDP.8 114.45,148.13 ; JDP.8 113.46,147.7 ; JDP.8 113.9,148.68 ; JDP.8 114.34,148.57 ; JSSD1.33 104.28,9.3 ; JSSD1.33 103.42,9.3 ; JSSD1.33 103.85,9.4 ; 1.55,38.05 PJPDC1.14 ; PJPDC1.14 2.53,38.05 ; PJPDC1.14 3.5,37.38 ; PJPDC1.14 1.55,36.7 ; PJPDC1.14 2.53,36.7 ; PJPDC1.14 1.55,37.38 ; PJPDC1.14 3.5,36.7 ; PJPDC1.14 3.5,38.05 ; JSSD3.3 136.68,8.07 ; JSSD3.3 135.72,7.64 ; JSSD3.3 136.58,7.64 ; JSSD3.3 136.15,7.54 ; 106.42,9.3 JSSD1.21 ; JSSD1.21 106.85,9.4 ; JSSD1.21 107.28,9.3 ; JSSD1.39 102.78,7.64 ; JSSD1.39 101.92,7.64 ; JSSD1.39 102.35,7.54 ; JHDMI.11 133.25,145.23 ; JHDMI.11 132.35,146.13 ; JHDMI.11 133.25,146.13 ; JHDMI.11 132.8,146.24 ; JHDMI.11 132.35,145.23 ; JHDMI.11 132.8,145.12 ; PBATT1.11 37.57,7.95 ; PBATT1.11 38.25,7 ; PBATT1.11 36.9,6.05 ; PBATT1.11 38.25,7.95 ; PBATT1.11 37.57,6.05 ; PBATT1.11 38.25,6.05 ; JUSBC.1 102.13,153.85 ; JUSBC.1 101.43,152.65 ; JUSBC.1 100.73,155.35 ; JUSBC.1 100.73,153.85 ; JUSBC.1 101.43,155.35 ; JUSBC.1 102.13,152.65 ; JUSBC.1 100.73,152.65 ; JUSBC.1 102.13,155.35 ; JHDMI.5 130.25,146.13 ; JHDMI.5 129.35,146.13 ; JHDMI.5 129.8,145.12 ; JHDMI.5 129.35,145.23 ; JHDMI.5 130.25,145.23 ; JHDMI.5 129.8,146.24 ; H14.1 70.5,131.35 ; H14.1 68.1,128.95 ; H14.1 70.5,126.55 ; H14.1 72.25,127.2 ; H14.1 68.75,130.7 ; H14.1 72.25,130.7 ; H14.1 72.9,128.95 ; H14.1 68.75,127.2 ; 36.9,3.53 PBATT1.12 ; PBATT1.12 37.57,4.48 ; PBATT1.12 38.25,3.53 ; PBATT1.12 36.9,4.48 ; PBATT1.12 36.9,2.57 ; PBATT1.12 37.57,2.57 ; PBATT1.12 38.25,2.57 ; PBATT1.12 38.25,4.48 ; JSSD3.45 126.08,9.3 ; JSSD3.45 125.65,9.4 ; JSSD3.45 125.22,9.3 ; JSSD3.15 133.58,7.64 ; JSSD3.15 133.15,7.54 ; JSSD3.15 132.72,7.64 ; 107.92,7.64 JSSD1.15 ; JSSD1.15 108.78,7.64 ; JSSD1.15 108.35,7.54 ; 94.03,149.64 JUSBC.B1 ; JUSBC.B1 94.49,150.1 ; JUSBC.B1 94.4,149.73 ; JUSBC.B1 93.66,150.47 ; H7.1 8.25,141.75 ; H7.1 4.75,138.25 ; H7.1 4.75,141.75 ; H7.1 6.5,142.4 ; H7.1 8.25,138.25 ; H7.1 6.5,137.6 ; H7.1 4.1,140 ; H7.1 8.9,140 ; 130.85,147.63 JHDMI.8 ; JHDMI.8 130.85,146.73 ; JHDMI.8 131.75,146.73 ; JHDMI.8 131.3,146.62 ; JHDMI.8 131.3,147.74 ; JHDMI.8 131.75,147.63 ; JSSD3.1 137.08,8.44 ; JSSD3.1 136.22,9.3 ; JSSD3.1 136.65,9.4 ; JSSD3.1 137.18,8.87 ; JSSD3.1 137.08,9.3 ; JSSD3.33 129.08,9.3 ; JSSD3.33 128.22,9.3 ; JSSD3.33 128.65,9.4 ; 124.1,152.54 JHDMI.21 ; JHDMI.21 125.05,151.38 ; JHDMI.21 124.1,153.7 ; JHDMI.21 126,152.54 ; JHDMI.21 126,151.38 ; JHDMI.21 126,153.7 ; JHDMI.21 124.1,151.38 ; JHDMI.21 125.05,153.7 ; JSSD1.1 112.38,8.87 ; JSSD1.1 112.28,8.44 ; JSSD1.1 111.42,9.3 ; JSSD1.1 111.85,9.4 ; JSSD1.1 112.28,9.3 ; 110.14,147.39 JDP.21 ; JDP.21 110.14,148.74 ; JDP.21 111.74,147.39 ; JDP.21 110.14,150.08 ; JDP.21 110.94,150.08 ; JDP.21 111.74,148.74 ; JDP.21 110.94,147.39 ; JDP.21 111.74,150.08 ; JUSBC.3 101.43,152.06 ; JUSBC.3 102.13,150.85 ; JUSBC.3 101.43,149.64 ; JUSBC.3 100.73,150.85 ; JUSBC.3 102.13,152.06 ; JUSBC.3 100.73,152.06 ; 127.85,147.63 JHDMI.2 ; JHDMI.2 127.74,147.18 ; JHDMI.2 128.3,146.62 ; JHDMI.2 128.75,146.73 ; JHDMI.2 128.3,147.74 ; JHDMI.2 128.75,147.63 ; JHDMI.2 127.85,146.73 ; JSSD1.9 110.28,9.3 ; JSSD1.9 109.42,9.3 ; JSSD1.9 109.85,9.4 ; JSSD3.51 124.58,7.64 ; JSSD3.51 124.15,7.54 ; JSSD3.51 123.72,7.64 ; 99.63,149.64 JUSBC.B12 ; JUSBC.B12 99.26,149.73 ; JUSBC.B12 99.17,150.1 ; JUSBC.B12 100,150.47 ; 1.55,20.8 PJPDC1.16 ; PJPDC1.16 2.53,19.45 ; PJPDC1.16 3.5,19.45 ; PJPDC1.16 2.53,20.8 ; PJPDC1.16 1.55,19.45 ; PJPDC1.16 3.5,20.8 ; PJPDC1.16 1.55,20.12 ; PJPDC1.16 3.5,20.12 ; 104.92,7.64 JSSD1.27 ; JSSD1.27 105.35,7.54 ; JSSD1.27 105.78,7.64 ; H10.1 89.37,152.7 ; H10.1 88.92,151.45 ; H10.1 87.67,154.4 ; H10.1 86.42,151.45 ; H10.1 88.92,153.95 ; H10.1 85.97,152.7 ; H10.1 86.42,153.95 ; H10.1 87.67,151 ; 118.22,9.3 JSSD3.73 ; JSSD3.73 118.12,8.87 ; JSSD3.73 119.08,9.3 ; JSSD3.73 118.65,9.4 ; 143.25,81.75 H2.1 ; H2.1 146.55,78.45 ; H2.1 147.16,80.1 ; H2.1 144.9,77.84 ; H2.1 142.64,80.1 ; H2.1 143.25,78.45 ; H2.1 144.9,82.36 ; H2.1 146.55,81.75 ; PJPDC1.15 6.98,19.45 ; PJPDC1.15 6,19.45 ; PJPDC1.15 6.98,20.8 ; PJPDC1.15 5.02,20.12 ; PJPDC1.15 6,20.8 ; PJPDC1.15 5.02,20.8 ; PJPDC1.15 5.02,19.45 ; JSSD3.39 127.58,7.64 ; JSSD3.39 126.72,7.64 ; JSSD3.39 127.15,7.54 ; JSSD1.51 99.78,7.64 ; JSSD1.51 98.92,7.64 ; JSSD1.51 99.35,7.54 ; 130.15,7.54 JSSD3.27 ; JSSD3.27 130.58,7.64 ; JSSD3.27 129.72,7.64
  GND2 w0.081: 73.97,32.92 73.92,32.97 v12(73.58,32.97) ; v12(69.34,20.47) 69.34,20.03 v1(69.41,19.97) ; 64.33,90.26 64.33,90.26 ; v1(109.82,91.3) 109.81,91.3 ; 119.74,40.95 119.74,40.95 ; 53.02,84.55 53.46,84.55
  GND2 w0.089: 115.7,40.54 115.7,40.16
  GND2 w0.203: v3(107.31,88.23) 107.45,88.23 v1(107.64,88.04) ; v1(134.21,89.66) 134.21,89.54 v3(133.92,89.25) ; PJPDC1.15 6.98,20.8 ; PJPDC1.15 6.98,19.45 ; PJPDC1.15 5.02,19.45 ; PJPDC1.15 6,19.45 ; PJPDC1.15 5.02,20.8 ; PJPDC1.15 6,20.8 ; PJPDC1.15 5.02,20.12 ; v1(36.55,101.35) v3(36.55,101.01) v1(36.55,100.65) ; v3(130.68,87.66) 130.3,88.04 v1(130.27,88.04) ; H11.1 106,154.4 ; H11.1 104.75,153.95 ; H11.1 106,151 ; H11.1 107.25,151.45 ; H11.1 104.3,152.7 ; H11.1 107.7,152.7 ; H11.1 107.25,153.95 ; H11.1 104.75,151.45 ; v1(39.35,99.25) v3(39.35,99.61) v1(39.35,99.95) ; v3(134.05,86.71) 134.05,86.66 v1(134.31,86.4) ; v1(32.35,92.25) v3(32.35,92.61) v1(32.35,92.95) ; 1.55,20.8 PJPDC1.16 ; PJPDC1.16 3.5,19.45 ; PJPDC1.16 3.5,20.12 ; PJPDC1.16 1.55,19.45 ; PJPDC1.16 1.55,20.12 ; PJPDC1.16 2.53,20.8 ; PJPDC1.16 2.53,19.45 ; PJPDC1.16 3.5,20.8 ; v1(36.55,109.05) v3(36.55,109.39) v1(36.55,109.75) ; v1(35.15,95.05) v3(35.15,95.42) v1(35.15,95.75) ; 111.42,9.3 JSSD1.1 ; JSSD1.1 112.28,9.3 ; JSSD1.1 111.85,9.4 ; JSSD1.1 112.28,8.44 ; JSSD1.1 112.38,8.87 ; 115.35,148.13 JDP.14 ; JDP.14 115.46,147.7 ; JDP.14 115.46,148.57 ; JDP.14 115.9,148.68 ; JDP.14 116.34,147.7 ; JDP.14 116.34,148.57 ; JDP.14 115.9,147.59 ; v3(112.14,86.96) 111.92,86.74 v1(111.83,86.74) ; v1(45.65,104.15) v3(45.65,103.8) v1(45.65,103.45) ; 91.53,152.65 JUSBC.2 ; JUSBC.2 92.23,155.35 ; JUSBC.2 91.53,155.35 ; JUSBC.2 91.53,153.85 ; JUSBC.2 92.23,152.65 ; JUSBC.2 92.93,153.85 ; JUSBC.2 92.93,152.65 ; JUSBC.2 92.93,155.35 ; v1(45.65,106.25) v3(45.65,106.59) v1(45.65,106.95) ; v1(104.33,89.35) 103.99,89.69 v3(103.95,89.69) ; JSSD1.33 103.85,9.4 ; JSSD1.33 104.28,9.3 ; JSSD1.33 103.42,9.3 ; v3(26.62,119.3) 26.75,119.17 v1(26.75,118.85) ; v1(49.85,105.55) v3(49.85,105.2) v1(49.85,104.85) ; JSSD1.73 94.28,9.3 ; JSSD1.73 93.85,9.4 ; JSSD1.73 93.32,8.87 ; JSSD1.73 93.42,9.3 ; v1(47.05,95.75) v3(47.05,95.42) v1(47.05,95.05) ; v3(104.9,92.17) 105.03,92.17 v1(105.25,91.95) ; v1(37.95,103.45) v3(37.95,103.8) v1(37.95,104.15) ; v1(48.45,101.35) v3(48.45,101.01) v1(48.45,100.65) ; v1(48.45,104.15) v3(48.45,103.8) v1(48.45,103.45) ; v1(41.45,99.25) v1(41.45,99.95) ; v3(54.32,108.07) 54.05,108.34 v1(54.05,108.35) ; v3(129.29,90.9) 129.04,90.65 v1(129.02,90.65) ; v1(44.25,92.95) v3(44.25,92.61) v1(44.25,92.25) ; v3(103.95,88.23) 104.09,88.23 v1(104.29,88.04) ; v1(41.45,104.85) v1(41.45,105.55) ; H7.1 8.25,138.25 ; H7.1 4.75,141.75 ; H7.1 4.75,138.25 ; H7.1 8.25,141.75 ; H7.1 6.5,142.4 ; H7.1 6.5,137.6 ; H7.1 8.9,140 ; H7.1 4.1,140 ; JSSD3.57 123.08,9.3 ; JSSD3.57 122.65,9.4 ; JSSD3.57 122.22,9.3 ; JSSD3.57 122.22,8.44 ; JSSD3.57 122.12,8.87 ; v3(112.14,85.05) 111.87,84.79 v1(111.83,84.79) ; v1(42.85,92.25) v3(42.85,92.61) v1(42.85,92.95) ; 98.92,7.64 JSSD1.51 ; JSSD1.51 99.78,7.64 ; JSSD1.51 99.35,7.54 ; JHDMI.20 126,146.58 ; JHDMI.20 126,148.13 ; JHDMI.20 126,145.03 ; JHDMI.20 124.1,145.03 ; JHDMI.20 125.05,145.03 ; JHDMI.20 124.1,146.58 ; JHDMI.20 124.1,148.13 ; JHDMI.20 125.05,148.13 ; v3(135.83,88.42) 136.16,88.76 v1(136.16,88.87) ; JSSD1.3 111.88,8.07 ; JSSD1.3 111.35,7.54 ; JSSD1.3 110.92,7.64 ; JSSD1.3 111.78,7.64 ; v3(124.68,87.15) 124.44,87.39 v1(124.4,87.39) ; v1(37.95,109.05) v3(37.95,109.39) v1(37.95,109.75) ; JSSD3.73 119.08,9.3 ; JSSD3.73 118.65,9.4 ; JSSD3.73 118.12,8.87 ; JSSD3.73 118.22,9.3 ; v1(33.75,98.55) v3(33.75,98.21) v1(33.75,97.85) ; 5.02,38.05 PJPDC1.13 ; PJPDC1.13 6,38.05 ; PJPDC1.13 5.02,37.38 ; PJPDC1.13 6.98,38.05 ; PJPDC1.13 6.98,37.38 ; PJPDC1.13 6,36.7 ; PJPDC1.13 6.98,36.7 ; PJPDC1.13 5.02,36.7 ; v1(131.77,89.35) 131.72,89.35 v3(131.51,89.56) ; v1(124.4,84.79) 124.44,84.79 v3(124.68,84.55) ; v1(42.85,109.05) v3(42.85,109.39) v1(42.85,109.75) ; v3(135.83,89.25) 135.83,89.19 v1(135.51,88.87) ; 92.23,149.64 JUSBC.4 ; JUSBC.4 91.53,152.06 ; JUSBC.4 92.93,152.06 ; JUSBC.4 92.23,152.06 ; JUSBC.4 92.93,150.85 ; JUSBC.4 91.53,150.85 ; JUSBC.4 91.53,149.64 ; 118.86,147.39 JDP.24 ; JDP.24 119.66,147.39 ; JDP.24 118.86,150.08 ; JDP.24 119.66,148.74 ; JDP.24 119.66,150.08 ; JDP.24 118.06,150.08 ; JDP.24 118.06,148.74 ; JDP.24 118.06,147.39 ; 5.75,45.75 H5.1 ; H5.1 7,42.8 ; H5.1 8.25,45.75 ; H5.1 5.75,43.25 ; H5.1 8.25,43.25 ; H5.1 7,46.2 ; H5.1 8.7,44.5 ; H5.1 5.3,44.5 ; JSSD3.9 134.65,9.4 ; JSSD3.9 135.08,9.3 ; JSSD3.9 134.22,9.3 ; JSSD3.75 118.58,7.64 ; JSSD3.75 117.72,8.5 ; JSSD3.75 118.15,7.54 ; JSSD3.75 117.62,8.07 ; JSSD3.75 117.72,7.64 ; v3(106.68,90.96) 106.76,90.96 v1(107.08,90.65) ; v1(47.05,108.35) v3(47.05,107.99) v1(47.05,107.65) ; v1(49.85,109.05) v3(49.85,109.39) v1(49.85,109.75) ; JDP.23 119.46,155.7 ; JDP.23 118.66,154.55 ; JDP.23 120.26,153.39 ; JDP.23 119.46,153.39 ; JDP.23 120.26,154.55 ; JDP.23 118.66,155.7 ; JDP.23 118.66,153.39 ; JDP.23 120.26,155.7 ; JSSD1.39 102.78,7.64 ; JSSD1.39 101.92,7.64 ; JSSD1.39 102.35,7.54 ; 27.82,155.39 JCDRA.50 ; JCDRA.50 29.78,152.31 ; JCDRA.50 29.78,153.85 ; JCDRA.50 28.8,152.31 ; JCDRA.50 29.78,155.39 ; JCDRA.50 27.82,152.31 ; JCDRA.50 27.82,153.85 ; JCDRA.50 28.8,155.39 ; v1(107.99,91.95) 107.77,92.17 v3(107.63,92.17) ; v3(44.01,112.95) 44.01,112.79 v1(44.25,112.55) ; v1(44.25,102.05) v3(44.25,102.4) v1(44.25,102.75) ; 138.6,152.54 JHDMI.22 ; JHDMI.22 139.55,151.38 ; JHDMI.22 139.55,153.7 ; JHDMI.22 138.6,151.38 ; JHDMI.22 140.5,152.54 ; JHDMI.22 140.5,153.7 ; JHDMI.22 138.6,153.7 ; JHDMI.22 140.5,151.38 ; v1(109.32,86.09) 109.36,86.09 v3(109.6,86.32) ; H2.1 147.16,80.1 ; H2.1 143.25,78.45 ; H2.1 146.55,81.75 ; H2.1 144.9,82.36 ; H2.1 144.9,77.84 ; H2.1 146.55,78.45 ; H2.1 143.25,81.75 ; H2.1 142.64,80.1 ; v3(46.35,112.2) v1(46.35,112.55) ; v1(37.95,92.95) 37.95,92.8 v3(37.76,92.61) 37.95,92.42 v1(37.95,92.25) ; v1(104.29,87.39) 104.4,87.39 v3(104.67,87.66) ; v1(33.75,109.05) v3(33.75,109.39) v1(33.75,109.75) ; v3(55,111.4) v1(54.75,111.15) ; v1(101.67,91.3) 101.37,91.59 v3(101.22,91.59) ; v3(129.29,88.93) 129.05,88.7 v1(129.02,88.7) ; 123.72,7.64 JSSD3.51 ; JSSD3.51 124.15,7.54 ; JSSD3.51 124.58,7.64 ; v1(42.85,102.75) v3(42.85,102.4) v1(42.85,102.05) ; v3(101.22,90.32) 101.34,90.32 v1(101.67,90) ; 22.82,6.05 PBATT1.13 ; PBATT1.13 22.15,7 ; PBATT1.13 22.15,6.05 ; PBATT1.13 23.5,7 ; PBATT1.13 23.5,6.05 ; PBATT1.13 22.15,7.95 ; PBATT1.13 22.82,7.95 ; PBATT1.13 23.5,7.95 ; v1(32.35,98.55) v3(32.35,98.21) v1(32.35,97.85) ; v1(131.77,88.7) 131.74,88.7 v3(131.51,88.93) ; JHDMI.11 133.25,146.13 ; JHDMI.11 133.25,145.23 ; JHDMI.11 132.35,145.23 ; JHDMI.11 132.8,146.24 ; JHDMI.11 132.35,146.13 ; JHDMI.11 132.8,145.12 ; v1(37.95,106.25) v3(37.95,106.59) v1(37.95,106.95) ; v1(47.05,94.35) v3(47.05,94.01) v1(47.05,93.65) ; v1(128.59,88.04) 128.52,88.04 v3(128.21,87.72) ; v1(44.25,97.85) v3(44.25,98.21) v1(44.25,98.55) ; JSSD3.1 137.18,8.87 ; JSSD3.1 137.08,8.44 ; JSSD3.1 136.22,9.3 ; JSSD3.1 137.08,9.3 ; JSSD3.1 136.65,9.4 ; v1(48.45,93.65) v3(48.45,94.01) v1(48.45,94.35) ; v3(125.98,89.56) 126.2,89.35 v1(126.28,89.35) ; v1(37.95,102.05) v3(37.95,102.4) v1(37.95,102.75) ; 138.75,45.75 H3.1 ; H3.1 141.25,45.75 ; H3.1 141.7,44.5 ; H3.1 138.3,44.5 ; H3.1 140,46.2 ; H3.1 141.25,43.25 ; H3.1 138.75,43.25 ; H3.1 140,42.8 ; v1(131.95,88.04) 132.08,88.04 v3(132.4,87.72) ; v1(36.55,97.85) v3(36.55,98.21) v1(36.55,98.55) ; v1(47.05,100.65) v3(47.05,101.01) v1(47.05,101.35) ; v1(35.15,102.75) v3(35.15,102.4) v1(35.15,102.05) ; v3(123.92,89.03) 123.59,88.7 v1(123.54,88.7) ; v1(45.65,97.85) v3(45.65,98.21) v1(45.65,98.55) ; v1(108.91,91.95) 108.69,92.17 v3(108.58,92.17) ; v1(33.75,104.15) v3(33.75,103.8) v1(33.75,103.45) ; v1(134.21,90.45) 134.21,90.36 v3(133.92,90.07) ; v3(32.74,119.32) 32.74,119.16 v1(33.05,118.85) ; v1(49.85,99.95) v3(49.85,99.61) v1(49.85,99.25) ; v1(109.32,86.74) 109.38,86.74 v3(109.6,86.96) ; v1(58.25,112.55) v3(58.64,112.55) ; JUSBC.B1 94.49,150.1 ; JUSBC.B1 94.03,149.64 ; JUSBC.B1 93.66,150.47 ; JUSBC.B1 94.4,149.73 ; JHDMI.8 131.75,147.63 ; JHDMI.8 130.85,147.63 ; JHDMI.8 131.3,147.74 ; JHDMI.8 131.75,146.73 ; JHDMI.8 130.85,146.73 ; JHDMI.8 131.3,146.62 ; v3(53.7,109.14) 53.61,109.05 v1(53.35,109.05) ; v3(131.64,86.94) 131.84,86.74 v1(131.95,86.74) ; v1(126.92,86.74) 126.95,86.74 v3(127.19,86.5) ; H12.1 123.28,150.73 ; H12.1 123.61,149.75 ; H12.1 121.32,148.77 ; H12.1 122.3,151.06 ; H12.1 120.99,149.75 ; H12.1 121.32,150.73 ; H12.1 122.3,148.44 ; H12.1 123.28,148.77 ; v3(103.95,90.96) 104.02,90.96 v1(104.33,90.65) ; v1(132.59,92.07) 132.82,92.29 v4(133.03,92.29) ; v5(101.2,90.99) 101.33,90.99 v1(101.67,90.65) ; 106.42,9.3 JSSD1.21 ; JSSD1.21 106.85,9.4 ; JSSD1.21 107.28,9.3 ; v3(123.44,81.05) 123.41,81.02 v1(123.05,81.02) ; v1(49.85,106.25) v3(49.85,106.59) v1(49.85,106.95) ; v1(130.68,86.39) 130.43,86.64 v3(130.43,86.77) 130.43,86.83 v1(130.68,87.09) ; v1(118.05,83.15) v3(118.05,83.59) ; v1(32.35,104.85) v3(32.35,105.2) v1(32.35,105.55) ; H14.1 70.5,131.35 ; H14.1 68.1,128.95 ; H14.1 68.75,127.2 ; H14.1 72.25,127.2 ; H14.1 72.25,130.7 ; H14.1 68.75,130.7 ; H14.1 70.5,126.55 ; H14.1 72.9,128.95 ; 129.35,145.23 JHDMI.5 ; JHDMI.5 129.8,145.12 ; JHDMI.5 129.35,146.13 ; JHDMI.5 130.25,146.13 ; JHDMI.5 130.25,145.23 ; JHDMI.5 129.8,146.24 ; v3(109.47,91.53) 109.59,91.53 v1(109.82,91.3) ; v3(53.76,107.36) v1(54.05,107.65) ; 126.72,7.64 JSSD3.39 ; JSSD3.39 127.58,7.64 ; JSSD3.39 127.15,7.54 ; 93.35,7.54 JSSD1.75 ; JSSD1.75 92.82,8.07 ; JSSD1.75 93.78,7.64 ; JSSD1.75 92.92,8.5 ; JSSD1.75 92.92,7.64 ; v1(37.95,96.45) v3(37.95,96.81) v1(37.95,97.15) ; v3(106.68,90.32) 106.75,90.32 v1(107.08,90) ; v1(45.65,95.05) v3(45.65,95.42) v1(45.65,95.75) ; v1(44.25,109.75) v3(44.25,109.39) v1(44.25,109.05) ; v1(42.85,94.35) v3(42.85,94.01) v1(42.85,93.65) ; v1(44.25,118.15) v3(44.25,118.52) ; v1(49.85,102.75) v3(49.85,102.4) v1(49.85,102.05) ; 124.1,151.38 JHDMI.21 ; JHDMI.21 126,151.38 ; JHDMI.21 125.05,151.38 ; JHDMI.21 126,153.7 ; JHDMI.21 125.05,153.7 ; JHDMI.21 126,152.54 ; JHDMI.21 124.1,153.7 ; JHDMI.21 124.1,152.54 ; v1(44.25,99.95) v3(44.25,99.61) v1(44.25,99.25) ; v1(133.62,88.04) 133.73,88.04 v3(134.05,87.72) ; v1(29.55,95.75) 29.88,95.75 v3(29.97,95.66) ; v3(105.85,92.17) 105.94,92.17 v1(106.16,91.95) ; 27.82,149.25 JCDRA.49 ; JCDRA.49 29.78,147.71 ; JCDRA.49 27.82,150.79 ; JCDRA.49 29.78,149.25 ; JCDRA.49 28.8,150.79 ; JCDRA.49 27.82,147.71 ; JCDRA.49 29.78,150.79 ; JCDRA.49 28.8,147.71 ; v3(55.18,108.62) v1(55.45,108.35) ; v1(48.45,97.15) v3(48.45,96.81) v1(48.45,96.45) ; v1(39.35,103.45) v3(39.35,103.8) v1(39.35,104.15) ; v1(32.35,102.05) v3(32.35,102.4) v1(32.35,102.75) ; v1(33.75,102.05) v3(33.75,102.4) v1(33.75,102.75) ; v1(39.35,92.95) v3(39.35,92.61) v1(39.35,92.25) ; v1(44.25,107.65) v3(44.25,107.99) v1(44.25,108.35) ; v1(55.45,111.85) v3(55.7,112.1) ; 147.75,112.65 H1.1 ; H1.1 147.75,116.15 ; H1.1 149.5,116.8 ; H1.1 151.25,116.15 ; H1.1 151.9,114.4 ; H1.1 149.5,112 ; H1.1 147.1,114.4 ; H1.1 151.25,112.65 ; JUSBC.1 101.43,155.35 ; JUSBC.1 102.13,152.65 ; JUSBC.1 100.73,153.85 ; JUSBC.1 100.73,152.65 ; JUSBC.1 102.13,153.85 ; JUSBC.1 102.13,155.35 ; JUSBC.1 100.73,155.35 ; JUSBC.1 101.43,152.65 ; v1(42.85,97.15) v3(42.85,96.81) v1(42.85,96.45) ; v3(53.07,106.67) v1(53.35,106.95) ; v3(109.47,89.63) 109.54,89.63 v1(109.82,89.35) ; v1(47.05,106.25) v3(47.05,106.59) v1(47.05,106.95) ; v1(42.15,112.55) 42.15,112.95 v3(42.04,113.06) ; v1(40.05,113.95) v3(40.4,114.3) ; v1(41.45,104.15) v1(41.45,103.45) ; v1(36.55,103.45) v3(36.55,103.8) v1(36.55,104.15) ; v1(47.05,109.05) v3(47.05,109.39) v1(47.05,109.75) ; v3(110.68,87.78) 110.93,88.04 v1(110.99,88.04) ; v1(109.82,90) 109.49,90.32 v3(109.47,90.32) ; JSSD3.3 136.58,7.64 ; JSSD3.3 136.68,8.07 ; JSSD3.3 135.72,7.64 ; JSSD3.3 136.15,7.54 ; 27.45,116.03 v1(27.45,116.75) ; 127.85,146.73 JHDMI.2 ; JHDMI.2 128.75,146.73 ; JHDMI.2 128.3,147.74 ; JHDMI.2 127.74,147.18 ; JHDMI.2 128.75,147.63 ; JHDMI.2 128.3,146.62 ; JHDMI.2 127.85,147.63 ; v1(119.37,84.79) 119.11,85.05 v3(119,85.05) ; v1(32.35,108.35) v3(32.35,107.99) v1(32.35,107.65) ; PJPDC1.14 2.53,38.05 ; PJPDC1.14 3.5,36.7 ; PJPDC1.14 3.5,38.05 ; PJPDC1.14 3.5,37.38 ; PJPDC1.14 1.55,38.05 ; PJPDC1.14 1.55,36.7 ; PJPDC1.14 2.53,36.7 ; PJPDC1.14 1.55,37.38 ; 109.54,155.7 JDP.22 ; JDP.22 111.14,153.39 ; JDP.22 110.34,155.7 ; JDP.22 110.34,153.39 ; JDP.22 111.14,154.55 ; JDP.22 111.14,155.7 ; JDP.22 109.54,153.39 ; JDP.22 109.54,154.55 ; v1(103.45,88.04) 103.26,88.23 v3(103.12,88.23) ; v1(37.95,108.35) v3(37.95,107.99) v1(37.95,107.65) ; v1(126.92,87.39) 126.95,87.39 v3(127.19,87.15) ; v1(37.95,100.65) v3(37.95,101.01) v1(37.95,101.35) ; v1(56.85,107.65) v3(57.24,107.65) ; JPCMC.36 150.66,141.63 ; JPCMC.36 149.99,139.85 ; JPCMC.36 149.99,143.42 ; JPCMC.36 148.21,144.08 ; JPCMC.36 146.42,139.85 ; v1(35.15,100.65) v3(35.15,101.01) v1(35.15,101.35) ; 129.72,7.64 JSSD3.27 ; JSSD3.27 130.15,7.54 ; JSSD3.27 130.58,7.64 ; v3(112.14,85.69) 111.89,85.44 v1(111.83,85.44) ; v3(109.47,88.99) 109.52,88.99 v1(109.82,88.7) ; v1(104.33,91.95) 104.11,92.17 v3(103.95,92.17) ; 113.9,147.59 JDP.8 ; JDP.8 113.46,148.57 ; JDP.8 114.34,147.7 ; JDP.8 114.45,148.13 ; JDP.8 113.46,147.7 ; JDP.8 113.9,148.68 ; JDP.8 114.34,148.57 ; v1(45.65,92.95) v3(45.65,92.61) v1(45.65,92.25) ; v1(42.85,104.85) v3(42.85,105.2) v1(42.85,105.55) ; v1(42.85,99.25) v3(42.85,99.61) v1(42.85,99.95) ; v1(36.55,108.35) v3(36.55,107.99) v1(36.55,107.65) ; v1(39.35,95.05) v3(39.35,95.42) v1(39.35,95.75) ; 135.35,146.13 JHDMI.17 ; JHDMI.17 135.8,146.24 ; JHDMI.17 136.25,145.23 ; JHDMI.17 136.25,146.13 ; JHDMI.17 135.35,145.23 ; JHDMI.17 135.8,145.12 ; v3(136.53,87.09) 136.53,87.09 v1(136.81,86.8) ; v1(35.15,94.35) v3(35.15,94.01) v1(35.15,93.65) ; v1(104.29,86.74) 104.36,86.74 v3(104.58,86.96) ; v3(123.92,91) 123.57,90.65 v1(123.54,90.65) ; 131.22,9.3 JSSD3.21 ; JSSD3.21 131.65,9.4 ; JSSD3.21 132.08,9.3 ; 86.42,153.95 H10.1 ; H10.1 88.92,151.45 ; H10.1 87.67,151 ; H10.1 85.97,152.7 ; H10.1 86.42,151.45 ; H10.1 89.37,152.7 ; H10.1 87.67,154.4 ; H10.1 88.92,153.95 ; JSSD1.27 105.78,7.64 ; JSSD1.27 104.92,7.64 ; JSSD1.27 105.35,7.54 ; v1(120.79,90) 120.79,89.93 v3(121.03,89.69) ; v1(40.75,98.55) v3(40.75,98.21) v1(40.75,97.85) ; v1(33.75,97.15) v3(33.75,96.81) v1(33.75,96.45) ; v1(129.02,90) v3(129.29,90.26) ; v1(47.05,92.25) v3(47.05,92.62) v1(47.05,92.95) ; 138.6,145.03 JHDMI.23 ; JHDMI.23 138.6,148.13 ; JHDMI.23 138.6,146.58 ; JHDMI.23 140.5,148.13 ; JHDMI.23 139.55,145.03 ; JHDMI.23 140.5,146.58 ; JHDMI.23 140.5,145.03 ; JHDMI.23 139.55,148.13 ; JSSD3.45 126.08,9.3 ; JSSD3.45 125.65,9.4 ; JSSD3.45 125.22,9.3 ; v1(45.65,96.45) v3(45.65,96.81) v1(45.65,97.15) ; v1(35.15,97.85) v3(35.15,98.21) v1(35.15,98.55) ; v1(35.15,104.15) v3(35.15,103.8) v1(35.15,103.45) ; v3(109.6,85.69) 109.35,85.44 v1(109.32,85.44) ; v1(132.2,84.79) 132.2,84.67 v3(132.02,84.48) ; 107.92,7.64 JSSD1.15 ; JSSD1.15 108.78,7.64 ; JSSD1.15 108.35,7.54 ; 61.3,147.71 JCDRA.47 ; JCDRA.47 61.3,150.79 ; JCDRA.47 60.32,149.25 ; JCDRA.47 60.32,147.71 ; JCDRA.47 60.32,150.79 ; JCDRA.47 62.28,147.71 ; JCDRA.47 62.28,150.79 ; JCDRA.47 62.28,149.25 ; v1(49.85,92.95) v3(49.85,92.61) v1(49.85,92.25) ; v1(33.75,104.85) v3(33.75,105.2) v1(33.75,105.55) ; v3(107.06,86.96) 106.84,86.74 v1(106.8,86.74) ; v1(45.65,99.95) v3(45.65,99.61) v1(45.65,99.25) ; v1(106.8,86.09) 106.82,86.09 v3(107.06,86.32) ; v3(123.92,90.36) 123.56,90 v1(123.54,90) ; v1(35.15,116.75) 35.26,116.75 35.48,116.96 v3(35.48,117.08) ; v1(32.35,95.05) v3(32.35,95.42) v1(32.35,95.75) ; v1(120.9,82.07) v3(120.52,82.07) ; v1(101.74,88.7) 101.64,88.7 v3(101.28,89.05) 101.57,89.35 v1(101.67,89.35) ; v1(48.45,107.65) v3(48.45,107.99) v1(48.45,108.35) ; v1(39.35,105.55) v3(39.35,105.2) v1(39.35,104.85) ; v1(126.92,84.79) 126.95,84.79 v3(127.19,84.55) ; v1(48.45,102.75) v3(48.45,102.4) v1(48.45,102.05) ; v1(123.57,88.04) 123.62,88.04 v3(123.95,88.37) ; v3(119,85.69) 119.12,85.69 v1(119.37,85.44) ; v1(47.05,102.05) v3(47.05,102.4) v1(47.05,102.75) ; v1(33.75,99.25) v3(33.75,99.61) v1(33.75,99.95) ; v1(56.15,107.65) v3(55.89,107.39) ; v1(44.25,101.35) v3(44.25,101.01) v1(44.25,100.65) ; H6.1 10.15,66.7 ; H6.1 7.6,64.44 ; H6.1 5.05,66.7 ; H6.1 10.15,64.44 ; H6.1 10.15,68.96 ; H6.1 5.05,68.96 ; H6.1 5.05,64.44 ; H6.1 7.6,68.96 ; v1(39.35,96.45) v3(39.35,96.81) v1(39.35,97.15) ; v1(39.35,106.95) v3(39.35,106.59) v1(39.35,106.25) ; v1(36.55,99.25) v3(36.55,99.61) v1(36.55,99.95) ; v1(42.85,98.55) v3(42.85,98.21) v1(42.85,97.85) ; v1(39.35,108.35) v3(39.35,107.99) v1(39.35,107.65) ; v1(32.35,97.15) v3(32.35,96.81) v1(32.35,96.45) ; v1(32.35,106.25) v3(32.35,106.59) v1(32.35,106.95) ; v1(136.16,90.45) 136.16,90.37 v3(136.4,90.13) ; v1(48.45,104.85) v3(48.45,105.2) v1(48.45,105.55) ; v3(102.04,85.05) 101.78,84.79 v1(101.77,84.79) ; v1(126.28,90) 126.18,90 v3(125.98,90.2) ; v1(134.21,88.87) 134.49,89.15 v3(134.49,89.25) ; v1(44.25,115.35) v3(44.54,115.05) ; v1(108.48,88.04) 108.39,88.04 v3(108.14,87.78) ; v1(45.65,93.65) v3(45.65,94.01) v1(45.65,94.35) ; v1(129.02,89.35) 129.24,89.56 v3(129.29,89.56) ; v1(40.75,102.75) v3(40.75,102.4) v1(40.75,102.05) ; v1(39.35,94.35) v3(39.35,94.01) v1(39.35,93.65) ; v1(134.42,87.96) 134.08,88.29 v3(134.05,88.29) ; v3(57.13,108.63) v1(56.85,108.35) ; v3(57.13,112.83) v1(56.85,112.55) ; v1(40.75,107.65) v3(40.75,107.99) v1(40.75,108.35) ; v3(124.68,85.2) 124.44,85.44 v1(124.4,85.44) ; 66.1,65.9 H15.1 ; H15.1 67.85,70.05 ; H15.1 64.35,70.05 ; H15.1 67.85,66.55 ; H15.1 64.35,66.55 ; H15.1 66.1,70.7 ; H15.1 63.7,68.3 ; H15.1 68.5,68.3 ; v1(49.85,96.45) v3(49.85,96.81) v1(49.85,97.15) ; v1(45.65,109.75) v3(45.65,109.39) v1(45.65,109.05) ; v1(44.25,104.15) v3(44.25,103.8) v1(44.25,103.45) ; v1(36.55,92.95) v3(36.55,92.61) v1(36.55,92.25) ; v1(44.25,104.85) v3(44.25,105.2) v1(44.25,105.55) ; v1(48.45,106.95) v3(48.45,106.59) v1(48.45,106.25) ; v1(33.75,92.95) v3(33.75,92.61) v1(33.75,92.25) ; v3(136.53,86.32) 136.57,86.32 v1(136.81,86.08) ; v1(56.85,103.45) 56.82,103.48 56.56,103.48 56.52,103.51 56.48,103.48 56.17,103.48 v1(56.15,103.45) ; 133.15,7.54 JSSD3.15 ; JSSD3.15 132.72,7.64 ; JSSD3.15 133.58,7.64 ; v1(36.55,95.05) v3(36.55,95.42) v1(36.55,95.75) ; v1(111.83,86.09) 111.9,86.09 v3(112.14,86.32) ; v1(36.55,106.25) v3(36.55,106.59) v1(36.55,106.95) ; v1(42.85,107.65) v3(42.85,107.99) v1(42.85,108.35) ; JUSBC.3 102.13,150.85 ; JUSBC.3 100.73,152.06 ; JUSBC.3 100.73,150.85 ; JUSBC.3 101.43,149.64 ; JUSBC.3 102.13,152.06 ; JUSBC.3 101.43,152.06 ; v1(111.83,87.39) 111.93,87.39 v3(112.14,87.59) ; v1(37.95,97.85) v3(37.95,98.21) v1(37.95,98.55) ; v1(47.05,104.15) v3(47.05,103.8) v1(47.05,103.45) ; v1(39.35,102.75) v3(39.35,102.4) v1(39.35,102.05) ; v1(29.55,102.05) 29.56,102.07 29.85,102.07 v3(29.97,101.95) ; JDP.21 110.94,150.08 ; JDP.21 110.14,148.74 ; JDP.21 111.74,147.39 ; JDP.21 110.94,147.39 ; JDP.21 110.14,147.39 ; JDP.21 111.74,150.08 ; JDP.21 111.74,148.74 ; JDP.21 110.14,150.08 ; v1(126.92,86.09) 126.95,86.09 v3(127.19,85.85) ; v3(102.04,85.69) 101.79,85.44 v1(101.77,85.44) ; v3(136.53,87.85) 136.57,87.85 v1(136.81,87.6) ; v1(122.73,88.04) 122.73,88.06 v3(122.49,88.29) ; v1(45.65,108.35) v3(45.65,107.99) v1(45.65,107.65) ; v3(121.67,82.32) 121.7,82.29 v1(122.05,82.29) ; v3(112.22,89.63) 112.28,89.63 v1(112.56,89.35) ; v3(106.74,92.17) 106.86,92.17 v1(107.08,91.95) ; v1(44.25,97.15) v3(44.25,96.81) v1(44.25,96.45) ; v1(134.24,85.75) 133.99,86 v3(133.99,86.07) ; v1(42.85,95.05) v3(42.85,95.42) v1(42.85,95.75) ; v3(129.41,88.42) 129.43,88.4 v1(129.43,88.04) ; v1(136.81,89.43) 136.9,89.43 v3(137.16,89.69) ; v3(131.64,85.64) 131.84,85.44 v1(131.95,85.44) ; v1(112.56,91.95) 112.34,92.17 v3(112.2,92.17) ; v1(131.95,87.39) 131.84,87.39 v3(131.64,87.59) ; v1(33.75,107.65) v3(33.75,107.99) v1(33.75,108.35) ; v1(37.95,105.55) v3(37.95,105.2) v1(37.95,104.85) ; JSSD1.45 101.28,9.3 ; JSSD1.45 100.42,9.3 ; JSSD1.45 100.85,9.4 ; v1(49.85,95.75) v3(49.85,95.42) v1(49.85,95.05) ; v3(112.22,91.53) 112.33,91.53 v1(112.56,91.3) ; v1(104.33,88.7) 104.04,88.99 v3(103.95,88.99) ; v1(32.35,103.45) v3(32.35,103.8) v1(32.35,104.15) ; v3(102.04,87.02) 101.77,86.75 v1(101.77,86.74) ; v3(133.22,87.72) 132.91,88.04 v1(132.79,88.04) ; v1(107.08,91.3) 106.78,91.59 v3(106.68,91.59) ; v1(32.35,93.65) v3(32.35,94.01) v1(32.35,94.35) ; v1(35.15,105.55) v3(35.15,105.2) v1(35.15,104.85) ; v1(33.75,93.65) v3(33.75,94.01) v1(33.75,94.35) ; v3(57.13,110.73) v1(56.85,110.45) ; v1(36.55,105.55) v3(36.55,105.2) v1(36.55,104.85) ; v3(57.13,112.13) v1(56.85,111.85) ; v1(104.29,85.44) 104.39,85.44 v3(104.58,85.63) ; JCDRA.48 62.28,155.39 ; JCDRA.48 60.32,155.39 ; JCDRA.48 62.28,153.85 ; JCDRA.48 61.3,152.31 ; JCDRA.48 60.32,153.85 ; JCDRA.48 61.3,155.39 ; JCDRA.48 62.28,152.31 ; JCDRA.48 60.32,152.31 ; v1(124.4,86.74) 124.44,86.74 v3(124.68,86.5) ; v3(57.13,111.43) v1(56.85,111.15) ; v3(109.7,87.66) 109.43,87.39 v1(109.32,87.39) ; v1(49.85,104.15) v3(49.85,103.8) v1(49.85,103.45) ; v1(111.65,91.95) 111.54,91.95 v3(111.32,91.72) ; v1(42.85,100.65) v3(42.85,101.01) v1(42.85,101.35) ; v1(49.85,101.35) v3(49.85,101.01) v1(49.85,100.65) ; v3(133.92,90.83) 134.21,91.12 v1(134.21,91.24) ; v1(35.15,109.05) v3(35.15,109.39) v1(35.15,109.75) ; v3(134.62,87.59) 134.6,87.59 v1(134.31,87.31) ; v1(131.95,86.09) 131.84,86.09 v3(131.64,86.29) ; v1(35.15,107.65) v3(35.15,107.99) v1(35.15,108.35) ; v1(35.15,96.45) v3(35.15,96.81) v1(35.15,97.15) ; v1(48.45,98.55) v3(48.45,98.21) v1(48.45,97.85) ; v1(45.65,102.75) v3(45.65,102.4) v1(45.65,102.05) ; v1(37.95,95.05) v3(37.95,95.42) v1(37.95,95.75) ; v1(47.05,99.95) v3(47.05,99.61) v1(47.05,99.25) ; v1(47.05,96.45) v3(47.05,96.81) v1(47.05,97.15) ; v3(112.22,90.32) 112.23,90.32 v1(112.56,90) ; v1(32.35,100.65) v3(32.35,101.01) v1(32.35,101.35) ; v3(125.68,88.33) 125.78,88.33 v1(126.08,88.04) ; v1(49.85,108.35) v3(49.85,107.99) v1(49.85,107.65) ; 97.32,8.87 JSSD1.57 ; JSSD1.57 98.28,9.3 ; JSSD1.57 97.42,8.44 ; JSSD1.57 97.42,9.3 ; JSSD1.57 97.85,9.4 ; v3(57.82,108.35) v1(58.25,108.35) ; v1(101.77,87.39) 101.89,87.39 v3(102.16,87.66) ; v1(39.35,109.05) v3(39.35,109.39) v1(39.35,109.75) ; v1(48.45,92.95) v3(48.45,92.61) v1(48.45,92.25) ; v1(129.43,86.74) 129.43,86.81 v3(129.16,87.09) 129.43,87.36 v1(129.43,87.39) ; v1(48.45,99.95) v3(48.45,99.61) v1(48.45,99.25) ; v1(54.05,103.45) v4(54.38,103.12) ; 109.42,9.3 JSSD1.9 ; JSSD1.9 109.85,9.4 ; JSSD1.9 110.28,9.3 ; v1(39.35,98.55) v3(39.35,98.21) v1(39.35,97.85) ; JSSD3.33 129.08,9.3 ; JSSD3.33 128.65,9.4 ; JSSD3.33 128.22,9.3 ; v3(107.06,85.69) 106.81,85.44 v1(106.8,85.44) ; v3(124.68,85.85) 124.44,86.09 v1(124.4,86.09) ; v1(105.12,88.04) 104.93,88.23 v3(104.78,88.23) ; 94.35,7.54 JSSD1.71 ; JSSD1.71 94.78,7.64 ; JSSD1.71 93.92,7.64 ; v1(49.85,98.55) v3(49.85,98.21) v1(49.85,97.85) ; v1(32.35,99.25) v3(32.35,99.61) v1(32.35,99.95) ; v3(29.94,97.85) v1(29.55,97.85) ; v1(45.65,101.35) v3(45.65,101.01) v1(45.65,100.65) ; v3(121.03,90.32) 120.79,90.56 v1(120.79,90.65) ; v1(36.55,94.35) v3(36.55,94.01) v1(36.55,93.65) ; v1(109.82,90.65) 109.51,90.96 v3(109.47,90.96) ; v1(37.95,94.35) 37.95,94.19 v3(37.77,94.01) 37.95,93.83 v1(37.95,93.65) ; v1(36.55,102.75) 36.56,102.74 v3(36.56,102.39) 36.56,102.06 v1(36.55,102.05) ; v1(139.63,73.34) v3(139.63,72.67) ; v1(131.77,90) 131.77,90 v3(131.51,90.26) ; PBATT1.11 38.25,7 ; PBATT1.11 38.25,7.95 ; PBATT1.11 37.57,7.95 ; v1(44.25,94.35) v3(44.25,94.01) v1(44.25,93.65) ; v3(107.19,87.66) 106.92,87.39 v1(106.8,87.39) ; v1(107.08,88.7) 106.72,89.05 v3(106.68,89.05) ; v1(40.75,109.05) v3(40.75,109.39) v1(40.75,109.75) ; v1(35.15,106.95) v3(35.15,106.59) v1(35.15,106.25) ; v1(35.15,99.25) v3(35.15,99.61) v1(35.15,99.95) ; v3(135.19,89.25) 135.19,89.2 v1(134.86,88.87) ; v1(109.32,84.79) 109.33,84.79 v3(109.6,85.05) ; v1(126.92,88.04) 126.62,88.33 v3(126.52,88.33) 126.28,88.58 v1(126.28,88.7) ; v1(35.15,92.25) v3(35.15,92.61) v1(35.15,92.95) ; v1(45.65,104.85) v3(45.65,105.2) v1(45.65,105.55) ; JSSD3.71 119.58,7.64 ; JSSD3.71 118.72,7.64 ; JSSD3.71 119.15,7.54 ; v1(54.05,110.45) v3(54.3,110.7) ; v1(52.65,108.35) v3(52.93,108.63) ; 99.17,150.1 JUSBC.B12 ; JUSBC.B12 100,150.47 ; JUSBC.B12 99.63,149.64 ; JUSBC.B12 99.26,149.73 ; v1(54.05,109.75) v3(54.33,110.03) ; v3(112.22,90.96) 112.25,90.96 v1(112.56,90.65) ; v3(125.98,90.83) 126.17,90.65 v1(126.28,90.65) ; v3(111.57,87.78) 111.82,88.04 v1(111.83,88.04) ; v3(112.22,88.99) 112.27,88.99 v1(112.56,88.7) 112.33,88.47 v3(112.33,88.36) ; v1(107.08,89.35) 106.73,89.69 v3(106.68,89.69) ; v3(104.58,84.99) 104.38,84.79 v1(104.29,84.79) ; v3(131.32,88.29) 131.11,88.08 v1(131.11,88.04) ; v1(33.75,95.05) v3(33.75,95.42) v1(33.75,95.75) ; v1(39.35,101.35) v3(39.35,101.01) v1(39.35,100.65) ; v1(47.05,105.55) v3(47.05,105.2) v1(47.05,104.85) ; v1(48.45,109.05) v3(48.45,109.39) v1(48.45,109.75) ; v3(127.51,87.78) 127.76,88.03 v1(127.76,88.04) ; v1(42.85,103.45) v3(42.85,103.8) v1(42.85,104.15) ; v3(118.17,82.01) 118.14,81.97 v1(118.14,81.59) ; v1(32.35,109.05) v3(32.35,109.39) v1(32.35,109.75) ; v1(49.85,94.35) v3(49.85,94.01) v1(49.85,93.65) ; v3(121.6,87.59) 121.68,87.59 v1(121.89,87.39) ; v1(44.25,106.25) v3(44.25,106.59) v1(44.25,106.95) ; v1(104.33,91.3) 104.04,91.59 v3(103.95,91.59) ; v1(29.55,93.65) 29.94,93.65 ; v1(55.45,110.45) v3(55.73,110.73) ; v1(54.05,104.15) v4(54.32,103.88) ; v1(47.05,97.85) v3(47.05,98.21) v1(47.05,98.55) ; v1(104.33,90) 104.01,90.32 v3(103.95,90.32) ; v1(134.81,86.89) 135.07,87.15 v3(135.13,87.15) ; v1(36.55,96.45) v3(36.55,96.81) v1(36.55,97.15) ; v1(123.54,89.35) 123.61,89.35 v3(123.92,89.66) ; v3(104.58,86.32) 104.35,86.09 v1(104.29,86.09) ; v1(101.77,86.09) 101.81,86.09 v3(102.04,86.32) ; v3(107.06,84.99) 106.86,84.79 v1(106.8,84.79) ; v1(121.89,84.79) 122.16,85.05 v3(122.17,85.05) ; v3(122.05,79.97) v1(122.05,80.39) ; v1(48.45,95.05) v3(48.45,95.42) v1(48.45,95.75) ; v1(42.85,106.25) v3(42.85,106.59) v1(42.85,106.95) ; v1(33.75,106.25) v3(33.75,106.59) v1(33.75,106.95) ; v3(110.43,91.72) 110.65,91.95 v1(110.73,91.95) ; v1(40.75,97.15) v3(40.75,96.81) v1(40.75,96.45) ; v1(122.81,82.26) v3(123.19,82.26) ; v1(37.95,99.25) v3(37.95,99.61) v1(37.95,99.95) ; v3(33.15,117.19) 33.15,116.85 v1(33.05,116.75) v3(33.36,116.44) ; v1(41.45,106.25) v1(40.75,106.95) ; v1(40.75,95.75) v1(41.45,95.05) ; v1(131.77,90.65) 131.76,90.65 v3(131.51,90.9) 131.77,91.15 v1(131.77,91.3) ; v1(44.25,95.05) v3(44.25,95.42) v1(44.25,95.75) ; v3(127.19,85.2) 126.95,85.44 v1(126.92,85.44) ; v3(35.51,117.81) v1(35.85,118.15) ; v1(41.45,92.25) v1(41.45,92.95) ; v1(33.75,101.35) v3(33.75,101.01) v1(33.75,100.65) ; v1(41.45,93.65) v1(41.45,94.35)
  GND2 w0.254: v1(24.65,83.15) v3(24.36,82.86) ; v1(23.25,83.85) v3(22.93,83.53) ; v1(5.71,130.46) 6.16,130.46 v3(6.25,130.55) ; v3(38.25,85.55) v1(37.95,85.25) ; v3(100.9,80.55) 100.9,80.55 v1(100.9,81.05) ; v1(113.92,73.62) v3(113.54,74.01) ; v3(41.85,89.18) 42.11,89.45 v1(42.15,89.45) ; v18(103.6,61.45) 103.61,61.45 v3(103.95,61.11) ; v1(37.95,118.15) 37.91,118.15 v3(37.61,117.85) ; v3(104.01,63.46) 103.63,63.85 v18(103.6,63.85) ; v3(97.67,70.58) v1(98,70.25) ; v3(107.25,63.53) 107.57,63.85 v18(107.6,63.85) ; v1(4.16,121.58) 4.16,121.07 v3(4.19,121.04) ; v3(28.99,90.2) 28.85,90.34 v1(28.85,90.85) ; v3(35.57,84.97) v1(35.85,85.25) ; v3(27.81,93.95) 27.85,93.95 v1(28.15,93.65) ; v1(40.05,118.15) v3(40.37,118.47) ; v1(11.38,45.33) 11.11,45.6 v3(11.11,45.68) ; v3(27.08,99.62) v1(26.75,99.95) ; v1(23.25,117.45) v3(23.6,117.1) ; v1(59.05,7.27) v3(59.44,7.27) ; v1(35.85,116.75) v3(35.51,116.41) ; v3(131.04,72.01) 131.17,71.88 v1(131.5,71.88) ; v3(31.37,87.73) 31.37,87.77 v3(31.65,88.05) ; v1(54.05,101.35) v3(54.38,101.02) ; v1(23.95,110.45) v3(24.39,110.89) ; v1(139.1,66.25) 139.1,66.29 v3(138.81,66.58) ; 100.01,80.61 v3(100.01,80.61) v1(100.01,81.05) ; v1(40.05,116.75) v3(40.39,117.09) ; v1(58.93,10.57) v3(59.31,10.57) ; v3(96.84,61.81) 97.2,61.45 v18(97.2,61.45) ; v3(26.39,140.1) 26.84,140.1 v1(26.86,140.12) ; v1(54.05,99.25) v3(53.65,98.85) ; v1(57.59,10.57) v3(57.98,10.57) ; v3(138.71,71.31) 138.84,71.31 139.1,71.05 v18(139.1,71.05) ; v3(98.87,67.97) 99.25,67.6 v1(99.26,67.6) ; v3(112.84,68.99) 113.18,68.65 v18(113.2,68.65) ; v1(23.95,118.85) v3(23.63,119.17) ; v3(25.66,85.56) 25.35,85.25 v1(25.35,85.25) ; v1(28.15,108.35) v3(28.45,108.05) ; v1(23.95,83.15) v3(23.66,82.86) ; v4(134.3,68.65) 134.3,68.67 v3(133.99,68.99) ; v3(129.16,65.81) 129.5,65.47 v4(129.5,65.45) ; v1(25.35,99.95) v3(25.88,99.95) ; v1(26.05,85.95) 26.05,85.95 v3(26.36,86.26) ; v1(129.32,73.18) 129.32,73.21 v3(129.03,73.5) ; v3(57.32,102.76) 56.86,102.76 v1(56.85,102.75) ; v3(27.11,95.47) 27.03,95.47 v1(26.75,95.75) ; v1(23.95,112.55) v3(24.26,112.24) ; v1(96.29,81.58) 96.29,81.2 v3(96.27,81.18) ; v3(42.26,115.75) 42.26,115.46 v1(42.15,115.35) ; v1(47.75,118.15) 47.74,118.15 47.05,118.84 v3(47.05,118.85) ; v1(131.51,66.37) 131.11,66.37 v3(131.06,66.32) ; v3(42.52,88.48) 42.59,88.48 42.85,88.75 v1(42.85,88.75) ; v1(25.35,91.55) 25.35,91.55 v3(25.02,91.22) 25.35,90.88 v1(25.35,90.85) ; v1(2.92,121.58) v3(2.92,121.1) ; v3(113.67,65.75) 113.97,65.45 v18(114,65.45) ; v1(23.95,85.95) v3(24.29,86.29) ; v3(131.06,70.64) 131.09,70.61 v1(131.51,70.61) ; v3(140.27,61.81) 139.91,61.45 v18(139.9,61.45) ; v3(97.66,68.99) 98,68.65 v18(98,68.65) ; v3(96.9,58.7) 97.2,59 v1(97.2,59.05) ; v3(38.31,87.01) 37.95,86.65 v1(37.95,86.65) ; v3(102.49,66.58) 102.8,66.26 v1(102.8,66.25) ; v18(107.6,61.45) 107.6,61.47 v3(107.28,61.78) ; v3(129.19,69.78) 129.5,69.47 v1(129.5,69.45) ; v1(44.25,116.75) v3(44.53,117.03) ; v3(137.54,72.86) 137.54,72.87 v1(137.54,73.34) ; v3(42.26,117.73) 42.26,118.04 v1(42.15,118.15) ; v1(24.65,118.85) v3(24.3,119.2) ; v1(23.95,91.55) v3(24.26,91.24) ; v3(128.4,68.99) 128.7,68.69 v18(128.7,68.65) ; 61.22,140.12 61.63,140.12 ; v1(105.6,71.06) 105.6,71.08 v3(105.28,71.4) ; v1(28.15,83.15) v3(27.82,82.82) ; v3(112.78,66.64) 113.17,66.25 v1(113.2,66.25) ; v1(23.95,87.35) v3(24.2,87.1) ; v1(28.15,97.85) 28.46,98.16 v3(28.5,98.16) ; v3(46.1,113.63) 46.1,113.7 v1(46.35,113.95) ; v3(42.26,116.33) 42.26,116.64 v1(42.15,116.75) ; v1(25.35,114.65) v3(24.94,115.06) ; v1(113.2,67.85) 113.2,67.87 v3(112.84,68.23) ; v3(28.52,106.61) 28.51,106.61 v1(28.15,106.25) ; v4(133.5,65.45) 133.4,65.45 v3(133.1,65.75) ; v1(133.5,67.85) 133.41,67.85 v3(133.16,68.1) ; v1(46.35,115.35) v3(46.07,115.63) ; v3(50.83,118.43) 50.56,118.15 v1(50.55,118.15) ; v1(40.75,113.95) 40.69,113.95 v3(40.41,113.68) ; v1(105.59,62.48) 105.59,62.52 v3(105.22,62.89) ; v1(24.65,118.15) v3(24.3,118.5) ; v18(98,71.05) 98,71.07 v3(97.66,71.4) ; v1(28.85,83.15) v3(28.61,82.91) ; v3(96.84,67.4) 97.19,67.05 v1(97.2,67.05) ; v1(23.95,99.95) v3(24.21,100.21) ; v3(50.16,119.25) 50.16,119.16 v1(49.85,118.85) ; v3(39.72,114.99) 39.72,115.02 v1(40.05,115.35) ; v3(131.06,63.81) v1(131.51,63.81) ; v3(27.83,99.67) 28.1,99.95 v1(28.15,99.95) ; v1(25.35,110.45) 25.34,110.45 v3(24.89,110.9) ; v1(103.6,69.45) 103.6,69.47 v3(103.22,69.85) ; v1(131.44,59.43) v3(131.44,59.84) ; v1(46.35,116.75) v3(46.06,116.46) ; v1(105.6,69.38) 105.59,69.38 v3(105.28,69.69) ; v3(27.77,115.71) 27.77,115.67 v1(27.45,115.35) ; v3(105.22,72.42) 105.58,72.06 v1(105.6,72.06) ; v1(33.75,118.15) v3(34.06,117.84) ; v3(25.6,87.1) v1(25.35,87.35) ; v3(105.28,59.59) 105.6,59.27 v1(105.6,59.25) ; v3(38.28,84.19) 37.95,83.86 v1(37.95,83.85) ; v3(24.94,89.53) 25.03,89.45 v1(25.35,89.45) ; v1(26.75,108.35) v3(27.08,108.01) ; v3(26.32,85.51) 26.06,85.25 v1(26.05,85.25) ; v3(35.46,118.54) v1(35.15,118.85) ; v1(105.59,65.34) 105.59,65.36 v3(105.92,65.69) ; v3(26.29,89.24) 26.54,89.24 v1(26.75,89.45) ; v3(35.54,83.54) v1(35.85,83.85) ; v1(128.7,66.25) 128.7,66.27 v3(128.4,66.58) ; v1(105.6,64.58) 105.6,64.61 v3(105.92,64.92) ; v1(26.75,91.55) 26.41,91.21 v3(26.37,91.21) ; v1(26.75,97.85) 26.75,97.74 v3(27.02,97.47) 26.75,97.2 v1(26.75,97.15) ; v18(105.59,67.7) 105.59,67.73 v3(105.28,68.04) ; v1(28.15,89.45) v3(28.46,89.14) ; v3(36.91,87.71) v1(37.25,88.05) ; v3(96.84,65.81) 97.2,65.45 v1(97.2,65.45) ; v3(25.6,115.6) 26.05,116.04 v1(26.05,116.05) ; v1(23.95,118.15) v3(23.63,118.47) ; v1(23.95,106.25) v3(23.56,106.64) ; v1(37.95,89.45) 37.95,89.41 v3(37.72,89.18) ; v4(133.5,63.85) 133.47,63.85 133.19,64.13 v3(133.19,64.13) ; v3(49.48,132.02) 49.63,131.87 v1(49.63,131.63) ; v1(2.92,104.59) v3(2.92,104.2) ; v3(27.21,85.61) 27.21,85.49 v1(27.45,85.25) ; v1(114,63.85) 114,63.86 v3(114.3,64.16) ; v3(128.33,71.4) 128.68,71.05 v18(128.7,71.05) ; v1(4.11,104.58) v3(4.11,104.18) ; v1(23.25,84.55) v3(22.89,84.19) ; v1(28.15,110.45) v3(27.87,110.73) ; v1(36.55,88.75) v3(36.86,88.43) ; v3(34.01,114.28) 34.01,114.21 v1(33.75,113.95) ; v3(39.81,113.15) 39.45,113.15 v1(39.35,113.25) ; v1(5.37,121.58) v3(5.37,121.12) ; v1(23.25,118.15) v3(23.57,117.83) ; v1(131.44,58.09) v3(131.44,58.51) ; v1(26.75,106.95) v3(26.42,107.28) ; v3(113.67,69.81) 114,69.48 v1(114,69.45) ; v1(25.35,106.25) v3(25.06,106.54) ; v3(48.84,117.81) 48.5,118.15 v1(48.45,118.15) ; v3(107.25,59.4) 107.6,59.05 v1(107.6,59.05) ; v1(23.95,108.35) v3(24.29,108.01) ; v3(105.22,61.05) 105.56,60.71 v1(105.59,60.71) ; v1(30.95,118.85) v3(30.59,119.21) ; v3(34.08,84.18) v1(33.75,83.85) ; v1(26.75,113.25) 26.85,113.35 v3(27.15,113.35) ; v1(48.45,116.75) 48.51,116.75 v3(48.85,116.42) ; v1(31.65,113.95) v3(31.65,114.36) ; v3(33.41,84.91) v1(33.75,85.25) ; v3(139.64,65.81) 139.9,65.55 v4(139.9,65.45) ; v3(24.92,108.77) 24.93,108.77 v1(25.35,108.35) ; v3(25.68,98.92) v1(25.35,99.25) ; v1(49.15,113.95) v3(49.4,114.2) ; v3(33.7,112.18) 33.75,112.23 v1(33.75,112.55) ; v1(35.85,115.35) v3(35.49,114.99) ; v3(129.79,64.16) 129.5,63.87 v4(129.5,63.85) ; v18(97.2,63.85) 97.2,63.86 v3(96.9,64.16) ; v1(6.68,121.58) v3(6.68,121.12) ; v1(23.95,93.65) v3(24.25,93.95) ; v3(114.36,61.81) v18(114,61.45) ; v1(23.95,97.85) v3(24.28,98.18) ; v1(24.65,85.95) v3(24.99,86.29) ; v1(26.75,93.65) v3(26.75,94.35) ; v1(56.26,10.57) v3(56.64,10.57) ; v1(35.85,88.05) v3(36.13,88.33) ; v3(34.07,115.03) v1(33.75,115.35) ; v1(33.75,116.75) v3(34.05,116.44) ; v1(23.95,83.85) v3(24.27,84.17) ; 29.4,135 v4(29.78,134.62) ; v1(26.05,83.85) v3(26.3,84.1)
  GND2 w0.508: v3(18.1,101.44) 18.07,101.46 v1(17.7,101.46) ; v1(9.9,121.56) v3(9.9,121.12) ; v1(9.18,121.57) v3(9.18,121.12)
  IN2 w0.058: v12(69.34,20.47) 69.41,20.54 69.41,22.67 69.93,23.19 69.93,29.31 v12(73.58,32.97)
  GND3 w0.203: JHDMI.23 139.55,148.13 ; JHDMI.23 138.6,145.03 ; JHDMI.23 139.55,145.03 ; JHDMI.23 138.6,146.58 ; JHDMI.23 138.6,148.13 ; JHDMI.23 140.5,146.58 ; JHDMI.23 140.5,145.03 ; JHDMI.23 140.5,148.13 ; H2.1 144.9,82.36 ; H2.1 144.9,77.84 ; H2.1 147.16,80.1 ; H2.1 146.55,81.75 ; H2.1 143.25,81.75 ; H2.1 142.64,80.1 ; H2.1 146.55,78.45 ; H2.1 143.25,78.45 ; JDP.14 115.9,148.68 ; JDP.14 115.46,147.7 ; JDP.14 115.35,148.13 ; JDP.14 116.34,148.57 ; JDP.14 116.34,147.7 ; JDP.14 115.9,147.59 ; JDP.14 115.46,148.57 ; JSSD1.57 98.28,9.3 ; JSSD1.57 97.85,9.4 ; JSSD1.57 97.42,9.3 ; JSSD1.57 97.32,8.87 ; JSSD1.57 97.42,8.44 ; 128.22,9.3 JSSD3.33 ; JSSD3.33 128.65,9.4 ; JSSD3.33 129.08,9.3 ; JHDMI.8 131.75,146.73 ; JHDMI.8 130.85,147.63 ; JHDMI.8 131.3,147.74 ; JHDMI.8 131.3,146.62 ; JHDMI.8 130.85,146.73 ; JHDMI.8 131.75,147.63 ; H15.1 68.5,68.3 ; H15.1 63.7,68.3 ; H15.1 67.85,70.05 ; H15.1 66.1,70.7 ; H15.1 67.85,66.55 ; H15.1 64.35,70.05 ; H15.1 64.35,66.55 ; H15.1 66.1,65.9 ; 87.67,151 H10.1 ; H10.1 88.92,151.45 ; H10.1 86.42,151.45 ; H10.1 89.37,152.7 ; H10.1 86.42,153.95 ; H10.1 87.67,154.4 ; H10.1 88.92,153.95 ; H10.1 85.97,152.7 ; 5.05,64.44 H6.1 ; H6.1 10.15,64.44 ; H6.1 5.05,66.7 ; H6.1 10.15,66.7 ; H6.1 7.6,64.44 ; H6.1 10.15,68.96 ; H6.1 5.05,68.96 ; H6.1 7.6,68.96 ; 4.1,140 H7.1 ; H7.1 8.25,141.75 ; H7.1 4.75,141.75 ; H7.1 6.5,142.4 ; H7.1 4.75,138.25 ; H7.1 8.25,138.25 ; H7.1 8.9,140 ; H7.1 6.5,137.6 ; JUSBC.2 92.93,155.35 ; JUSBC.2 92.23,155.35 ; JUSBC.2 92.23,152.65 ; JUSBC.2 91.53,153.85 ; JUSBC.2 92.93,153.85 ; JUSBC.2 92.93,152.65 ; JUSBC.2 91.53,152.65 ; JUSBC.2 91.53,155.35 ; 124.1,151.38 JHDMI.21 ; JHDMI.21 126,151.38 ; JHDMI.21 126,153.7 ; JHDMI.21 125.05,151.38 ; JHDMI.21 125.05,153.7 ; JHDMI.21 126,152.54 ; JHDMI.21 124.1,152.54 ; JHDMI.21 124.1,153.7 ; JCDRA.48 62.28,152.31 ; JCDRA.48 62.28,153.85 ; JCDRA.48 61.3,155.39 ; JCDRA.48 61.3,152.31 ; JCDRA.48 60.32,152.31 ; JCDRA.48 60.32,153.85 ; JCDRA.48 62.28,155.39 ; JCDRA.48 60.32,155.39 ; JPCMC.36 149.99,139.85 ; JPCMC.36 148.21,144.08 ; JPCMC.36 150.66,141.63 ; JPCMC.36 149.99,143.42 ; JPCMC.36 146.42,139.85 ; JDP.21 111.74,148.74 ; JDP.21 111.74,147.39 ; JDP.21 110.14,147.39 ; JDP.21 110.94,147.39 ; JDP.21 110.94,150.08 ; JDP.21 110.14,150.08 ; JDP.21 111.74,150.08 ; JDP.21 110.14,148.74 ; JDP.24 118.86,150.08 ; JDP.24 119.66,148.74 ; JDP.24 118.06,147.39 ; JDP.24 119.66,147.39 ; JDP.24 118.86,147.39 ; JDP.24 119.66,150.08 ; JDP.24 118.06,150.08 ; JDP.24 118.06,148.74 ; 124.15,7.54 JSSD3.51 ; JSSD3.51 124.58,7.64 ; JSSD3.51 123.72,7.64 ; 70.5,126.55 H14.1 ; H14.1 68.75,130.7 ; H14.1 68.75,127.2 ; H14.1 70.5,131.35 ; H14.1 72.25,130.7 ; H14.1 68.1,128.95 ; H14.1 72.25,127.2 ; H14.1 72.9,128.95 ; H1.1 151.25,112.65 ; H1.1 147.75,112.65 ; H1.1 149.5,116.8 ; H1.1 151.25,116.15 ; H1.1 147.75,116.15 ; H1.1 147.1,114.4 ; H1.1 149.5,112 ; H1.1 151.9,114.4 ; 92.82,8.07 JSSD1.75 ; JSSD1.75 92.92,7.64 ; JSSD1.75 92.92,8.5 ; JSSD1.75 93.35,7.54 ; JSSD1.75 93.78,7.64 ; 1.55,38.05 PJPDC1.14 ; PJPDC1.14 1.55,37.38 ; PJPDC1.14 1.55,36.7 ; PJPDC1.14 2.53,36.7 ; PJPDC1.14 3.5,36.7 ; PJPDC1.14 3.5,38.05 ; PJPDC1.14 3.5,37.38 ; PJPDC1.14 2.53,38.05 ; 117.72,8.5 JSSD3.75 ; JSSD3.75 118.58,7.64 ; JSSD3.75 118.15,7.54 ; JSSD3.75 117.72,7.64 ; JSSD3.75 117.62,8.07 ; 101.43,149.64 JUSBC.3 ; JUSBC.3 101.43,152.06 ; JUSBC.3 102.13,152.06 ; JUSBC.3 100.73,152.06 ; JUSBC.3 102.13,150.85 ; JUSBC.3 100.73,150.85 ; 119.46,153.39 JDP.23 ; JDP.23 118.66,154.55 ; JDP.23 120.26,155.7 ; JDP.23 120.26,153.39 ; JDP.23 118.66,153.39 ; JDP.23 118.66,155.7 ; JDP.23 120.26,154.55 ; JDP.23 119.46,155.7 ; 104.75,151.45 H11.1 ; H11.1 104.75,153.95 ; H11.1 107.7,152.7 ; H11.1 106,154.4 ; H11.1 104.3,152.7 ; H11.1 106,151 ; H11.1 107.25,151.45 ; H11.1 107.25,153.95 ; 91.53,150.85 JUSBC.4 ; JUSBC.4 92.23,152.06 ; JUSBC.4 91.53,149.64 ; JUSBC.4 91.53,152.06 ; JUSBC.4 92.23,149.64 ; JUSBC.4 92.93,150.85 ; JUSBC.4 92.93,152.06 ; JCDRA.50 29.78,153.85 ; JCDRA.50 27.82,152.31 ; JCDRA.50 27.82,153.85 ; JCDRA.50 28.8,155.39 ; JCDRA.50 29.78,155.39 ; JCDRA.50 28.8,152.31 ; JCDRA.50 29.78,152.31 ; JCDRA.50 27.82,155.39 ; PJPDC1.15 6.98,20.8 ; PJPDC1.15 5.02,20.12 ; PJPDC1.15 6,20.8 ; PJPDC1.15 6.98,19.45 ; PJPDC1.15 5.02,20.8 ; PJPDC1.15 6,19.45 ; PJPDC1.15 5.02,19.45 ; 5.02,37.38 PJPDC1.13 ; PJPDC1.13 6,38.05 ; PJPDC1.13 5.02,36.7 ; PJPDC1.13 6,36.7 ; PJPDC1.13 6.98,38.05 ; PJPDC1.13 5.02,38.05 ; PJPDC1.13 6.98,36.7 ; PJPDC1.13 6.98,37.38 ; JCDRA.49 29.78,147.71 ; JCDRA.49 29.78,149.25 ; JCDRA.49 27.82,149.25 ; JCDRA.49 29.78,150.79 ; JCDRA.49 28.8,147.71 ; JCDRA.49 27.82,147.71 ; JCDRA.49 28.8,150.79 ; JCDRA.49 27.82,150.79 ; 138.6,151.38 JHDMI.22 ; JHDMI.22 140.5,151.38 ; JHDMI.22 140.5,153.7 ; JHDMI.22 139.55,153.7 ; JHDMI.22 138.6,152.54 ; JHDMI.22 138.6,153.7 ; JHDMI.22 139.55,151.38 ; JHDMI.22 140.5,152.54 ; 60.32,149.25 JCDRA.47 ; JCDRA.47 60.32,147.71 ; JCDRA.47 61.3,150.79 ; JCDRA.47 61.3,147.71 ; JCDRA.47 62.28,150.79 ; JCDRA.47 60.32,150.79 ; JCDRA.47 62.28,147.71 ; JCDRA.47 62.28,149.25 ; 122.22,9.3 JSSD3.57 ; JSSD3.57 122.65,9.4 ; JSSD3.57 122.22,8.44 ; JSSD3.57 123.08,9.3 ; JSSD3.57 122.12,8.87 ; JSSD3.45 125.65,9.4 ; JSSD3.45 126.08,9.3 ; JSSD3.45 125.22,9.3 ; 5.75,43.25 H5.1 ; H5.1 7,46.2 ; H5.1 8.25,43.25 ; H5.1 5.75,45.75 ; H5.1 8.25,45.75 ; H5.1 5.3,44.5 ; H5.1 8.7,44.5 ; H5.1 7,42.8 ; 127.15,7.54 JSSD3.39 ; JSSD3.39 127.58,7.64 ; JSSD3.39 126.72,7.64 ; H12.1 123.28,150.73 ; H12.1 123.28,148.77 ; H12.1 122.3,151.06 ; H12.1 123.61,149.75 ; H12.1 121.32,150.73 ; H12.1 122.3,148.44 ; H12.1 121.32,148.77 ; H12.1 120.99,149.75 ; 138.3,44.5 H3.1 ; H3.1 140,46.2 ; H3.1 138.75,43.25 ; H3.1 141.25,43.25 ; H3.1 141.25,45.75 ; H3.1 138.75,45.75 ; H3.1 140,42.8 ; H3.1 141.7,44.5 ; 105.35,7.54 JSSD1.27 ; JSSD1.27 104.92,7.64 ; JSSD1.27 105.78,7.64 ; JSSD1.3 111.88,8.07 ; JSSD1.3 110.92,7.64 ; JSSD1.3 111.35,7.54 ; JSSD1.3 111.78,7.64 ; JSSD1.9 110.28,9.3 ; JSSD1.9 109.42,9.3 ; JSSD1.9 109.85,9.4 ; JSSD1.73 94.28,9.3 ; JSSD1.73 93.85,9.4 ; JSSD1.73 93.32,8.87 ; JSSD1.73 93.42,9.3 ; 129.72,7.64 JSSD3.27 ; JSSD3.27 130.58,7.64 ; JSSD3.27 130.15,7.54 ; 100.42,9.3 JSSD1.45 ; JSSD1.45 100.85,9.4 ; JSSD1.45 101.28,9.3 ; 132.8,145.12 JHDMI.11 ; JHDMI.11 133.25,145.23 ; JHDMI.11 132.35,146.13 ; JHDMI.11 132.35,145.23 ; JHDMI.11 132.8,146.24 ; JHDMI.11 133.25,146.13 ; JHDMI.20 125.05,148.13 ; JHDMI.20 124.1,146.58 ; JHDMI.20 124.1,145.03 ; JHDMI.20 125.05,145.03 ; JHDMI.20 126,145.03 ; JHDMI.20 124.1,148.13 ; JHDMI.20 126,148.13 ; JHDMI.20 126,146.58 ; JSSD3.3 136.68,8.07 ; JSSD3.3 136.15,7.54 ; JSSD3.3 135.72,7.64 ; JSSD3.3 136.58,7.64 ; JSSD1.1 112.38,8.87 ; JSSD1.1 112.28,9.3 ; JSSD1.1 112.28,8.44 ; JSSD1.1 111.85,9.4 ; JSSD1.1 111.42,9.3 ; JDP.22 110.34,155.7 ; JDP.22 111.14,154.55 ; JDP.22 110.34,153.39 ; JDP.22 109.54,155.7 ; JDP.22 109.54,154.55 ; JDP.22 111.14,155.7 ; JDP.22 109.54,153.39 ; JDP.22 111.14,153.39 ; 94.35,7.54 JSSD1.71 ; JSSD1.71 94.78,7.64 ; JSSD1.71 93.92,7.64 ; 135.8,145.12 JHDMI.17 ; JHDMI.17 135.35,145.23 ; JHDMI.17 136.25,145.23 ; JHDMI.17 136.25,146.13 ; JHDMI.17 135.8,146.24 ; JHDMI.17 135.35,146.13 ; PBATT1.13 23.5,7.95 ; PBATT1.13 22.15,7 ; PBATT1.13 22.15,7.95 ; PBATT1.13 22.15,6.05 ; PBATT1.13 23.5,6.05 ; PBATT1.13 22.82,6.05 ; PBATT1.13 23.5,7 ; PBATT1.13 22.82,7.95 ; JHDMI.5 130.25,146.13 ; JHDMI.5 129.8,145.12 ; JHDMI.5 130.25,145.23 ; JHDMI.5 129.35,146.13 ; JHDMI.5 129.35,145.23 ; JHDMI.5 129.8,146.24 ; JHDMI.2 128.75,146.73 ; JHDMI.2 128.3,146.62 ; JHDMI.2 127.74,147.18 ; JHDMI.2 127.85,147.63 ; JHDMI.2 128.75,147.63 ; JHDMI.2 128.3,147.74 ; JHDMI.2 127.85,146.73 ; JSSD1.51 99.78,7.64 ; JSSD1.51 98.92,7.64 ; JSSD1.51 99.35,7.54 ; 100.73,153.85 JUSBC.1 ; JUSBC.1 100.73,155.35 ; JUSBC.1 102.13,152.65 ; JUSBC.1 102.13,155.35 ; JUSBC.1 101.43,152.65 ; JUSBC.1 101.43,155.35 ; JUSBC.1 102.13,153.85 ; JUSBC.1 100.73,152.65 ; JSSD1.33 104.28,9.3 ; JSSD1.33 103.85,9.4 ; JSSD1.33 103.42,9.3 ; JSSD3.71 119.58,7.64 ; JSSD3.71 118.72,7.64 ; JSSD3.71 119.15,7.54 ; 133.15,7.54 JSSD3.15 ; JSSD3.15 133.58,7.64 ; JSSD3.15 132.72,7.64 ; 1.55,19.45 PJPDC1.16 ; PJPDC1.16 3.5,20.12 ; PJPDC1.16 1.55,20.8 ; PJPDC1.16 2.53,20.8 ; PJPDC1.16 2.53,19.45 ; PJPDC1.16 3.5,20.8 ; PJPDC1.16 3.5,19.45 ; PJPDC1.16 1.55,20.12 ; 131.22,9.3 JSSD3.21 ; JSSD3.21 131.65,9.4 ; JSSD3.21 132.08,9.3 ; 118.12,8.87 JSSD3.73 ; JSSD3.73 119.08,9.3 ; JSSD3.73 118.65,9.4 ; JSSD3.73 118.22,9.3 ; JDP.8 114.34,148.57 ; JDP.8 114.34,147.7 ; JDP.8 114.45,148.13 ; JDP.8 113.46,147.7 ; JDP.8 113.9,147.59 ; JDP.8 113.9,148.68 ; JDP.8 113.46,148.57 ; 102.35,7.54 JSSD1.39 ; JSSD1.39 102.78,7.64 ; JSSD1.39 101.92,7.64 ; 94.03,149.64 JUSBC.B1 ; JUSBC.B1 94.49,150.1 ; JUSBC.B1 94.4,149.73 ; JUSBC.B1 93.66,150.47 ; JSSD3.9 134.65,9.4 ; JSSD3.9 135.08,9.3 ; JSSD3.9 134.22,9.3 ; JSSD3.1 137.18,8.87 ; JSSD3.1 136.65,9.4 ; JSSD3.1 136.22,9.3 ; JSSD3.1 137.08,9.3 ; JSSD3.1 137.08,8.44 ; PBATT1.11 38.25,7.95 ; PBATT1.11 38.25,7 ; PBATT1.11 37.57,7.95 ; JSSD1.21 107.28,9.3 ; JSSD1.21 106.42,9.3 ; JSSD1.21 106.85,9.4 ; 107.92,7.64 JSSD1.15 ; JSSD1.15 108.35,7.54 ; JSSD1.15 108.78,7.64 ; JUSBC.B12 100,150.47 ; JUSBC.B12 99.17,150.1 ; JUSBC.B12 99.26,149.73 ; JUSBC.B12 99.63,149.64
  VCC w0.203: 27.82,149.25 JCDRA.49 ; JCDRA.49 28.8,150.79 ; JCDRA.49 27.82,150.79 ; JCDRA.49 29.78,150.79 ; JCDRA.49 29.78,149.25 ; 124.1,151.38 JHDMI.21 ; JHDMI.21 124.1,152.54 ; JHDMI.21 125.05,151.38 ; JHDMI.21 124.1,153.7 ; JHDMI.21 126,151.38 ; JHDMI.21 126,152.54 ; JHDMI.21 125.05,153.7 ; JHDMI.21 126,153.7 ; JCDRA.48 62.28,152.31 ; JCDRA.48 60.32,155.39 ; JCDRA.48 60.32,152.31 ; JCDRA.48 62.28,155.39 ; JCDRA.48 61.3,155.39 ; JCDRA.48 61.3,152.31 ; JCDRA.48 62.28,153.85 ; JCDRA.48 60.32,153.85 ; JCDRA.47 62.28,149.25 ; JCDRA.47 60.32,150.79 ; JCDRA.47 62.28,150.79 ; JCDRA.47 61.3,150.79 ; JCDRA.47 60.32,149.25 ; 138.6,152.54 JHDMI.22 ; JHDMI.22 140.5,153.7 ; JHDMI.22 139.55,153.7 ; JHDMI.22 140.5,151.38 ; JHDMI.22 139.55,151.38 ; JHDMI.22 138.6,151.38 ; JHDMI.22 138.6,153.7 ; JHDMI.22 140.5,152.54 ; JDP.24 119.66,150.08 ; JDP.24 118.86,147.39 ; JDP.24 118.86,150.08 ; JDP.24 119.66,148.74 ; JDP.24 119.66,147.39 ; JDP.24 118.06,148.74 ; JDP.24 118.06,147.39 ; JDP.24 118.06,150.08 ; PBATT1.14 23.5,3.53 ; PBATT1.14 22.82,4.48 ; PBATT1.14 23.5,2.57 ; PBATT1.14 22.15,2.57 ; PBATT1.14 22.15,4.48 ; PBATT1.14 23.5,4.48 ; PBATT1.14 22.82,2.57 ; PBATT1.14 22.15,3.53 ; 119.46,153.39 JDP.23 ; JDP.23 118.66,154.55 ; JDP.23 118.66,153.39 ; JDP.23 120.26,155.7 ; JDP.23 120.26,154.55 ; JDP.23 118.66,155.7 ; JDP.23 119.46,155.7 ; JDP.23 120.26,153.39 ; 135.35,146.13 JHDMI.17 ; JHDMI.17 135.8,146.24 ; JHDMI.17 136.25,146.13 ; 91.53,152.65 JUSBC.2 ; JUSBC.2 92.93,152.65 ; JUSBC.2 92.93,155.35 ; JUSBC.2 92.93,153.85 ; JUSBC.2 91.53,153.85 ; JUSBC.2 92.23,152.65 ; JUSBC.2 91.53,155.35 ; JUSBC.2 92.23,155.35 ; JDP.14 116.34,147.7 ; JDP.14 115.9,148.68 ; JDP.14 115.9,147.59 ; JDP.14 115.46,148.57 ; JDP.14 115.35,148.13 ; JDP.14 116.34,148.57 ; JDP.14 115.46,147.7 ; JHDMI.2 128.3,147.74 ; JHDMI.2 128.3,146.62 ; JHDMI.2 128.75,147.63 ; JHDMI.2 127.85,147.63 ; JHDMI.2 127.74,147.18 ; JHDMI.2 127.85,146.73 ; JHDMI.2 128.75,146.73 ; JDP.21 110.94,150.08 ; JDP.21 111.74,150.08 ; JDP.21 110.14,150.08 ; JDP.21 111.74,147.39 ; JDP.21 110.14,147.39 ; JDP.21 110.94,147.39 ; JDP.21 111.74,148.74 ; JDP.21 110.14,148.74 ; 100.73,150.85 JUSBC.3 ; JUSBC.3 102.13,150.85 ; JUSBC.3 102.13,152.06 ; JUSBC.3 101.43,152.06 ; JUSBC.3 100.73,152.06 ; JUSBC.1 102.13,152.65 ; JUSBC.1 100.73,153.85 ; JUSBC.1 100.73,152.65 ; JUSBC.1 101.43,155.35 ; JUSBC.1 102.13,155.35 ; JUSBC.1 100.73,155.35 ; JUSBC.1 102.13,153.85 ; JUSBC.1 101.43,152.65 ; JHDMI.20 125.05,148.13 ; JHDMI.20 126,146.58 ; JHDMI.20 126,148.13 ; JHDMI.20 124.1,148.13 ; JHDMI.20 124.1,146.58 ; JDP.22 111.14,153.39 ; JDP.22 111.14,154.55 ; JDP.22 111.14,155.7 ; JDP.22 110.34,153.39 ; JDP.22 109.54,153.39 ; JDP.22 110.34,155.7 ; JDP.22 109.54,154.55 ; JDP.22 109.54,155.7 ; 93.55,150.32 JUSBC.B1 ; JUSBC.B1 93.66,150.47 ; JUSBC.B1 93.81,150.58 ; JDP.8 114.34,147.7 ; JDP.8 113.9,147.59 ; JDP.8 114.34,148.57 ; JDP.8 114.45,148.13 ; JDP.8 113.46,148.57 ; JDP.8 113.46,147.7 ; JDP.8 113.9,148.68 ; H4.1 43.65,3.75 ; H4.1 41.15,1.25 ; H4.1 40.7,2.5 ; H4.1 43.65,1.25 ; H4.1 44.1,2.5 ; H4.1 42.4,0.8 ; H4.1 42.4,4.2 ; H4.1 41.15,3.75 ; JCDRA.50 28.8,155.39 ; JCDRA.50 29.78,155.39 ; JCDRA.50 29.78,153.85 ; JCDRA.50 27.82,155.39 ; JCDRA.50 28.8,152.31 ; JCDRA.50 27.82,152.31 ; JCDRA.50 29.78,152.31 ; JCDRA.50 27.82,153.85 ; PBATT1.12 37.57,4.48 ; PBATT1.12 37.57,2.57 ; PBATT1.12 36.9,3.53 ; PBATT1.12 36.9,4.48 ; PBATT1.12 38.25,4.48 ; PBATT1.12 38.25,2.57 ; PBATT1.12 38.25,3.53 ; PBATT1.12 36.9,2.57 ; PBATT1.11 38.25,6.05 ; PBATT1.11 36.9,6.05 ; PBATT1.11 38.25,7 ; PBATT1.11 37.57,6.05 ; 120.99,149.75 H12.1 ; H12.1 123.61,149.75 ; H12.1 122.3,151.06 ; H12.1 121.32,150.73 ; H12.1 123.28,148.77 ; H12.1 122.3,148.44 ; H12.1 121.32,148.77 ; H12.1 123.28,150.73 ; 91.53,152.06 JUSBC.4 ; JUSBC.4 92.23,152.06 ; JUSBC.4 92.93,150.85 ; JUSBC.4 91.53,150.85 ; JUSBC.4 92.93,152.06 ; JHDMI.23 140.5,148.13 ; JHDMI.23 140.5,146.58 ; JHDMI.23 139.55,148.13 ; JHDMI.23 138.6,148.13 ; JHDMI.23 138.6,146.58 ; H11.1 107.25,153.95 ; H11.1 104.75,153.95 ; H11.1 106,151 ; H11.1 107.25,151.45 ; H11.1 106,154.4 ; H11.1 107.7,152.7 ; H11.1 104.75,151.45 ; H11.1 104.3,152.7 ; 129.35,146.13 JHDMI.5 ; JHDMI.5 130.25,146.13 ; JHDMI.5 129.8,146.24 ; 22.15,7 PBATT1.13 ; PBATT1.13 22.82,6.05 ; PBATT1.13 23.5,6.05 ; PBATT1.13 23.5,7 ; PBATT1.13 22.15,6.05 ; JHDMI.11 133.25,146.13 ; JHDMI.11 132.35,146.13 ; JHDMI.11 132.8,146.24 ; 130.85,146.73 JHDMI.8 ; JHDMI.8 131.3,147.74 ; JHDMI.8 131.75,147.63 ; JHDMI.8 130.85,147.63 ; JHDMI.8 131.75,146.73 ; JHDMI.8 131.3,146.62 ; 85.97,152.7 H10.1 ; H10.1 86.42,151.45 ; H10.1 86.42,153.95 ; H10.1 89.37,152.7 ; H10.1 88.92,153.95 ; H10.1 87.67,151 ; H10.1 87.67,154.4 ; H10.1 88.92,151.45
  IN3 w0.058: v3(95.53,19.9) 95.53,19.58 95.63,19.47 95.63,19.19 95.44,19 94.5,19 93.71,19.79 92.93,19.79 92.59,19.46 91.89,19.46 91.71,19.63 90.23,19.63 90.07,19.47 90.06,19.47 89.63,19.04 89.34,19.04 89.24,18.93 88.94,18.93 88.84,19.04 87.5,19.04 85.19,16.73 84.2,16.73
  IN3 w0.076: 84.2,16.73 82.8,16.73 v9(81.14,15.06)
  IN3 w0.254: v3(12.25,134.26) 12.22,134.26 v4(11.87,133.91) ; v4(13.37,132.41) 13.72,132.76 v3(13.75,132.76) ; v3(14.5,132.76) 14.47,132.76 v4(14.12,132.41) ; v3(13,132.01) 12.97,132.01 v4(12.62,131.66) 12.28,131.32 v3(12.25,131.32) ; v3(4.74,125.33) 4.72,125.33 v4(4.38,125.67) ; v3(15.25,134.26) 15.22,134.26 v4(14.87,133.91) ; v4(13.37,133.91) 13.72,134.26 v3(13.75,134.26) ; v4(11.12,133.91) 10.78,134.26 v3(10.78,134.29) ; v4(14.12,130.91) 14.47,131.26 v3(14.5,131.26) ; v4(11.87,132.41) 12.22,132.76 v3(12.25,132.76) ; v4(2.88,126.42) 3.22,126.08 v3(3.24,126.08) ; v3(5.49,125.33) 5.47,125.33 v4(5.13,125.67) ; v3(11.5,132.76) 11.47,132.76 v4(11.12,132.41)
  GND4 w0.076: v9(81.14,15.06) 81.11,15.06 v6(80.87,14.82)
  GND4 w0.089: 115.7,40.16 v6(115.7,39.65)
  GND4 w0.203: PBATT1.12 38.25,3.53 ; PBATT1.12 38.25,2.57 ; PBATT1.12 36.9,3.53 ; PBATT1.12 38.25,4.48 ; PBATT1.12 36.9,4.48 ; PBATT1.12 37.57,2.57 ; PBATT1.12 36.9,2.57 ; PBATT1.12 37.57,4.48 ; 60.32,150.79 JCDRA.47 ; JCDRA.47 60.32,149.25 ; JCDRA.47 61.3,150.79 ; JCDRA.47 62.28,149.25 ; JCDRA.47 60.32,147.71 ; JCDRA.47 61.3,147.71 ; JCDRA.47 62.28,147.71 ; JCDRA.47 62.28,150.79 ; JDP.8 114.34,147.7 ; JDP.8 113.9,148.68 ; JDP.8 113.46,147.7 ; JDP.8 113.9,147.59 ; JDP.8 114.34,148.57 ; JDP.8 113.46,148.57 ; JDP.8 114.45,148.13 ; JHDMI.5 130.25,145.23 ; JHDMI.5 130.25,146.13 ; JHDMI.5 129.35,146.13 ; JHDMI.5 129.8,146.24 ; JHDMI.5 129.35,145.23 ; JHDMI.5 129.8,145.12 ; JHDMI.8 131.3,147.74 ; JHDMI.8 131.3,146.62 ; JHDMI.8 131.75,146.73 ; JHDMI.8 130.85,147.63 ; JHDMI.8 130.85,146.73 ; JHDMI.8 131.75,147.63 ; JDP.22 111.14,153.39 ; JDP.22 110.34,153.39 ; JDP.22 109.54,154.55 ; JDP.22 109.54,153.39 ; JDP.22 109.54,155.7 ; JDP.22 111.14,154.55 ; JDP.22 110.34,155.7 ; JDP.22 111.14,155.7 ; v3(127.19,87.15) v4(127.44,86.9) ; 87.67,151 H10.1 ; H10.1 89.37,152.7 ; H10.1 86.42,151.45 ; H10.1 87.67,154.4 ; H10.1 85.97,152.7 ; H10.1 86.42,153.95 ; H10.1 88.92,153.95 ; H10.1 88.92,151.45 ; 115.46,148.57 JDP.14 ; JDP.14 115.9,147.59 ; JDP.14 115.46,147.7 ; JDP.14 116.34,147.7 ; JDP.14 115.35,148.13 ; JDP.14 115.9,148.68 ; JDP.14 116.34,148.57 ; v4(131.25,89.18) v3(131.51,88.93) ; JUSBC.B1 94.4,149.73 ; JUSBC.B1 94.03,149.64 ; JUSBC.B1 94.49,150.1 ; JUSBC.B1 93.66,150.47 ; H5.1 8.25,45.75 ; H5.1 7,46.2 ; H5.1 7,42.8 ; H5.1 5.3,44.5 ; H5.1 8.25,43.25 ; H5.1 5.75,45.75 ; H5.1 5.75,43.25 ; H5.1 8.7,44.5 ; 91.53,149.64 JUSBC.4 ; JUSBC.4 91.53,150.85 ; JUSBC.4 92.93,150.85 ; JUSBC.4 92.23,152.06 ; JUSBC.4 92.93,152.06 ; JUSBC.4 91.53,152.06 ; JUSBC.4 92.23,149.64 ; 135.35,145.23 JHDMI.17 ; JHDMI.17 135.8,146.24 ; JHDMI.17 135.35,146.13 ; JHDMI.17 135.8,145.12 ; JHDMI.17 136.25,145.23 ; JHDMI.17 136.25,146.13 ; PJPDC1.13 6.98,38.05 ; PJPDC1.13 6,36.7 ; PJPDC1.13 6.98,37.38 ; PJPDC1.13 5.02,38.05 ; PJPDC1.13 5.02,36.7 ; PJPDC1.13 6,38.05 ; PJPDC1.13 6.98,36.7 ; PJPDC1.13 5.02,37.38 ; v4(134.62,87.21) v3(134.62,87.59) ; H1.1 151.25,116.15 ; H1.1 149.5,112 ; H1.1 151.9,114.4 ; H1.1 149.5,116.8 ; H1.1 147.1,114.4 ; H1.1 147.75,112.65 ; H1.1 151.25,112.65 ; H1.1 147.75,116.15 ; v3(124.68,85.85) v4(124.93,85.6) ; H4.1 43.65,3.75 ; H4.1 42.4,4.2 ; H4.1 40.7,2.5 ; H4.1 42.4,0.8 ; H4.1 44.1,2.5 ; H4.1 43.65,1.25 ; H4.1 41.15,1.25 ; H4.1 41.15,3.75 ; JHDMI.2 128.75,146.73 ; JHDMI.2 127.74,147.18 ; JHDMI.2 127.85,147.63 ; JHDMI.2 127.85,146.73 ; JHDMI.2 128.75,147.63 ; JHDMI.2 128.3,147.74 ; JHDMI.2 128.3,146.62 ; v4(131.38,85.37) 131.64,85.63 v3(131.64,85.64) ; H2.1 147.16,80.1 ; H2.1 144.9,82.36 ; H2.1 146.55,81.75 ; H2.1 143.25,81.75 ; H2.1 146.55,78.45 ; H2.1 144.9,77.84 ; H2.1 142.64,80.1 ; H2.1 143.25,78.45 ; JDP.21 111.74,148.74 ; JDP.21 110.94,147.39 ; JDP.21 111.74,150.08 ; JDP.21 111.74,147.39 ; JDP.21 110.14,150.08 ; JDP.21 110.94,150.08 ; JDP.21 110.14,148.74 ; JDP.21 110.14,147.39 ; H7.1 6.5,142.4 ; H7.1 6.5,137.6 ; H7.1 4.75,138.25 ; H7.1 4.1,140 ; H7.1 8.25,141.75 ; H7.1 8.9,140 ; H7.1 8.25,138.25 ; H7.1 4.75,141.75 ; JUSBC.2 92.93,153.85 ; JUSBC.2 92.23,155.35 ; JUSBC.2 92.23,152.65 ; JUSBC.2 92.93,155.35 ; JUSBC.2 92.93,152.65 ; JUSBC.2 91.53,152.65 ; JUSBC.2 91.53,155.35 ; JUSBC.2 91.53,153.85 ; v4(107.31,86.58) v3(107.06,86.32) ; v3(131.64,85.64) v4(131.38,85.9) ; v3(131.64,85.64) 131.65,85.63 v4(132.02,85.63) ; v3(142.88,69.94) 142.9,69.92 v4(142.9,69.53) ; 124.1,152.54 JHDMI.21 ; JHDMI.21 126,152.54 ; JHDMI.21 126,151.38 ; JHDMI.21 125.05,153.7 ; JHDMI.21 125.05,151.38 ; JHDMI.21 126,153.7 ; JHDMI.21 124.1,153.7 ; JHDMI.21 124.1,151.38 ; 60.32,153.85 JCDRA.48 ; JCDRA.48 60.32,155.39 ; JCDRA.48 61.3,152.31 ; JCDRA.48 62.28,152.31 ; JCDRA.48 60.32,152.31 ; JCDRA.48 62.28,153.85 ; JCDRA.48 62.28,155.39 ; JCDRA.48 61.3,155.39 ; H15.1 67.85,66.55 ; H15.1 66.1,65.9 ; H15.1 63.7,68.3 ; H15.1 64.35,66.55 ; H15.1 66.1,70.7 ; H15.1 68.5,68.3 ; H15.1 64.35,70.05 ; H15.1 67.85,70.05 ; v3(131.64,87.59) v4(131.38,87.85) ; JDP.23 119.46,155.7 ; JDP.23 118.66,154.55 ; JDP.23 120.26,155.7 ; JDP.23 120.26,154.55 ; JDP.23 118.66,153.39 ; JDP.23 118.66,155.7 ; JDP.23 120.26,153.39 ; JDP.23 119.46,153.39 ; H12.1 123.28,150.73 ; H12.1 121.32,148.77 ; H12.1 122.3,151.06 ; H12.1 121.32,150.73 ; H12.1 122.3,148.44 ; H12.1 120.99,149.75 ; H12.1 123.61,149.75 ; H12.1 123.28,148.77 ; 99.17,150.1 JUSBC.B12 ; JUSBC.B12 100,150.47 ; JUSBC.B12 99.26,149.73 ; JUSBC.B12 99.63,149.64 ; v3(131.51,90.9) 131.51,91.02 v4(131.32,91.21) ; JUSBC.1 101.43,155.35 ; JUSBC.1 102.13,155.35 ; JUSBC.1 100.73,152.65 ; JUSBC.1 101.43,152.65 ; JUSBC.1 100.73,155.35 ; JUSBC.1 100.73,153.85 ; JUSBC.1 102.13,153.85 ; JUSBC.1 102.13,152.65 ; 5.02,19.45 PJPDC1.15 ; PJPDC1.15 6,20.8 ; PJPDC1.15 6.98,20.8 ; PJPDC1.15 5.02,20.12 ; PJPDC1.15 6,19.45 ; PJPDC1.15 5.02,20.8 ; PJPDC1.15 6.98,19.45 ; v4(107.31,85.94) v3(107.06,85.69) ; 1.55,19.45 PJPDC1.16 ; PJPDC1.16 1.55,20.8 ; PJPDC1.16 3.5,20.12 ; PJPDC1.16 3.5,19.45 ; PJPDC1.16 2.53,19.45 ; PJPDC1.16 3.5,20.8 ; PJPDC1.16 2.53,20.8 ; PJPDC1.16 1.55,20.12 ; PBATT1.11 37.57,7.95 ; PBATT1.11 38.25,7 ; PBATT1.11 37.57,6.05 ; PBATT1.11 38.25,7.95 ; PBATT1.11 38.25,6.05 ; PBATT1.11 36.9,6.05 ; PJPDC1.14 3.5,38.05 ; PJPDC1.14 1.55,38.05 ; PJPDC1.14 1.55,37.38 ; PJPDC1.14 2.53,38.05 ; PJPDC1.14 2.53,36.7 ; PJPDC1.14 3.5,36.7 ; PJPDC1.14 1.55,36.7 ; PJPDC1.14 3.5,37.38 ; 138.6,151.38 JHDMI.22 ; JHDMI.22 139.55,151.38 ; JHDMI.22 140.5,152.54 ; JHDMI.22 139.55,153.7 ; JHDMI.22 140.5,153.7 ; JHDMI.22 140.5,151.38 ; JHDMI.22 138.6,152.54 ; JHDMI.22 138.6,153.7 ; v4(112.39,87.85) v3(112.14,87.59) ; 124.1,146.58 JHDMI.20 ; JHDMI.20 125.05,145.03 ; JHDMI.20 124.1,145.03 ; JHDMI.20 124.1,148.13 ; JHDMI.20 126,145.03 ; JHDMI.20 126,148.13 ; JHDMI.20 125.05,148.13 ; JHDMI.20 126,146.58 ; JCDRA.50 29.78,152.31 ; JCDRA.50 27.82,152.31 ; JCDRA.50 27.82,153.85 ; JCDRA.50 29.78,155.39 ; JCDRA.50 27.82,155.39 ; JCDRA.50 28.8,152.31 ; JCDRA.50 29.78,153.85 ; JCDRA.50 28.8,155.39 ; H14.1 70.5,131.35 ; H14.1 72.25,130.7 ; H14.1 68.75,127.2 ; H14.1 70.5,126.55 ; H14.1 72.9,128.95 ; H14.1 68.1,128.95 ; H14.1 72.25,127.2 ; H14.1 68.75,130.7 ; 22.82,2.57 PBATT1.14 ; PBATT1.14 22.15,2.57 ; PBATT1.14 22.15,4.48 ; PBATT1.14 23.5,3.53 ; PBATT1.14 23.5,2.57 ; PBATT1.14 22.82,4.48 ; PBATT1.14 23.5,4.48 ; PBATT1.14 22.15,3.53 ; H11.1 107.25,151.45 ; H11.1 106,154.4 ; H11.1 104.75,153.95 ; H11.1 106,151 ; H11.1 107.7,152.7 ; H11.1 104.75,151.45 ; H11.1 107.25,153.95 ; H11.1 104.3,152.7 ; JCDRA.49 29.78,147.71 ; JCDRA.49 29.78,150.79 ; JCDRA.49 27.82,149.25 ; JCDRA.49 29.78,149.25 ; JCDRA.49 28.8,147.71 ; JCDRA.49 28.8,150.79 ; JCDRA.49 27.82,150.79 ; JCDRA.49 27.82,147.71 ; v3(123.92,91) 124.14,91.21 v4(124.21,91.21) ; 118.06,147.39 JDP.24 ; JDP.24 118.86,150.08 ; JDP.24 119.66,147.39 ; JDP.24 118.86,147.39 ; JDP.24 119.66,150.08 ; JDP.24 118.06,150.08 ; JDP.24 119.66,148.74 ; JDP.24 118.06,148.74 ; H6.1 10.15,66.7 ; H6.1 7.6,64.44 ; H6.1 7.6,68.96 ; H6.1 10.15,68.96 ; H6.1 5.05,64.44 ; H6.1 5.05,66.7 ; H6.1 10.15,64.44 ; H6.1 5.05,68.96 ; v3(124.68,86.5) v4(124.93,86.25) ; 138.6,148.13 JHDMI.23 ; JHDMI.23 139.55,148.13 ; JHDMI.23 140.5,148.13 ; JHDMI.23 139.55,145.03 ; JHDMI.23 140.5,145.03 ; JHDMI.23 138.6,145.03 ; JHDMI.23 138.6,146.58 ; JHDMI.23 140.5,146.58 ; JPCMC.36 149.99,139.85 ; JPCMC.36 149.99,143.42 ; JPCMC.36 148.21,144.08 ; JPCMC.36 146.42,139.85 ; JPCMC.36 150.66,141.63 ; v4(104.84,87.21) v3(104.58,86.96) ; v4(139.69,73.09) 139.69,72.73 v3(139.63,72.67) ; v3(121.6,87.59) 121.6,87.66 v4(121.86,87.91) ; v4(112.39,87.21) v3(112.14,86.96) ; v3(137.92,69.05) 137.67,69.31 v4(137.54,69.31) ; v3(109.6,86.96) v4(109.86,87.21) ; v4(131.38,86.55) v3(131.64,86.29) 131.67,86.26 v4(132.02,86.26) ; v16(132.02,84.86) v3(132.02,84.48) 131.83,84.29 v16(131.83,84.17) ; H3.1 141.7,44.5 ; H3.1 138.3,44.5 ; H3.1 140,46.2 ; H3.1 140,42.8 ; H3.1 141.25,45.75 ; H3.1 138.75,45.75 ; H3.1 138.75,43.25 ; H3.1 141.25,43.25 ; v3(124.68,84.55) v4(124.93,84.29) ; v3(123.92,90.36) 124.14,90.58 v4(124.21,90.58) ; v4(102.3,85.31) v3(102.04,85.05) ; PBATT1.13 23.5,7.95 ; PBATT1.13 22.82,7.95 ; PBATT1.13 23.5,7 ; PBATT1.13 23.5,6.05 ; PBATT1.13 22.82,6.05 ; PBATT1.13 22.15,7.95 ; PBATT1.13 22.15,6.05 ; PBATT1.13 22.15,7 ; v3(124.68,87.15) v4(124.93,86.9) ; v4(104.84,86.58) v3(104.58,86.32) ; v3(109.6,85.69) v4(109.86,85.94) ; v3(137.86,70) 137.67,70.2 v4(137.48,70.2) ; v4(112.39,86.58) v3(112.14,86.32) ; v4(104.84,85.24) v3(104.58,84.99) ; v3(127.19,86.5) v4(127.44,86.25) ; v3(109.6,85.05) v4(109.86,85.31) ; v3(137.16,89.69) v4(137.16,89.31) ; v4(102.3,87.28) v3(102.04,87.02) ; v3(131.64,86.94) v4(131.38,87.2) ; v4(125.73,90.45) v3(125.98,90.2) ; 101.43,149.64 JUSBC.3 ; JUSBC.3 102.13,152.06 ; JUSBC.3 100.73,152.06 ; JUSBC.3 101.43,152.06 ; JUSBC.3 100.73,150.85 ; JUSBC.3 102.13,150.85 ; v4(112.39,85.94) v3(112.14,85.69) ; v4(122.24,88.55) v3(122.49,88.29) ; v4(142.83,68.52) 142.83,68.21 v3(142.88,68.16) ; 132.35,145.23 JHDMI.11 ; JHDMI.11 132.8,145.12 ; JHDMI.11 132.35,146.13 ; JHDMI.11 132.8,146.24 ; JHDMI.11 133.25,145.23 ; JHDMI.11 133.25,146.13 ; v4(131.25,89.82) v3(131.51,89.56) ; v3(127.19,85.85) v4(127.44,85.6) ; v4(136.02,90.13) v3(136.4,90.13) ; v3(127.19,84.55) v16(127.44,84.29) ; v4(107.31,87.21) v3(107.06,86.96) ; v4(125.73,91.09) v3(125.98,90.83) ; v4(112.39,85.31) v3(112.14,85.05) ; v3(123.92,89.66) 124.14,89.88 v4(124.21,89.88) ; v4(107.31,85.24) v3(107.06,84.99) ; v4(102.3,85.94) v3(102.04,85.69) ; v3(109.6,86.32) v4(109.86,86.58) ; v3(124.68,85.2) v4(124.93,84.95) ; v4(125.73,89.82) v3(125.98,89.56) ; v4(102.3,86.58) v3(102.04,86.32) ; v4(129.54,89.82) v3(129.29,89.56) ; v4(136.53,88.23) v3(136.53,87.85) ; v3(127.19,85.2) v4(127.44,84.95) ; v4(104.84,85.88) v3(104.58,85.63)
  GND4 w0.254: v3(129.16,67.4) 129.5,67.06 v4(129.5,67.05) ; v4(139.9,59.05) 139.92,59.05 v3(140.27,58.7) ; v3(36.55,92.61) v4(36.89,92.61) ; v4(9.24,113.39) 9.62,113.39 v3(9.7,113.31) ; v4(34.09,63.12) v3(34.54,63.12) ; 136.84,73.94 v3(136.84,73.94) v4(136.84,73.41) ; v4(50.11,93.77) 50.09,93.77 v3(49.85,94.01) ; v4(134.93,73.72) v3(134.93,74.32) 134.94,74.32 ; v4(48.45,95.79) 48.45,95.78 v3(48.45,95.42) ; 30.18,44.69 30.18,44.31 30.1,44.24 ; 6.48,78.58 v3(6.52,78.62) v4(6.52,79.15) ; v4(131.5,64.33) 131.09,64.33 v3(131.06,64.35) ; v4(39.59,97.18) 39.59,97.05 v3(39.35,96.81) ; v4(44.26,95.79) 44.25,95.78 v3(44.25,95.42) ; v3(139.64,65.81) 139.9,65.55 v4(139.9,65.45) ; v3(2.67,112.49) 2.85,112.68 2.85,112.79 v4(3.25,113.19) ; v15(44.16,115.11) 44.49,115.11 v3(44.54,115.05) 44.54,114.96 44.38,114.79 v15(44.38,114.72) ; v3(9.59,74.71) 9.63,74.68 v4(9.02,74.68) ; v4(3.13,84.1) v3(3.13,84.55) ; v4(4.35,84.08) v3(4.35,84.55) ; v4(50.1,92.86) 50.1,92.86 v3(49.85,92.61) ; v3(47.05,95.42) 47.05,95.78 v4(47.05,95.79) ; v4(139.1,68.65) 139.09,68.65 v3(138.75,68.99) ; v4(48.2,97.16) 48.2,97.07 v3(48.45,96.81) ; v4(139.9,67.05) 139.9,67.07 v3(139.57,67.4) ; v3(35.56,62.38) 35.31,62.63 v4(35.31,62.79) ; v4(4.04,78.07) 4.25,78.07 v3(4.57,78.39) 4.32,78.64 v4(4.04,78.64) ; v4(133.5,63.85) 133.47,63.85 v3(133.19,64.13) ; v3(45.65,95.42) 45.65,95.73 v4(45.59,95.79) ; v4(102.8,70.25) 102.82,70.25 v3(103.22,69.85) ; v4(10.47,77.99) 10.47,78.32 v3(10.73,78.58) ; v4(32.32,95.79) 32.35,95.76 v3(32.35,95.42) ; v3(103.25,67.4) 103.6,67.05 v4(103.6,67.05) ; v4(129.5,59.05) 129.51,59.05 v3(129.86,58.7) ; v3(33.75,95.42) 33.75,95.76 v4(33.72,95.79) ; v3(133.99,68.16) 134.3,67.85 v4(134.3,67.85) ; v4(46.67,92.61) 47.04,92.61 v3(47.05,92.62) ; v3(133.16,69.75) 133.46,69.45 v4(133.5,69.45) ; v4(51.46,62.79) 51.46,63.3 v3(51.5,63.34) ; v4(47.24,97.12) 47.24,97.01 v3(47.05,96.81) ; v3(2.73,70.2) 2.73,70.67 2.57,70.82 v4(2.57,70.99) ; v4(45.33,97.16) 45.33,97.14 v3(45.65,96.81) ; v4(37.91,95.79) 37.95,95.75 v3(37.95,95.42) ; v4(3.05,96.26) v3(3.46,95.84) 3.31,95.69 3.05,95.69 v4(3.05,95.68) ; v3(39.35,95.42) 39.35,95.74 v4(39.31,95.79) ; v4(42.8,95.79) 42.85,95.74 v3(42.85,95.42) ; v4(45.28,94.01) v3(45.65,94.01) ; v3(33.85,62.64) 33.69,62.79 v4(33.32,62.79) ; v4(44.39,97.18) 44.39,96.95 v3(44.25,96.81) ; v4(31.85,94.01) v3(32.35,94.01) ; v3(44.45,70.96) 44.22,71.19 v4(43.97,71.19) ; v4(31.85,92.61) v3(32.35,92.61) ; v4(9.24,78) 9.39,78 9.91,78.51 v3(9.91,78.58) ; 133.03,72.93 v3(133.03,72.93) v4(133.03,73.41) ; v4(131.51,68.81) 131.11,68.81 v3(131.06,68.86) ; v3(33.75,96.81) 33.87,96.94 v4(33.87,97.18) ; v4(10.47,95.07) 11.09,95.07 v3(11.11,95.09) ; v4(129.5,63.85) 129.5,63.87 v3(129.79,64.16) ; v3(133.99,66.58) 134.3,66.26 v4(134.3,66.25) ; v3(141.54,60.1) 141.55,60.09 v4(141.99,60.09) ; v3(36.55,96.81) 36.72,96.98 v4(36.72,97.18) ; v4(33.3,68.24) 32.91,68.24 32.89,68.23 v3(32.83,68.23) ; v4(42.46,97.17) 42.49,97.17 v3(42.85,96.81) ; v4(9.24,79.23) 9.89,79.23 v3(9.91,79.21) ; v4(3.79,70.98) 3.64,70.82 3.64,70.24 v3(3.68,70.2) ; v4(35.75,65.14) 35.53,65.14 v3(35.31,65.37) ; v3(35.18,68.23) 35.16,68.24 v4(34.51,68.24) ; v3(36.55,94.01) v4(36.89,94.01) ; v4(4.33,77.31) v3(4.76,77.31) ; v3(44.45,70.2) 44.34,70.31 v4(43.97,70.31) ; v4(49.85,95.79) 49.85,95.42 v3(49.85,95.42) ; v4(9.24,101.19) 9.24,101.54 v3(9.21,101.56) ; v3(37.76,92.61) v4(38.15,92.61) ; v4(3.13,101.18) v3(3.13,101.54) ; v4(5.56,84.08) v3(5.56,84.55) ; v4(48.07,94.01) v3(48.45,94.01) ; v4(9.24,96.31) v3(9.66,96.31) ; v4(5,70.98) 4.85,70.82 4.85,70.24 v3(4.89,70.2) ; v4(48.07,92.61) v3(48.45,92.61) ; v4(35.12,95.79) 35.15,95.75 v3(35.15,95.42) ; v4(45.28,92.61) v3(45.65,92.61) ; v3(36.55,95.42) v1(36.55,95.75) v4(36.51,95.79) ; v3(141.48,61.81) 141.52,61.78 v4(141.99,61.78) ; v3(37.77,94.01) v4(38.14,94.01) ; v4(129.5,65.45) 129.5,65.47 v3(129.16,65.81) ; v4(131.5,66.15) 131.23,66.15 v3(131.06,66.32) ; v4(6.79,101.19) 6.79,101.56 v3(6.79,101.56) ; v4(9.24,95.08) v3(9.72,95.08) ; v4(9.24,93.86) 9.5,93.86 v3(9.78,94.13) ; v4(46.67,94.01) v3(47.05,94.01) ; v3(35.88,67.59) 35.65,67.82 v4(35.43,67.82) ; v3(35.15,92.61) v4(35.5,92.61) ; v4(35.5,94.01) v3(35.15,94.01) ; v4(8,101.19) v3(8,101.56) ; v4(5.56,101.16) v3(5.56,101.53)
  GND4 w0.508: v4(3.47,94.95) 3.47,94.81 3.49,94.78 v3(3.49,94.33) ; v4(12.15,121.54) v3(12.15,120.87) ; v4(15.63,119.78) v3(15.63,120.23) ; v3(9.84,110.96) 9.82,110.94 v4(9.24,110.94) ; v4(13.18,119.78) v3(13.18,120.23) ; v4(13.4,121.54) v3(13.4,120.87) ; v4(5.84,116.04) v3(6.29,116.04) ; v3(11.18,118.52) 10.87,118.21 v4(10.87,118.1) ; v3(9.78,76.8) 9.76,76.78 v4(9.24,76.78) ; v4(10.47,112.15) v3(10.99,112.15) ; v4(9.24,112.16) v3(9.72,112.16) ; v3(4.38,102.71) 4.35,102.74 v4(4.35,103.29) ; v4(14.41,119.78) v3(14.41,120.23)
  IN4 w0.127: 70.73,147.25 70.23,146.75 70.23,146.14 70.36,146.01 v6(70.5,146.01) 70.65,146.01 70.97,146.33 v6(71.97,146.33) v17(73.09,146.33) 73.37,146.05 73.4,146.05 73.41,146.04 73.65,146.04 73.66,146.05 74.04,146.05 74.23,146.25 74.23,146.78 73.98,147.03 v17(73.85,147.03) 73.56,147.03 73.34,147.25 v6(72.47,147.25) v6(71.45,147.25) 70.73,147.25
  GND5 w0.203: 131.22,9.3 JSSD3.21 ; JSSD3.21 132.08,9.3 ; JSSD3.21 131.65,9.4 ; 115.46,148.57 JDP.14 ; JDP.14 116.34,147.7 ; JDP.14 115.35,148.13 ; JDP.14 115.9,148.68 ; JDP.14 116.34,148.57 ; JDP.14 115.9,147.59 ; JDP.14 115.46,147.7 ; 147.75,116.15 H1.1 ; H1.1 149.5,116.8 ; H1.1 151.25,116.15 ; H1.1 151.25,112.65 ; H1.1 147.1,114.4 ; H1.1 151.9,114.4 ; H1.1 149.5,112 ; H1.1 147.75,112.65 ; 6,36.7 PJPDC1.13 ; PJPDC1.13 6.98,36.7 ; PJPDC1.13 5.02,37.38 ; PJPDC1.13 6.98,37.38 ; PJPDC1.13 6,38.05 ; PJPDC1.13 6.98,38.05 ; PJPDC1.13 5.02,36.7 ; PJPDC1.13 5.02,38.05 ; 5.05,68.96 H6.1 ; H6.1 5.05,66.7 ; H6.1 7.6,68.96 ; H6.1 10.15,68.96 ; H6.1 10.15,64.44 ; H6.1 5.05,64.44 ; H6.1 7.6,64.44 ; H6.1 10.15,66.7 ; 130.15,7.54 JSSD3.27 ; JSSD3.27 129.72,7.64 ; JSSD3.27 130.58,7.64 ; 22.15,6.05 PBATT1.13 ; PBATT1.13 22.82,6.05 ; PBATT1.13 23.5,6.05 ; PBATT1.13 22.15,7.95 ; PBATT1.13 22.15,7 ; PBATT1.13 22.82,7.95 ; PBATT1.13 23.5,7 ; PBATT1.13 23.5,7.95 ; JPCMC.36 149.99,143.42 ; JPCMC.36 145.76,141.63 ; JPCMC.36 149.99,139.85 ; JPCMC.36 146.42,139.85 ; JPCMC.36 150.66,141.63 ; JPCMC.36 148.21,144.08 ; JHDMI.11 132.8,146.24 ; JHDMI.11 133.25,146.13 ; JHDMI.11 132.35,145.23 ; JHDMI.11 132.8,145.12 ; JHDMI.11 132.35,146.13 ; JHDMI.11 133.25,145.23 ; JHDMI.21 126,151.38 ; JHDMI.21 125.05,153.7 ; JHDMI.21 125.05,151.38 ; JHDMI.21 124.1,153.7 ; JHDMI.21 126,153.7 ; JHDMI.21 126,152.54 ; JHDMI.21 124.1,151.38 ; JHDMI.21 124.1,152.54 ; JCDRA.47 61.3,150.79 ; JCDRA.47 62.28,150.79 ; JCDRA.47 62.28,149.25 ; JCDRA.47 61.3,147.71 ; JCDRA.47 62.28,147.71 ; JCDRA.47 60.32,149.25 ; JCDRA.47 60.32,150.79 ; JCDRA.47 60.32,147.71 ; 92.92,7.64 JSSD1.75 ; JSSD1.75 93.78,7.64 ; JSSD1.75 92.82,8.07 ; JSSD1.75 93.35,7.54 ; JSSD1.75 92.92,8.5 ; JCDRA.48 62.28,152.31 ; JCDRA.48 61.3,152.31 ; JCDRA.48 60.32,152.31 ; JCDRA.48 62.28,153.85 ; JCDRA.48 60.32,155.39 ; JCDRA.48 62.28,155.39 ; JCDRA.48 60.32,153.85 ; JCDRA.48 61.3,155.39 ; PBATT1.12 37.57,4.48 ; PBATT1.12 38.25,2.57 ; PBATT1.12 38.25,3.53 ; PBATT1.12 37.57,2.57 ; PBATT1.12 36.9,2.57 ; PBATT1.12 36.9,4.48 ; PBATT1.12 38.25,4.48 ; PBATT1.12 36.9,3.53 ; JDP.21 111.74,147.39 ; JDP.21 110.14,148.74 ; JDP.21 111.74,148.74 ; JDP.21 110.14,150.08 ; JDP.21 110.94,147.39 ; JDP.21 110.14,147.39 ; JDP.21 111.74,150.08 ; JDP.21 110.94,150.08 ; H4.1 44.1,2.5 ; H4.1 41.15,1.25 ; H4.1 43.65,3.75 ; H4.1 42.4,0.8 ; H4.1 43.65,1.25 ; H4.1 42.4,4.2 ; H4.1 40.7,2.5 ; H4.1 41.15,3.75 ; JHDMI.20 126,145.03 ; JHDMI.20 126,148.13 ; JHDMI.20 126,146.58 ; JHDMI.20 125.05,145.03 ; JHDMI.20 124.1,148.13 ; JHDMI.20 124.1,146.58 ; JHDMI.20 125.05,148.13 ; JHDMI.20 124.1,145.03 ; 108.35,7.54 JSSD1.15 ; JSSD1.15 108.78,7.64 ; JSSD1.15 107.92,7.64 ; 106.42,9.3 JSSD1.21 ; JSSD1.21 106.85,9.4 ; JSSD1.21 107.28,9.3 ; H5.1 8.7,44.5 ; H5.1 5.75,45.75 ; H5.1 5.75,43.25 ; H5.1 7,42.8 ; H5.1 7,46.2 ; H5.1 8.25,43.25 ; H5.1 8.25,45.75 ; H5.1 5.3,44.5 ; 91.53,152.65 JUSBC.2 ; JUSBC.2 92.93,153.85 ; JUSBC.2 92.93,155.35 ; JUSBC.2 92.93,152.65 ; JUSBC.2 91.53,155.35 ; JUSBC.2 92.23,155.35 ; JUSBC.2 92.23,152.65 ; JUSBC.2 91.53,153.85 ; JHDMI.8 131.75,147.63 ; JHDMI.8 131.75,146.73 ; JHDMI.8 131.3,147.74 ; JHDMI.8 130.85,146.73 ; JHDMI.8 130.85,147.63 ; JHDMI.8 131.3,146.62 ; JDP.24 119.66,148.74 ; JDP.24 119.66,147.39 ; JDP.24 118.86,147.39 ; JDP.24 118.06,150.08 ; JDP.24 118.86,150.08 ; JDP.24 119.66,150.08 ; JDP.24 118.06,148.74 ; JDP.24 118.06,147.39 ; JSSD1.27 105.78,7.64 ; JSSD1.27 105.35,7.54 ; JSSD1.27 104.92,7.64 ; PBATT1.14 23.5,4.48 ; PBATT1.14 22.82,2.57 ; PBATT1.14 22.82,4.48 ; PBATT1.14 22.15,3.53 ; PBATT1.14 23.5,2.57 ; PBATT1.14 22.15,4.48 ; PBATT1.14 23.5,3.53 ; PBATT1.14 22.15,2.57 ; JUSBC.B12 100,150.47 ; JUSBC.B12 99.63,149.64 ; JUSBC.B12 99.26,149.73 ; JUSBC.B12 99.17,150.1 ; JSSD3.3 136.58,7.64 ; JSSD3.3 136.15,7.54 ; JSSD3.3 136.68,8.07 ; JSSD3.3 135.72,7.64 ; H10.1 88.92,153.95 ; H10.1 85.97,152.7 ; H10.1 89.37,152.7 ; H10.1 88.92,151.45 ; H10.1 87.67,151 ; H10.1 86.42,153.95 ; H10.1 87.67,154.4 ; H10.1 86.42,151.45 ; 118.12,8.87 JSSD3.73 ; JSSD3.73 118.65,9.4 ; JSSD3.73 118.22,9.3 ; JSSD3.73 119.08,9.3 ; JSSD1.9 110.28,9.3 ; JSSD1.9 109.42,9.3 ; JSSD1.9 109.85,9.4 ; JSSD1.73 94.28,9.3 ; JSSD1.73 93.85,9.4 ; JSSD1.73 93.42,9.3 ; JSSD1.73 93.32,8.87 ; JDP.8 113.9,148.68 ; JDP.8 113.9,147.59 ; JDP.8 113.46,147.7 ; JDP.8 114.45,148.13 ; JDP.8 113.46,148.57 ; JDP.8 114.34,147.7 ; JDP.8 114.34,148.57 ; 111.35,7.54 JSSD1.3 ; JSSD1.3 110.92,7.64 ; JSSD1.3 111.88,8.07 ; JSSD1.3 111.78,7.64 ; 122.22,8.44 JSSD3.57 ; JSSD3.57 122.12,8.87 ; JSSD3.57 122.22,9.3 ; JSSD3.57 123.08,9.3 ; JSSD3.57 122.65,9.4 ; JUSBC.4 92.93,152.06 ; JUSBC.4 91.53,150.85 ; JUSBC.4 92.93,150.85 ; JUSBC.4 92.23,149.64 ; JUSBC.4 92.23,152.06 ; JUSBC.4 91.53,152.06 ; JUSBC.4 91.53,149.64 ; 97.42,9.3 JSSD1.57 ; JSSD1.57 97.32,8.87 ; JSSD1.57 97.85,9.4 ; JSSD1.57 97.42,8.44 ; JSSD1.57 98.28,9.3 ; JSSD1.33 104.28,9.3 ; JSSD1.33 103.85,9.4 ; JSSD1.33 103.42,9.3 ; 1.55,37.38 PJPDC1.14 ; PJPDC1.14 3.5,38.05 ; PJPDC1.14 2.53,36.7 ; PJPDC1.14 1.55,36.7 ; PJPDC1.14 3.5,36.7 ; PJPDC1.14 1.55,38.05 ; PJPDC1.14 2.53,38.05 ; PJPDC1.14 3.5,37.38 ; 129.35,145.23 JHDMI.5 ; JHDMI.5 130.25,146.13 ; JHDMI.5 129.8,145.12 ; JHDMI.5 129.35,146.13 ; JHDMI.5 129.8,146.24 ; JHDMI.5 130.25,145.23 ; 27.82,153.85 JCDRA.50 ; JCDRA.50 28.8,155.39 ; JCDRA.50 29.78,153.85 ; JCDRA.50 27.82,155.39 ; JCDRA.50 29.78,155.39 ; JCDRA.50 29.78,152.31 ; JCDRA.50 27.82,152.31 ; JCDRA.50 28.8,152.31 ; H2.1 147.16,80.1 ; H2.1 142.64,80.1 ; H2.1 144.9,82.36 ; H2.1 146.55,81.75 ; H2.1 143.25,81.75 ; H2.1 143.25,78.45 ; H2.1 144.9,77.84 ; H2.1 146.55,78.45 ; 127.15,7.54 JSSD3.39 ; JSSD3.39 126.72,7.64 ; JSSD3.39 127.58,7.64 ; 36.9,6.05 PBATT1.11 ; PBATT1.11 38.25,6.05 ; PBATT1.11 37.57,7.95 ; PBATT1.11 38.25,7 ; PBATT1.11 38.25,7.95 ; PBATT1.11 37.57,6.05 ; 102.35,7.54 JSSD1.39 ; JSSD1.39 102.78,7.64 ; JSSD1.39 101.92,7.64 ; 118.15,7.54 JSSD3.75 ; JSSD3.75 117.72,7.64 ; JSSD3.75 118.58,7.64 ; JSSD3.75 117.72,8.5 ; JSSD3.75 117.62,8.07 ; JHDMI.17 135.8,146.24 ; JHDMI.17 135.8,145.12 ; JHDMI.17 135.35,145.23 ; JHDMI.17 136.25,145.23 ; JHDMI.17 136.25,146.13 ; JHDMI.17 135.35,146.13 ; 138.6,152.54 JHDMI.22 ; JHDMI.22 138.6,151.38 ; JHDMI.22 140.5,152.54 ; JHDMI.22 140.5,153.7 ; JHDMI.22 140.5,151.38 ; JHDMI.22 139.55,151.38 ; JHDMI.22 139.55,153.7 ; JHDMI.22 138.6,153.7 ; 118.72,7.64 JSSD3.71 ; JSSD3.71 119.15,7.54 ; JSSD3.71 119.58,7.64 ; JDP.23 120.26,154.55 ; JDP.23 120.26,155.7 ; JDP.23 120.26,153.39 ; JDP.23 118.66,154.55 ; JDP.23 118.66,155.7 ; JDP.23 119.46,153.39 ; JDP.23 119.46,155.7 ; JDP.23 118.66,153.39 ; JHDMI.2 128.75,147.63 ; JHDMI.2 128.75,146.73 ; JHDMI.2 128.3,147.74 ; JHDMI.2 128.3,146.62 ; JHDMI.2 127.85,146.73 ; JHDMI.2 127.85,147.63 ; JHDMI.2 127.74,147.18 ; JSSD3.1 136.65,9.4 ; JSSD3.1 137.08,9.3 ; JSSD3.1 136.22,9.3 ; JSSD3.1 137.18,8.87 ; JSSD3.1 137.08,8.44 ; JHDMI.23 139.55,148.13 ; JHDMI.23 140.5,145.03 ; JHDMI.23 138.6,148.13 ; JHDMI.23 138.6,146.58 ; JHDMI.23 140.5,148.13 ; JHDMI.23 140.5,146.58 ; JHDMI.23 138.6,145.03 ; JHDMI.23 139.55,145.03 ; 109.54,154.55 JDP.22 ; JDP.22 109.54,155.7 ; JDP.22 111.14,155.7 ; JDP.22 110.34,153.39 ; JDP.22 110.34,155.7 ; JDP.22 111.14,153.39 ; JDP.22 109.54,153.39 ; JDP.22 111.14,154.55 ; 100.73,153.85 JUSBC.1 ; JUSBC.1 101.43,152.65 ; JUSBC.1 101.43,155.35 ; JUSBC.1 102.13,155.35 ; JUSBC.1 102.13,153.85 ; JUSBC.1 102.13,152.65 ; JUSBC.1 100.73,152.65 ; JUSBC.1 100.73,155.35 ; 128.22,9.3 JSSD3.33 ; JSSD3.33 129.08,9.3 ; JSSD3.33 128.65,9.4 ; H11.1 107.7,152.7 ; H11.1 104.75,151.45 ; H11.1 107.25,151.45 ; H11.1 106,151 ; H11.1 106,154.4 ; H11.1 107.25,153.95 ; H11.1 104.3,152.7 ; H11.1 104.75,153.95 ; H3.1 141.25,43.25 ; H3.1 138.75,43.25 ; H3.1 141.25,45.75 ; H3.1 140,42.8 ; H3.1 140,46.2 ; H3.1 141.7,44.5 ; H3.1 138.3,44.5 ; H3.1 138.75,45.75 ; H12.1 122.3,151.06 ; H12.1 122.3,148.44 ; H12.1 121.32,150.73 ; H12.1 123.61,149.75 ; H12.1 120.99,149.75 ; H12.1 123.28,150.73 ; H12.1 121.32,148.77 ; H12.1 123.28,148.77 ; H14.1 72.25,127.2 ; H14.1 70.5,126.55 ; H14.1 68.1,128.95 ; H14.1 68.75,130.7 ; H14.1 68.75,127.2 ; H14.1 72.25,130.7 ; H14.1 70.5,131.35 ; H14.1 72.9,128.95 ; JCDRA.49 28.8,150.79 ; JCDRA.49 28.8,147.71 ; JCDRA.49 27.82,149.25 ; JCDRA.49 29.78,147.71 ; JCDRA.49 29.78,150.79 ; JCDRA.49 27.82,147.71 ; JCDRA.49 27.82,150.79 ; JCDRA.49 29.78,149.25 ; 1.55,20.8 PJPDC1.16 ; PJPDC1.16 3.5,19.45 ; PJPDC1.16 2.53,20.8 ; PJPDC1.16 1.55,19.45 ; PJPDC1.16 3.5,20.12 ; PJPDC1.16 3.5,20.8 ; PJPDC1.16 2.53,19.45 ; PJPDC1.16 1.55,20.12 ; JSSD1.71 94.78,7.64 ; JSSD1.71 93.92,7.64 ; JSSD1.71 94.35,7.54 ; JSSD1.1 112.28,8.44 ; JSSD1.1 112.38,8.87 ; JSSD1.1 111.42,9.3 ; JSSD1.1 112.28,9.3 ; JSSD1.1 111.85,9.4 ; 134.22,9.3 JSSD3.9 ; JSSD3.9 134.65,9.4 ; JSSD3.9 135.08,9.3 ; H7.1 6.5,142.4 ; H7.1 4.75,138.25 ; H7.1 8.25,138.25 ; H7.1 8.25,141.75 ; H7.1 8.9,140 ; H7.1 4.1,140 ; H7.1 6.5,137.6 ; H7.1 4.75,141.75 ; JSSD1.45 101.28,9.3 ; JSSD1.45 100.42,9.3 ; JSSD1.45 100.85,9.4 ; 124.15,7.54 JSSD3.51 ; JSSD3.51 123.72,7.64 ; JSSD3.51 124.58,7.64 ; JUSBC.3 101.43,152.06 ; JUSBC.3 100.73,152.06 ; JUSBC.3 102.13,152.06 ; JUSBC.3 100.73,150.85 ; JUSBC.3 101.43,149.64 ; JUSBC.3 102.13,150.85 ; 99.35,7.54 JSSD1.51 ; JSSD1.51 98.92,7.64 ; JSSD1.51 99.78,7.64 ; 133.15,7.54 JSSD3.15 ; JSSD3.15 132.72,7.64 ; JSSD3.15 133.58,7.64 ; JSSD3.45 126.08,9.3 ; JSSD3.45 125.22,9.3 ; JSSD3.45 125.65,9.4 ; JUSBC.B1 94.49,150.1 ; JUSBC.B1 94.4,149.73 ; JUSBC.B1 93.66,150.47 ; JUSBC.B1 94.03,149.64 ; H15.1 67.85,66.55 ; H15.1 64.35,66.55 ; H15.1 68.5,68.3 ; H15.1 63.7,68.3 ; H15.1 67.85,70.05 ; H15.1 64.35,70.05 ; H15.1 66.1,65.9 ; H15.1 66.1,70.7 ; 5.02,20.12 PJPDC1.15 ; PJPDC1.15 6.98,20.8 ; PJPDC1.15 5.02,20.8 ; PJPDC1.15 6.98,19.45 ; PJPDC1.15 6,20.8 ; PJPDC1.15 6,19.45 ; PJPDC1.15 5.02,19.45
  BOTTOM w0.081: UT1.U23 UT1.U22 ; UT1.R23 UT1.R22
  BOTTOM w0.127: v4(111.38,22.3) v10(110.13,22.3) ; 74.3,146.71 74.13,146.88 73.43,146.88 v18(73.41,146.9) 73.22,146.71 73.22,146.08 v18(73.34,145.95) v18(73.91,145.95) 74.2,145.95 UT1.E23 ; v10(70.89,52.39) 70.55,52.73 v5(70.55,53.3)
  BOTTOM w0.152: UT1.A20 v18(75.81,147.1) ; UT1.L23 UT1.L22 ; v5(94.66,42.32) 94.68,42.32 95,42 95,40.5 95.02,40.48 ; UT1.E22 UT1.E23 ; UT1.A16 v18(77.65,147.1) ; UT1.A18 v18(76.73,147.1) ; v5(94.66,44.52) 94.66,44.31 95,43.97 95,43.14 95.69,42.45 95.69,41.45 95.89,41.25 v5(96.16,41.25) ; UT1.A14 v18(78.57,147.1) ; UT1.A22 v18(74.89,147.1)
  BOTTOM w0.178: v18(73.88,143.61) 74.14,143.88 UT1.J23 ; v18(73.89,139.12) 74.05,139.28 UT1.W23 UT1.W22
  BOTTOM w0.203: U17.11 v5(68.01,12.09) ; UG45.11 66.48,96.43 v18(66.65,96.6)
  BOTTOM w0.254: v4(55.62,130.88) 55.89,130.61 CG6577.2 ; CG6522.2 39.42,128.53 v4(39.52,128.63) 39.56,128.59 CG6523.2 ; v4(2.88,81.92) 2.9,81.94 CG680.2 ; CG6691.2 13.57,72.73 v4(13.37,72.93) ; CG6785.2 30.72,64.48 v4(30.93,64.28) ; v5(46.8,152.2) 46.75,152.15 JEDP.19 ; v4(2.88,73.68) 3.18,73.98 CG6680.2 ; CG6735.2 45.47,74.67 v4(45.58,74.77) ; v4(48.58,74.02) 48.65,74.09 CG6745.2 ; v4(38.77,126.38) 38.89,126.26 CG6527.2 ; v4(4.38,132.41) 4.3,132.34 CG6639.2 ; CG6750.2 45.48,70.93 v4(45.58,71.02) ; CG6575.2 53.25,126.42 v4(53.15,126.52) ; v4(55.62,134.62) 55.36,134.36 CG6578.2 ; CG823.2 52.83,75.77 v4(53.07,75.52) ; CG6651.2 5.94,131.66 v4(5.88,131.66) 5.49,131.66 CG6659.2 ; CG6573.2 57.05,128.7 v4(57.12,128.63) 57.62,128.13 CG6592.2 ; CG6790.2 30.61,67.59 v4(30.93,67.28) ; CG6688.2 14.88,72.92 v4(14.87,72.93) ; v4(54.12,127.88) 54.13,127.88 CG6572.2 CG6574.2 ; v18(108.4,68.65) 108.4,68.68 v5(108.78,69.05) ; CG6632.2 4.2,125.85 v4(4.38,125.67) ; v4(52.32,64.28) 52.31,64.26 CG6741.2 ; CG6657.2 13.31,124.23 v4(13.37,124.17) ; UD8.D8 102.8,68.74 v5(102.49,69.05) ; CG6598.2 4.38,113.25 v4(4.38,113.83) 3.98,114.24 CG6613.2 ; CG6661.2 8.27,132.14 CG6637.2 8.26,131.79 v4(8.13,131.66) 7.87,131.41 CG6660.2 CG6648.2 7.66,132.13 v4(7.38,132.41) ; CG6643.2 3.66,124.13 v4(3.63,124.17) ; v5(94.66,40.12) 95.02,40.48 95.65,40.48 95.81,40.32 96.11,40.32 96.22,40.22 96.33,40.22 96.59,39.96 96.59,39.85 v5(96.88,39.55) 97.07,39.36 v5(97.62,39.36) 97.62,39.84 98.4,40.63 ; CG6646.2 14.83,124.21 v4(14.87,124.17) ; v4(5.13,82.67) 5.05,82.75 CG6684.2 ; v4(31.68,75.52) 31.39,75.24 CG882.2 ; CG6559.2 49.59,129.34 v4(49.63,129.38) ; v4(54.12,137.62) 54.19,137.56 CG6584.2 ; CG775.2 15.65,97.48 v4(15.62,97.5) ; CG6769.2 36.83,67.93 v4(36.92,68.03) 37.23,68.33 CG6763.2 ; CG6706.2 11.73,99.9 v4(11.87,99.75) ; v4(45.58,63.53) 45.49,63.62 CG6742.2 ; CG6682.2 14.05,79.75 v4(14.12,79.67) 14.19,79.61 CG6671.2 ; CG6658.2 11.09,124.13 v4(11.12,124.17) ; CG6795.2 39.27,70.93 v4(39.17,71.02) ; v4(11.87,107.09) 11.96,107 CG6612.2 ; v4(6.63,124.17) 6.58,124.12 CG6655.2 ; CG776.2 5.05,99.83 v4(5.13,99.75) ; CG791.2 47.12,64.24 v4(47.08,64.28) ; CG841.2 39.7,69.24 v18(39.73,69.22) ; v5(53.22,152.24) 53.25,152.21 JEDP.6 ; CG784.2 8.4,97.78 v4(8.13,97.5) ; CG6666.2 11.97,72.83 v4(11.87,72.93) 12.03,73.08 CG6699.2 ; CG6702.2 12.75,92.38 v4(12.62,92.26) ; CG6712.2 13.52,89.86 v4(13.37,90.01) ; CG554.2 54.73,138.98 v4(54.87,139.12) ; v4(4.38,93.01) 4.29,93.09 CG6724.2 ; CG6563.2 48.55,130.55 v4(48.88,130.88) ; v4(57.12,134.62) 56.83,134.33 CG6589.2 ; v4(12.62,109.34) 12.5,109.46 CG6618.2 ; CG6557.2 39.6,130.05 v4(39.52,130.13) ; v4(37.27,126.38) 37.11,126.55 CG514.2 ; v4(55.32,73.27) 55.33,73.27 CG6739.2 ; v5(42.72,152.24) 42.75,152.21 JEDP.27 ; v4(29.43,63.53) 29.34,63.44 CG6786.2 ; CG6536.2 29.89,127.24 v4(29.78,127.13) ; v4(11.12,81.17) 11.06,81.11 CG6668.2 ; v4(11.12,107.09) 11.09,107.05 CG6626.2 ; v4(6.63,90.01) 6.58,89.96 CG6723.2 ; CG6690.2 7.01,73.31 v4(6.63,72.93) ; CG6703.2 3.53,89.91 v4(3.63,90.01) ; v4(6.63,74.43) 6.68,74.43 CG6670.2 ; CG6604.2 14.25,110.21 v4(14.12,110.09) 13.96,109.92 CG6627.2 ; CG6737.2 53.02,70.33 v4(53.07,70.27) ; CG878.2 37.19,75.26 v4(36.92,75.52) ; CG6594.2 12.72,114.49 v4(12.62,114.58) ; CG6697.2 15.7,73.6 v4(15.62,73.68) ; v4(4.38,91.51) 4.26,91.62 CG6708.2 ; CG6796.2 31.33,71.37 v4(30.93,71.77) 30.58,72.12 CG6783.2 ; v4(47.83,75.52) 47.52,75.22 CG835.2 ; v4(12.62,80.42) 12.21,80.01 CG6693.2 ; CG6725.2 3.47,99.91 v4(3.63,99.75) ; CG6689.2 3.2,80.1 v4(2.88,80.42) ; CG621.2 15.69,109.4 v4(15.62,109.34) ; UE1.8 127.4,20.08 127.66,19.81 127.66,19.47 v18(128.28,18.85) ; CG6766.2 39.72,65.31 v4(39.8,65.39) ; v4(14.12,130.91) 14.05,130.99 CG6650.2 ; v4(8.13,75.18) 8,75.05 CG6681.2 ; v4(53.82,67.28) 53.99,67.11 CG6740.2 ; v1(97.2,65.45) 96.45,65.45 v5(96.11,65.79) ; JEDP.41 56.65,151.35 56.62,151.37 v5(56.62,152.24) ; JEDP.12 50.25,152.21 v5(50.22,152.24) ; CG6653.2 12.56,126.48 v4(12.62,126.42) ; CG6713.2 12.85,97.73 v4(12.62,97.5) ; JEDP.42 35.32,151.35 v5(34.67,151.35) ; CG6685.2 15.6,75.15 v4(15.62,75.18) ; 98.4,40.63 98.36,40.63 97.24,41.75 96.72,41.75 96.23,41.25 v5(96.16,41.25) ; 98.4,40.63 v5(98.46,40.63) ; v4(47.08,73.27) 46.73,73.62 CG792.2 ; v4(11.12,74.43) 10.95,74.6 CG6686.2 ; v4(14.87,133.91) 14.71,133.75 CG6663.2 ; CG6581.2 47.75,135 v4(47.38,135.37) ; CG6748.2 53.02,67.97 v4(53.07,68.03) ; CG6695.2 3.53,82.77 v4(3.63,82.67) ; v4(8.13,80.42) 8.13,80.43 CG6698.2 ; v4(31.68,62.78) 31.94,63.04 CG6793.2 ; CG6765.2 31.69,68.01 v4(31.68,68.03) ; v4(15.62,80.42) 15.66,80.46 CG6817.2 ; CG6654.2 4.99,124.03 v4(5.13,124.17) ; CG6754.2 55.43,66.42 v4(55.32,66.53) ; v4(47.38,127.13) 47.32,127.07 CG6569.2 ; CG6571.2 55.22,130.53 v4(55.62,130.13) ; v4(47.83,68.03) 47.31,68.54 CG796.2 ; CG676.2 15.78,131.51 v4(15.62,131.66) ; v4(14.87,99.75) 14.83,99.79 CG779.2 ; CG6715.2 14.96,89.92 v4(14.87,90.01) ; v4(50.38,127.88) 50.42,127.83 CG6560.2 ; CG6547.2 30.33,126.18 v4(30.53,126.38) ; CG6645.2 15.76,124.78 v4(15.62,124.92) ; CG772.2 7.66,91.79 v4(7.38,91.51) ; CG6683.2 6.26,75.55 v4(5.88,75.18) 5.81,75.24 CG6675.2 ; v4(14.87,107.09) 15.01,106.95 CG6625.2 ; v4(29.43,74.77) 29.28,74.92 CG6770.2 ; v4(4.38,127.17) 4.29,127.25 CG6642.2 ; CG6710.2 11.91,89.97 v4(11.87,90.01) ; CG6784.2 29.42,73.27 v4(29.43,73.27) ; CG6700.2 7.03,80.77 v4(6.63,81.17) ; CG6585.2 CG6579.2 49.68,136.18 v4(49.63,136.12) ; CG6696.2 7.07,82.23 v4(6.63,82.67) ; CG6749.2 53.54,72.99 v4(53.82,73.27) ; CG6821.2 3.32,74.73 v4(2.88,75.18) 3.19,75.49 CG7083.2 ; v4(11.12,133.91) 11.34,133.7 CG6649.2 ; CG6596.2 4.41,110.05 v4(4.38,110.09) 4.05,109.76 4.05,109.74 CG6599.2 ; CG6704.2 11.09,89.97 v4(11.12,90.01) ; CG6764.2 37,70.2 v4(36.92,70.27) ; v4(45.58,65.03) 45.46,65.14 CG6730.2 ; v4(47.08,67.28) 46.82,67.53 CG6755.2 ; CG6641.2 14.12,126.84 v4(14.12,127.17) 14.12,127.47 CG6652.2 ; CG6823.2 3.26,91.87 v4(2.88,92.26) 2.93,92.31 CG778.2 ; v4(36.17,64.28) 35.91,64.01 CG6768.2 ; v4(54.87,133.87) 54.75,133.87 54.42,134.2 CG6570.2 ; v4(53.82,64.28) 54.17,63.93 CG785.1 ; CG6797.2 32.56,64.14 v4(32.43,64.28) ; v4(8.13,114.58) 8.06,114.65 CG6602.2 ; CG6664.2 15.67,133.21 v4(15.62,133.16) ; CG6738.2 55.67,63.19 v4(55.32,63.53) 55.6,63.81 CG6726.2 ; v4(7.38,125.67) 7.14,125.43 CG6656.2 ; CG6672.2 4.38,74.42 v4(4.38,74.43) ; CG6716.2 4.51,96.89 v4(4.38,96.75) 4.23,96.61 CG768.2 ; v4(29.43,71.77) 29.39,71.81 CG6771.2 ; v4(32.43,74.02) 32.48,73.97 CG6779.2 ; v4(6.63,108.59) 7,108.96 CG6624.2 ; v4(4.38,75.93) 4.48,75.82 CG6669.2 ; v4(4.38,130.91) 4.23,130.77 CG6665.2 ; CG6729.2 45.49,67.36 v4(45.58,67.28) ; CG6762.2 38.06,75.16 v4(38.42,75.52) ; v4(13.37,107.09) 13.49,106.97 CG6603.2 ; CG6549.2 36.93,135.78 v4(37.27,136.12) 37.45,136.3 CG6546.2 ; UE1.47 124.44,26.88 v18(124.27,27.05) ; CG6747.2 52.19,74.16 v4(52.32,74.02) 52.73,73.62 CG6743.2 ; CG6565.2 47,135 v4(47.38,134.62) ; v18(103.6,65.45) v5(104.12,65.45) ; CG6545.2 29.85,130.05 v4(29.78,130.13) ; v4(53.07,62.78) 53.09,62.79 CG6736.2 ; CG6788.2 29.27,67.43 v4(29.43,67.28) ; v4(47.38,130.88) 47.7,130.55 CG6583.2 ; v4(38.02,130.88) 37.73,130.58 CG6554.2 ; v4(45.58,73.27) 45.44,73.14 CG6731.2 ; CG6732.2 54.64,62.72 v4(54.57,62.78) ; CG6607.2 4.96,106.92 v4(5.13,107.09) ; CG6757.2 48.26,70.71 v4(47.83,70.27) 47.68,70.13 CG6761.2 ; v4(14.12,113.83) 14.05,113.91 CG6609.2 ; CG6622.2 7.45,116.91 v4(7.38,116.83) ; v4(7.38,72.93) 7.52,72.78 CG6673.2 ; v4(39.17,63.53) 39.26,63.44 CG6767.2 ; CG6662.2 13.31,133.85 v4(13.37,133.91) ; UD5.T1 v4(114,58.42) ; UD6.E1 103.6,67.88 v5(103.25,68.23) ; CG6551.2 39.83,131.13 39.57,130.88 v4(39.52,130.88) ; CG6644.2 11.47,125.32 v4(11.12,125.67) ; CG6751.2 55.61,72.06 v4(55.32,71.77) ; CG6630.2 8.1,126.39 v4(8.13,126.42) ; v5(94.66,42.32) 94.66,42.33 94.04,42.95 94.04,43.65 93.92,43.78 93.92,44.04 91.9,46.07 v18(91.14,46.07) v18(86.44,46.07) 85.47,46.07 84.96,46.57 v18(84.96,48.86) 84.96,51.02 85.6,51.65 v18(87.13,51.65) 89.73,51.65 90.3,51.08 v18(90.3,48.89) v5(94.66,44.52) ; v5(135.19,97.93) 135.33,97.79 135.33,97 RH186.2 ; CG6610.2 3.39,106.85 v4(3.63,107.09) ; v4(39.17,71.77) 39.39,71.55 CG6789.2 ; v4(5.13,90.01) 5.12,90 CG6707.2 ; v4(11.12,99.75) 11.13,99.76 CG6719.2 ; v4(37.27,129.38) 37.19,129.29 CG6524.2 ; CG6556.2 37.77,128.17 38.02,127.91 v4(38.02,127.88) ; v5(44.22,152.24) 44.25,152.21 JEDP.24 ; CG6753.2 48.78,64.07 v4(48.58,64.28) 48.43,64.43 CG6744.2 ; CG6677.2 11.07,72.87 v4(11.12,72.93) ; v4(47.08,74.02) 47.14,74.09 CG6733.2 ; CG674.2 15.69,126.48 v4(15.62,126.42) ; CG6597.2 5.75,109.46 v4(5.88,109.34) ; v4(55.62,127.88) 55.57,127.82 CG6593.2 CG555.2 ; CG769.2 15.75,92.38 v4(15.62,92.26) ; v4(54.87,136.12) 54.78,136.22 CG6582.2 ; CG6709.2 14.59,97.79 v4(14.12,98.25) ; CG6776.2 36.04,74.16 v4(36.17,74.02) ; v4(4.38,79.67) 4.04,79.34 CG723.2 ; CG6674.2 10.22,75.02 v4(10.37,75.18) ; v4(53.82,71.02) 54.05,71.25 CG6728.2 ; CG6544.2 v4(33.6,127.9) ; v4(29.43,65.03) 29.36,64.96 CG6787.2 ; CG6568.2 47.28,128.53 v4(47.38,128.63) ; v4(11.12,91.51) 11.4,91.23 CG6718.2 ; v4(36.92,72.52) 36.87,72.58 CG6792.2 ; v4(7.38,124.17) 7.39,124.15 CG6633.2 ; CG777.2 15.73,99.11 v4(15.62,99) ; v5(54.72,152.24) 54.75,152.21 JEDP.3 ; v4(29.43,66.53) 29.39,66.49 CG6774.2 ; v4(30.93,73.27) 30.87,73.33 CG6773.2 ; CG6548.2 37.34,133.94 v4(37.27,133.87) ; v4(7.38,99.75) 7.45,99.83 CG782.2 ; v4(55.32,71.02) 55.35,71 CG6752.2 CG6727.2 ; CG624.2 15.71,114.49 v4(15.62,114.58) ; CG6540.2 39.58,127.07 v4(39.52,127.13) ; CG738.2 2.88,99 v4(2.88,99) ; CG783.2 10.61,92.02 v4(10.37,92.26) 10.71,92.59 CG6717.2 ; CG6711.2 13.65,97.98 v4(13.37,98.25) ; CG6758.2 46.14,62.59 v4(46.33,62.78) ; CG838.2 31.72,70.32 v4(31.68,70.27) ; CG6676.2 10.49,80.54 v4(10.37,80.42) ; v4(6.63,99.75) 6.77,99.9 CG780.2 ; v4(29.43,71.02) 29.4,71 CG6772.2 ; CG6722.2 14.19,93.07 v4(14.12,93.01) ; CG6538.2 32.68,127.97 v4(32.78,127.88) ; v4(12.62,131.66) 12.71,131.57 CG6638.2 ; v4(10.37,97.5) 10.1,97.78 CG6720.2 ; v4(39.17,74.77) 39.19,74.79 CG6794.2 ; CG771.2 CG773.2 10.88,98.01 v4(11.12,98.25) ; v4(49.63,133.87) 49.66,133.91 CG6580.2 ; CG6576.2 56.86,130.61 v4(57.12,130.88) ; v4(37.67,67.28) 37.46,67.49 CG6777.2 ; v4(8.13,109.34) 8.13,109.33 CG6611.2 ; CG6705.2 5.85,92.29 v4(5.88,92.26) ; CG6781.2 39.21,66.56 v4(39.17,66.53) ; v4(39.17,73.27) 39.28,73.38 CG6780.2 ; CG7082.2 14.57,76.37 v4(14.12,75.93) ; v4(5.88,97.5) 5.85,97.48 CG6714.2 ; CG6778.2 39.27,67.38 v4(39.17,67.28) ; JEDP.16 v5(48.25,152.23) ; v18(59.75,90.07) 58.29,90.07 57.85,89.63 v18(57.85,88.86) v18(57.85,87.02) 57.85,86.13 58.1,85.88 v18(59.5,85.88) v18(62.93,85.88) 63.56,85.88 63.82,86.13 v18(63.82,88.1) 63.82,89.75 63.5,90.07 v18(62.1,90.07) v18(59.75,90.07) ; v18(68.07,148.3) v18(66.93,148.3) 66.23,148.3 v18(65.85,147.92) v18(65.85,146.78) v18(65.85,145.76) 65.85,145.25 v18(66.1,145) v18(67.37,145) v18(68.58,145) v18(69.28,145.7) v18(71.06,145.7) 71.37,146.01 v18(71.37,146.78) 71.37,147.35 v18(71.09,147.63) 70.8,147.92 v18(70.36,147.92) v18(69.15,147.92) 68.77,148.3 v18(68.07,148.3)
  BOTTOM w0.305: v4(11.12,116.83) 11.07,116.89 CG6606.2 ; CH190.2 108.69,35.23 CH186.2 ; v4(11.87,82.67) 12.12,82.92 QG4.3 ; v4(5.13,116.83) 5.05,116.91 CG6620.2 ; CG6667.2 11.34,82.46 v4(11.12,82.67) ; v4(11.87,116.83) 12.1,117.06 CG6621.2 ; CG6617.2 3.53,116.93 v4(3.63,116.83) ; CG6600.2 7.45,107.01 v4(7.38,107.09) ; v4(13.37,116.83) 13.59,117.05 CG6608.2 ; CG6595.2 15.07,117.03 v4(14.87,116.83) ; v4(5.88,114.58) 5.85,114.56 CG6601.2 ; CG6605.2 6.39,117.07 v4(6.63,116.83)
  BOTTOM w0.356: v5(97.79,107.6) 97.76,107.62 CH105.2 ; v5(121.54,58.19) 121.06,58.67 CD311.2 ; CH201.2 12.7,16.93 v5(12.38,17.25) ; CH106.2 99.73,105.27 v5(99.76,105.25)
  BOTTOM w0.381: CH107.2 100.61,103.88 100.39,103.67 ; RV17.2 120.82,142.5 v5(120.15,143.16) ; CH120.2 98.81,87.04 v5(98.32,87.04) ; v4(45.58,71.02) 45.93,71.38 CG6756.2 ; CH190.2 108.69,34.38 v5(108.83,34.24) ; CH126.2 101.7,90.48 v5(101.2,90.99) ; CH182.2 96.1,26.23 96.46,25.86 97.07,25.86 v5(97.4,25.54) ; v5(111.13,37.93) 112.28,37.93 CH192.2 ; CH180.2 104.83,41.56 v5(104.83,41.71) ; v5(99.11,89.5) 99.45,89.5 CH127.2 ; CH188.2 106.94,34.29 v5(106.74,34.09) ; RH11.2 116.66,24.67 v5(116.78,24.78) ; CH121.2 98.14,86.12 v5(97.44,86.12) ; CH176.2 99.37,27.03 v5(99.4,27.06) 99.42,27.08 RH28.2 99.98,27.08 RH1601.2 ; v5(124.9,92.31) 124.95,92.26 CH118.2 ; CH181.2 107.47,41.72 v5(107.38,41.8) ; RH14.2 94.31,34.65 95.16,33.8 v5(95.16,33.8) ; CH233.2 100.49,29.13 100.13,28.76 v5(100.13,28.72) ; CH82.2 v5(117.13,49.18)
  BOTTOM w0.406: UH3.3 v5(16.46,15.19) ; JIO1.B10 5.25,6.36 4.65,5.76 v5(4.65,5.64) ; v5(11.3,15.01) 10.98,15.34 JIO1.G1
  BOTTOM w0.508: RH581.2 94.17,48.15 v5(93.69,48.63) ; CD278.2 CD298.2 125.72,73.06 v5(126.19,72.6) ; PCV169.2 79.38,82.24 v5(79.38,81.05) ; v5(42.46,8.19) 42.74,8.47 PR507.2 PC511.2 ; CD284.2 120.42,58.36 v5(120.77,58.01) ; CG648.2 v4(3.15,120.3) ; RH214.2 94,23.08 94.11,23.08 94.42,23.4 v5(94.42,23.52) ; v5(99.76,95.01) 99.8,94.97 CH102.2 ; PRB18.2 v5(38.6,14.47) ; PCZ47.2 126.16,126.43 v5(126.15,126.44) ; PCZ73.1 v5(92.34,136.68) 92.89,136.68 CT99.2 ; v5(113.47,30.7) 113.7,30.92 CH46.2 ; v18(116.07,58.34) 117.14,58.34 CD366.2 v5(117.88,58.36) ; v5(92.53,36.93) 92.53,36.61 92.43,36.52 92.43,36.44 CM30.2 ; PCB23.2 39.56,18.13 v5(39.37,17.93) ; CU26.2 86.98,12.68 v4(86.93,12.73) ; PCZ23.2 145.29,121.57 v5(145.54,121.31) ; v18(50.18,14.89) 50.99,14.89 PCB33.2 ; PCA1.2 140.46,98.78 v5(139.85,99.39) ; PCZ110.2 v5(89.52,132.31) ; PCV19.2 72.87,27.16 v5(72.64,27.38) ; v5(13.84,20.67) 14.49,20.02 SW1.1 ; v4(27.37,102.01) 27.14,101.78 CG6887.2 ; v4(2.88,116.08) 2.92,116.04 CG576.1 ; v5(72.64,30.43) 72.48,30.27 PCV18.1 ; PCZ246.2 141.76,89.15 v5(141.76,90.53) ; PCZ106.1 134.04,133.14 134.23,133.33 134.85,133.33 v5(134.89,133.29) ; v4(58.99,125.69) 59.01,125.68 CG521.2 ; v5(136.39,13.1) 136,12.71 C641.2 ; RH199.2 12.59,15.39 11.68,15.39 v5(11.3,15.01) ; v5(102.17,74.83) 102.73,74.27 CD353.2 ; PCB22.1 v5(39.37,17.17) ; v5(89.73,50.76) 89.44,51.05 CH47.2 ; PRB36.2 v5(39.69,13.43) ; CG552.2 56.3,139.2 v4(56.37,139.12) ; v5(46.04,23.71) 45.69,23.36 PCB32.2 ; PCB21.2 v5(39.05,16.09) ; v4(9.59,38.01) v18(10.54,38.01) ; PCZ128.2 v5(121.69,129.76) ; CE27.2 10.16,20.16 v5(10.73,20.73) ; CD357.2 CD358.2 98.92,72.62 98.92,72.62 v5(98.92,72.53) ; PCM15.2 v5(151.07,61.88) ; v4(27.24,107.09) 27.21,107.12 CG6888.2 ; JRTC1.2 16.48,13.78 v5(17.02,14.32) ; PCZ130.2 v5(128.21,126.55) ; CT114.2 94.59,15.62 v4(94.81,15.84) ; v5(117.59,92.3) 118.2,92.3 CH119.2 ; CG645.2 v4(4.38,120.3) ; CH45.2 117.64,30.38 v5(117.53,30.27) ; C2.2 CT117.2 96.76,22.11 v5(96.87,22.22) ; PCZ99.2 107.92,126.27 v5(107.29,126.27) ; PRV26.1 73.97,30.62 v5(74.17,30.43) ; v5(99.75,103.65) 100.37,103.65 100.39,103.67 ; JTOBII.1 v5(143.74,142.31) ; YE1.4 v5(130.23,23.47) ; v5(115.76,92.26) 116.37,92.26 CH122.2 ; PCZ129.2 v5(124.13,123.7) ; PRB42.2 v5(50.86,19.9)
  vias: v1(1.7,32.29) v1(1.7,31.4) v1(1.7,30.57) v1(1.7,29.81) v1(1.7,28.16) v1(1.89,53.3) v1(1.89,51.53) v1(1.89,50.57) v1(1.91,48.87) v1(2.41,132.74) v1(2.41,132.04) v1(2.41,131.09) v1(2.54,133.57) v1(2.53,23.04) v1(2.46,14.67) v1(2.6,134.33) v1(2.64,7.58) v1(2.73,18.06) v1(2.83,62.58) v1(2.88,133.16) v1(2.88,131.66) v1(2.88,124.92) v1(2.88,114.58) v1(2.88,109.34) v1(2.88,107.84) v1(2.88,97.5) v1(2.88,90.76) v1(2.97,24.1) v1(3.11,134.33) v1(3.63,133.91) v1(3.63,72.93) v1(3.75,51.18) v1(3.81,48.53) v1(3.76,9.38) v1(3.91,50.24) v1(4,134.33) v1(4.1,136.41) v1(4.27,25.94) v1(4.45,130.33) v1(4.38,115.33) v1(4.38,108.59) v1(4.38,98.25) v1(4.38,81.17) v1(4.64,134.33) v1(4.58,3.75) v1(4.6,3.16) v1(4.75,54.19) v1(4.94,51.29) v1(5.03,60.21) v1(5.13,133.91) v1(5.13,132.41) v1(5.13,115.33) v1(5.13,108.59) v1(5.13,98.25) v1(5.13,91.51) v1(5.13,81.17) v1(5.13,74.43) v1(5.13,72.93) v1(5.37,24.1) v1(5.52,134.33) v1(5.61,136.41) v1(5.74,2.76) v1(5.88,126.42) v1(5.88,80.42) v1(6.29,134.33) v1(6.63,133.91) v1(6.63,132.41) v1(6.63,125.67) v1(6.63,115.33) v1(6.63,107.09) v1(6.63,98.25) v1(6.63,91.51) v1(6.67,25.94) v1(6.87,85.27) v1(6.92,25.06) v1(6.9,23.19) v1(7.15,62.33) v1(7.18,40.3) v1(7.38,133.91) v1(7.38,115.33) v1(7.38,108.59) v1(7.38,98.25) v1(7.38,90.01) v1(7.38,82.67) v1(7.38,81.17) v1(7.38,74.43) v1(7.37,4.98) v1(7.45,129.44) v1(7.45,128.22) v1(7.73,50.6) v1(7.7,23.14) v1(7.99,3.46) v1(8.13,92.26) v1(8.53,85.26) v1(8.53,38.57) v1(8.79,17.71) v1(8.88,50.6) v1(9.14,6) v1(9.17,54.64) v1(9.4,19.93) v1(9.4,18.98) v1(9.86,119.47) v1(9.97,17.95) v1(10.37,131.66) v1(10.37,126.42) v1(10.37,114.58) v1(10.37,109.34) v1(10.59,119.47) v1(10.58,54.18) v1(11.12,115.33) v1(11.12,108.59) v1(11.13,85.26) v1(11.87,125.67) v1(11.87,124.17) v1(11.87,115.33) v1(11.87,108.59) v1(11.87,98.25) v1(11.87,91.51) v1(11.87,81.17) v1(11.87,74.43) v1(12.52,85.18) v1(12.62,75.18) v1(13.37,125.67) v1(13.37,115.33) v1(13.37,108.59) v1(13.37,99.75) v1(13.37,91.51) v1(13.37,82.67) v1(13.37,81.17) v1(13.37,74.43) v1(13.84,85.18) v1(14.12,125.67) v1(14.12,115.33) v1(14.12,108.59) v1(14.12,96.75) v1(14.12,91.51) v1(14.12,81.17) v1(14.12,74.43) v1(14.87,82.67) v1(15.38,85.18) v1(15.62,116.08) v1(15.62,107.84) v1(15.62,90.76) v1(15.62,81.92) v1(15.82,29.77) v1(16.13,133.89) v1(16.16,132.41) v1(16.76,41.63) v1(17.56,40.44) v1(17.7,106.89) v1(17.75,133.19) v1(18.54,29.19) v1(19,35.97) v1(19.08,39) v1(20.22,35.97) v1(20.32,28.72) v1(20.32,28.4) v1(20.56,134.51) v1(20.64,28.72) v1(20.64,28.4) v1(20.95,28.72) v1(20.95,28.4) v1(21.54,40.97) v1(21.49,27.46) v1(21.49,27.14) v1(21.55,38.67) v1(21.7,134.27) v1(21.84,35.84) v1(21.84,35.52) v1(22.16,35.84) v1(22.16,35.52) v1(22.48,35.84) v1(22.48,35.52) v1(23,86.29) v1(23.25,104.85) v1(23.25,100.65) v1(23.43,123.1) v1(23.95,116.05) v1(23.95,114.65) v1(23.95,95.75) v1(23.95,89.45) v1(24.26,123.1) v1(24.31,116.44) v1(24.65,105.55) v1(24.65,102.75) v1(24.84,112.55) v1(24.94,119.28) v1(24.99,103.7) v1(24.97,93.94) v1(24.98,13.2) v1(25.15,123.1) v1(25.35,116.75) v1(25.35,112.55) v1(25.35,103.45) v1(25.35,97.85) v1(25.35,93.65) v1(25.64,117.78) v1(25.59,42.42) v1(25.69,113.63) v1(25.68,89.05) v1(26.04,123.1) v1(26.05,118.15) v1(26.09,135.36) v1(26.12,112.32) v1(26.29,64.62) v1(26.28,63.4) v1(26.28,62.19) v1(26.37,106.61) v1(26.43,105.88) v1(26.38,103.16) v1(26.37,100.27) v1(26.4,96.83) v1(26.4,95.44) v1(26.75,114.65) v1(26.75,112.55) v1(26.75,110.45) v1(26.75,106.25) v1(26.75,104.15) v1(26.75,87.35) v1(26.77,82.59) v1(26.86,137.32) v1(26.95,136.09) v1(26.95,134.88) v1(27.04,86.3) v1(26.99,64.3) v1(27.13,107.28) v1(27.13,105.87) v1(27.11,103.15) v1(27.1,100.28) v1(27.11,94.66) v1(27.08,92.51) v1(27.11,87) v1(27.23,84.85) v1(27.28,110.45) v1(27.45,118.15) v1(27.45,117.45) v1(27.45,109.05) v1(27.45,86.65) v1(27.45,83.85) v1(27.53,108.05) v1(27.7,105.96) v1(27.75,100.99) v1(27.74,86.32) v1(27.71,84.89) v1(27.77,119.23) v1(27.79,112.69) v1(27.76,103.77) v1(27.81,97.54) v1(27.8,95.44) v1(27.8,94.66) v1(27.8,93.35) v1(27.81,88.42) v1(28.15,104.15) v1(28.15,95.75) v1(28.15,91.55) v1(28.13,87.91) v1(28.51,107.29) v1(28.5,103.09) v1(28.47,102.39) v1(28.47,100.27) v1(28.5,97.55) v1(28.5,95.44) v1(28.49,94.64) v1(28.85,118.85) v1(28.85,116.75) v1(28.85,109.05) v1(28.77,104.43) v1(28.85,96.45) v1(28.85,94.35) v1(28.84,93.53) v1(28.93,89.46) v1(29.1,112.17) v1(29.15,107.98) v1(29.12,88.13) v1(29.27,116.04) v1(29.55,118.15) v1(29.55,116.75) v1(29.55,115.35) v1(29.55,113.95) v1(29.55,110.45) v1(29.55,108.35) v1(29.55,106.25) v1(29.55,104.15) v1(29.55,99.95) v1(29.55,91.55) v1(29.55,88.05) v1(29.55,86.65) v1(29.78,138.37) v1(29.78,136.87) v1(29.78,135.37) v1(29.78,130.88) v1(29.78,128.63) v1(29.78,87.28) v1(30,116.41) v1(29.97,115.72) v1(30.18,75.52) v1(30.18,62.78) v1(30.25,124.24) v1(30.53,139.12) v1(30.95,86.65) v1(30.93,74.02) v1(30.93,71.02) v1(30.93,66.53) v1(30.93,65.03) v1(30.92,4.98) v1(31.28,137.62) v1(31.28,136.87) v1(31.28,135.37) v1(31.28,134.62) v1(31.28,130.88) v1(31.28,130.13) v1(31.28,128.63) v1(31.28,127.88) v1(31.27,86.27) v1(31.37,116.04) v1(31.48,88.74) v1(31.65,118.15) v1(31.65,116.75) v1(31.65,115.35) v1(31.65,112.55) v1(31.65,89.45) v1(31.68,72.52) v1(31.68,65.78) v1(32.03,139.12) v1(32.03,136.12) v1(32.03,133.87) v1(32.03,131.63) v1(32.03,129.38) v1(32.03,126.38) v1(32.04,86.29) v1(32.09,85.59) v1(32.35,118.15) v1(32.52,145.35) v1(32.72,87) v1(32.66,86.3) v1(32.78,137.62) v1(33.06,3.19) v1(33.15,42.42) v1(33.57,88.75) v1(33.75,117.46) v1(33.75,116.12) v1(33.73,114.63) v1(33.75,89.45) v1(33.75,88.05) v1(33.75,86.65) v1(33.97,113.49) v1(34.1,87.05) v1(34.45,88.75) v1(34.45,87.35) v1(34.7,116.42) v1(34.79,115.03) v1(34.8,114.28) v1(34.89,117.07) v1(34.87,85.59) v1(35.5,115.69) v1(35.57,86.29) v1(35.85,112.55) v1(35.85,89.45) v1(36.18,115.72) v1(36.18,115.01) v1(36.52,127.88) v1(36.9,77.66) v1(36.92,65.78) v1(36.92,62.78) v1(37.25,116.75) v1(37.27,139.12) v1(37.27,131.63) v1(37.68,145.58) v1(37.71,86.98) v1(37.67,74.02) v1(37.67,73.27) v1(37.67,71.77) v1(37.67,71.02) v1(37.67,66.53) v1(37.67,65.03) v1(37.67,64.28) v1(37.8,88.67) v1(37.95,113.95) v1(37.95,112.55) v1(37.95,88.05) v1(38.02,137.62) v1(38.02,136.87) v1(38.02,135.37) v1(38.02,134.62) v1(38.02,130.13) v1(38.02,128.63) v1(38.06,85.96) v1(38.25,84.86) v1(38.42,62.78) v1(38.77,139.12) v1(39.01,145.57) v1(39.17,23.36) v1(39.52,138.37) v1(39.52,136.87) v1(39.52,135.37) v1(39.52,134.62) v1(39.5,22.84) v1(39.5,21.36) v1(39.66,23.33) v1(40.05,112.55) v1(40.05,89.45) v1(40.05,88.05) v1(40.05,86.65) v1(40.05,85.25) v1(40.05,83.85) v1(40.2,88.6) v1(40.64,142.38) v1(40.75,101.35) v1(40.75,85.95) v1(40.75,83.15) v1(40.71,42.42) v1(41.02,114.3) v1(41.19,145.72) v1(41.45,113.25) v1(41.45,100.65) v1(41.53,147.54) v1(41.45,84.55) v1(41.83,141.46) v1(41.83,88.5) v1(41.8,87.06) v1(41.9,85.54) v1(42.13,131.58) v1(42.13,130.84) v1(42.15,113.95) v1(42.15,88.05) v1(42.15,86.65) v1(42.15,85.25) v1(42.15,83.85) v1(42.46,87.71) v1(42.51,86.29) v1(42.61,147.28) v1(42.85,83.85) v1(43.13,85.59) v1(43.19,115.04) v1(43.18,114.29) v1(43.55,115.35) v1(43.55,113.25) v1(43.55,83.15) v1(43.8,116.42) v1(44.09,88.74) v1(44.15,64.87) v1(44.15,63.64) v1(44.15,62.42) v1(44.2,147.41) v1(44.25,113.95) v1(44.25,83.85) v1(44.64,147.41) v1(44.58,113.6) v1(45.03,77.66) v1(45.35,115.03) v1(45.58,71.77) v1(45.58,66.53) v1(46.08,114.33) v1(46.35,118.15) v1(46.33,75.52) v1(46.91,60.29) v1(47.09,123.42) v1(47.08,71.77) v1(47.08,71.02) v1(47.08,66.53) v1(47.08,65.03) v1(47.38,138.37) v1(47.38,136.87) v1(47.38,130.13) v1(47.75,118.85) v1(47.83,72.52) v1(47.83,65.78) v1(47.83,62.78) v1(47.89,123.42) v1(48.04,114.98) v1(48.13,139.12) v1(48.13,126.38) v1(48.11,117.08) v1(48.06,116.4) v1(48.06,115.67) v1(48.06,114.3) v1(48.17,60.29) v1(48.33,42.42) v1(48.45,113.95) v1(48.84,117.1) v1(48.79,115.74) v1(48.88,137.62) v1(48.88,136.87) v1(48.88,135.37) v1(48.88,134.62) v1(48.88,130.13) v1(48.88,128.63) v1(48.88,127.88) v1(49.38,60.29) v1(49.63,139.12) v1(49.63,126.38) v1(49.85,114.65) v1(49.85,88.05) v1(50.11,117.08) v1(50.55,116.75) v1(50.55,115.35) v1(50.55,89.45) v1(50.55,88.05) v1(50.55,86.65) v1(50.6,60.29) v1(50.93,136.08) v1(50.93,117.08) v1(51.25,116.05) v1(51.25,88.75) v1(51.57,118.44) v1(51.57,117.21) v1(51.95,116.75) v1(52.65,118.15) v1(52.65,106.25) v1(52.65,104.15) v1(52.65,102.05) v1(52.65,99.95) v1(52.65,99.25) v1(52.65,97.85) v1(52.65,95.75) v1(52.65,93.65) v1(52.65,91.55) v1(52.65,32.54) v1(53.07,72.52) v1(53.07,65.78) v1(53.35,118.85) v1(53.35,104.85) v1(53.35,102.75) v1(53.35,100.65) v1(53.57,136.13) v1(53.82,74.02) v1(53.82,71.77) v1(53.82,66.53) v1(53.82,65.03) v1(53.76,26.7) v1(54.05,106.25) v1(54.05,105.55) v1(54.05,102.05) v1(54.05,99.95) v1(54.05,97.85) v1(54.05,95.05) v1(54.05,93.65) v1(54.05,92.95) v1(54.05,95.75) v1(54.05,91.55) v1(54.29,24.22) v1(54.29,23.9) v1(54.29,23.59) v1(54.29,23.27) v1(54.42,105.88) v1(54.42,101.75) v1(54.42,96.8) v1(54.42,96.1) v1(54.57,75.52) v1(54.64,27.82) v1(54.64,27.41) v1(54.61,26.95) v1(54.64,26.57) v1(54.74,95.85) v1(54.75,86.65) v1(54.75,85.25) v1(54.87,131.63) v1(54.87,126.38) v1(54.86,104.17) v1(55.02,27.79) v1(55.02,27.38) v1(55.02,26.95) v1(55.04,26.57) v1(55.12,96.87) v1(55.12,96.1) v1(55.12,94.07) v1(55.32,74.77) v1(55.32,67.28) v1(55.32,65.03) v1(55.45,106.25) v1(55.45,104.15) v1(55.45,102.05) v1(55.45,99.95) v1(55.45,97.85) v1(55.45,95.75) v1(55.45,87.35) v1(55.62,137.62) v1(55.62,136.87) v1(55.62,135.37) v1(55.63,27.59) v1(55.81,101.57) v1(55.82,96.8) v1(55.88,95.98) v1(56.01,42.42) v1(56.15,111.85) v1(56.15,109.75) v1(56.15,105.55) v1(56.15,101.35) v1(56.15,99.25) v1(56.15,97.15) v1(56.15,95.05) v1(56.15,92.95) v1(56.26,87.47) v1(56.37,126.38) v1(56.45,96.8) v1(56.85,109.75) v1(56.85,109.05) v1(56.85,106.95) v1(56.85,106.25) v1(56.85,105.55) v1(56.85,104.85) v1(56.85,104.15) v1(56.85,102.05) v1(56.85,101.35) v1(56.85,100.65) v1(56.85,99.95) v1(56.85,99.25) v1(56.85,98.55) v1(56.85,97.85) v1(56.85,97.15) v1(56.85,96.45) v1(56.85,95.75) v1(56.85,95.05) v1(56.85,94.35) v1(56.85,93.65) v1(56.85,92.95) v1(56.85,92.25) v1(57.12,138.37) v1(57.12,136.87) v1(57.12,135.37) v1(57.12,130.13) v1(57.12,127.13) v1(57.17,103.78) v1(57.17,103.17) v1(57.23,101) v1(57.21,88.45) v1(57.37,87.57) v1(57.55,106.51) v1(57.91,106.71) v1(57.89,105.27) v1(57.89,103.1) v1(57.89,92.59) v1(57.92,88.46) v1(57.91,84.86) v1(58.25,110.45) v1(58.25,104.15) v1(58.25,99.95) v1(58.25,97.85) v1(58.25,95.75) v1(58.25,93.65) v1(58.25,85.95) v1(58.41,37.33) v1(58.53,101.01) v1(58.58,105.24) v1(58.6,103.1) v1(58.6,95.3) v1(58.59,92.61) v1(58.61,88.48) v1(58.75,35.89) v1(59.04,34.98) v1(59.05,100.05) v1(59.19,104.49) v1(59.39,102.74) v1(59.63,136.79) v1(59.69,127.61) v1(60.25,100.59) v1(60.17,37.47) v1(60.45,123.04) v1(62.78,108.6) v1(62.78,107.57) v1(62.78,106.68) v1(62.78,105.64) v1(62.78,104.68) v1(62.79,103.62) v1(62.78,102.58) v1(62.94,29.8) v1(62.97,30.23) v1(63.42,30.25) v1(63.42,29.77) v1(63.45,29.36) v1(63.64,24.93) v1(63.69,141.71) v1(63.69,25.91) v1(63.76,42.42) v1(63.91,29.8) v1(63.91,29.39) v1(63.94,28.54) v1(64.1,117.57) v1(64.22,25.35) v1(64.34,130.33) v1(64.33,107.6) v1(64.33,105.69) v1(64.44,136.34) v1(64.39,103.66) v1(64.39,101.63) v1(64.49,29.68) v1(64.74,25.86) v1(64.72,24.89) v1(65.05,135.21) v1(65.74,130.33) v1(65.98,109.57) v1(65.98,108.55) v1(66.03,107.6) v1(65.98,106.64) v1(65.98,105.63) v1(65.98,104.68) v1(65.98,103.66) v1(65.98,102.64) v1(66.74,130.51) v1(68.2,34.58) v1(68.19,30.7) v1(68.19,29.87) v1(68.19,29.05) v1(68.19,28.22) v1(68.19,27.4) v1(68.19,26.57) v1(68.19,25.75) v1(68.19,24.92) v1(68.19,24.09) v1(68.9,8.16) v1(68.9,6.63) v1(69.46,38.03) v1(69.46,37.45) v1(69.46,36.89) v1(70.03,38.03) v1(70.03,37.45) v1(70.03,36.89) v1(70.37,108.23) v1(71.31,42.42) v1(72.3,77.11) v1(72.42,6.75) v1(72.58,16.14) v1(72.96,134.76) v1(73.23,143.16) v1(73.23,142.27) v1(73.23,141.38) v1(73.41,16.14) v1(73.47,137.7) v1(73.47,137.12) v1(73.47,136.49) v1(73.47,135.79) v1(73.47,135.22) v1(74.28,16.09) v1(74.36,33.37) v1(74.49,135.66) v1(74.65,88.55) v1(74.76,143.92) v1(74.99,135.66) v1(75.42,133.39) v1(75.51,142.13) v1(75.51,141.49) v1(75.63,135.66) v1(75.69,33.37) v1(76.14,135.66) v1(76.54,143.92) v1(76.48,140.36) v1(76.69,140.95) v1(76.77,135.66) v1(77.34,135.66) v1(77.47,141.98) v1(77.47,37.37) v1(77.47,36.54) v1(77.6,139.41) v1(77.7,139.79) v1(77.66,138.52) v1(78.04,141.98) v1(78.16,151.54) v1(78.23,68.8) v1(78.38,141.06) v1(78.38,140.49) v1(78.38,139.92) v1(78.61,138.46) v1(78.74,139.35) v1(78.74,135.6) v1(79.06,139.47) v1(79.5,139.73) v1(79.82,138.27) v1(79.88,135.6) v1(80.14,139.73) v1(80.17,11.86) v1(80.45,135.6) v1(80.58,139.47) v1(80.58,78.89) v1(80.81,142.65) v1(80.9,40.86) v1(80.96,39.21) v1(81.28,59.36) v1(81.28,57.81) v1(81.6,135.54) v1(82.17,135.54) v1(82.48,150.33) v1(82.74,135.54) v1(82.74,132.18) v1(83.19,137.89) v1(83.17,17.37) v1(83.83,18.89) v1(84.52,138.39) v1(84.65,17.95) v1(84.77,141.8) v1(85.28,111.99) v1(85.76,139.7) v1(87.2,113.82) v1(87.44,75.15) v1(87.5,76.48) v1(87.5,75.85) v1(87.57,80.86) v1(87.57,80.16) v1(87.57,79.53) v1(87.57,78.77) v1(87.57,78.07) v1(87.57,77.24) v1(87.57,34.06) v1(88.01,81.69) v1(87.96,37.82) v1(88.13,113.82) v1(88.39,39.21) v1(88.46,14.89) v1(88.54,7.04) v1(88.57,29.15) v1(88.71,34.95) v1(88.84,147.98) v1(88.84,147.35) v1(88.82,21.01) v1(89.06,106.56) v1(89.81,6.76) v1(90.11,113.49) v1(90.17,44.4) v1(90.3,20.44) v1(90.55,106.31) v1(90.61,22.82) v1(90.79,142.55) v1(90.81,141.51) v1(90.81,140.62) v1(90.93,20.44) v1(91.5,113.4) v1(91.5,44.41) v1(91.69,139.47) v1(91.76,19.57) v1(91.88,44.1) v1(92.08,21.35) v1(92.2,142.27) v1(92.2,86.2) v1(92.58,143.16) v1(92.71,85.94) v1(92.84,113.43) v1(93.05,22.12) v1(93.09,87.47) v1(93.28,140.81) v1(93.79,51.4) v1(94.36,151.48) v1(94.36,86.07) v1(94.36,51.4) v1(95.06,51.4) v1(95.19,151.48) v1(95.17,62.23) v1(95.17,58.93) v1(95.44,40.03) v1(95.41,21.44) v1(95.63,51.4) v1(95.89,38.38) v1(95.89,31.9) v1(96.2,50.89) v1(96.2,35.52) v1(96.71,31.33) v1(96.94,144.33) v1(97.09,140.53) v1(97.22,102.9) v1(97.79,35.4) v1(97.85,33.94) v1(98.04,45.24) v1(98.26,144.19) v1(98.42,151.48) v1(98.42,109.18) v1(98.74,42.7) v1(98.87,33.87) v1(98.93,17.42) v1(99.12,41.75) v1(99.19,104.49) v1(99.25,151.48) v1(99.25,102.83) v1(99.38,44.35) v1(99.5,33.3) v1(99.69,106.83) v1(99.76,108.36) v1(99.89,41.75) v1(100.33,20.45) v1(101.49,136.11) v1(101.54,108.49) v1(101.56,134.84) v1(101.6,23.59) v1(102.3,111.09) v1(102.3,109.76) v1(104.08,50.38) v1(105.09,50.13) v1(105.32,115.2) v1(107.38,143.02) v1(107.63,45.24) v1(108.08,44.92) v1(108.33,142.97) v1(108.58,144.01) v1(109.22,44.73) v1(109.26,115.22) v1(109.63,141.82) v1(109.75,143.96) v1(110.49,30.44) v1(111.02,115.22) v1(111.24,41.15) v1(111.29,141.93) v1(111.58,44.35) v1(111.7,52.22) v1(111.76,49.68) v1(111.98,114.01) v1(111.95,52.73) v1(112.2,145.82) v1(112.84,42.51) v1(112.89,44.91) v1(113.08,142.5) v1(113.79,34.19) v1(113.86,35.14) v1(114.03,44.48) v1(114.87,52.48) v1(114.86,34.02) v1(115.25,53.56) v1(116.08,53.05) v1(116.52,52.48) v1(116.6,21.99) v1(116.74,142.47) v1(117.22,19.01) v1(117.63,28.67) v1(118.52,47.78) v1(118.75,35.91) v1(118.87,30.06) v1(118.87,25.94) v1(119,32.86) v1(119.09,49.16) v1(119.28,48.21) v1(119.38,46.48) v1(119.7,50.51) v1(119.95,140.22) v1(119.99,49.47) v1(120.08,50.51) v1(120.14,41.44) v1(120.64,41.99) v1(120.79,45.77) v1(121.17,114.84) v1(121.26,116.17) v1(121.28,20.09) v1(122.17,89.69) v1(122.17,89.05) v1(123,16.35) v1(123.06,88.99) v1(123.54,91.3) v1(123.9,71.05) v1(123.9,70.25) v1(123.9,68.65) v1(124.02,91.72) v1(124.33,16.35) v1(124.9,90.2) v1(124.9,89.56) v1(124.9,88.42) v1(125.79,91.66) v1(126.28,91.3) v1(126.75,91.66) v1(126.93,135.28) v1(127.64,91.66) v1(128.52,91.66) v1(129.02,91.95) v1(129.02,91.3) v1(129.43,86.09) v1(129.43,85.44) v1(129.43,84.79) v1(129.48,91.66) v1(130.43,91.66) v1(131.01,133.13) v1(131.38,92.29) v1(131.38,91.66) v1(131.56,36.64) v1(131.56,36.26) v1(131.56,35.88) v1(131.77,91.95) v1(131.88,36.64) v1(131.88,36.26) v1(131.88,35.88) v1(132.21,91.72) v1(132.19,36.64) v1(132.19,36.26) v1(132.19,35.88) v1(132.82,49.62) v1(133.1,91.72) v1(133.5,59.05) v1(134.62,51.69) v1(134.82,52.73) v1(135.09,47.45) v1(135.62,52.73) v1(135.65,51.67) v1(135.69,48.36) v1(136.41,49.42) v1(136.98,55.02) v1(137.22,141.32) v1(137.48,140.17) v1(139.14,54.45) v1(139.14,53.49) v1(139.14,52.61) v1(139.76,23.41) v1(139.89,139.79) v1(139.9,63.85) v1(140.93,54.83) v1(140.93,54.19) v1(140.93,53.56) v1(142.37,35.02) v1(142.75,25.49) v1(143,30.7) v1(143,24.98) v1(143.19,29.56) v1(143.32,31.71) v1(143.83,28.73) v1(144.02,24.6) v1(144.08,35.02) v1(144.15,32.54) v1(144.15,26.06) v1(144.78,35.97) v1(144.91,28.35) v1(145.35,32.67) v1(145.48,52.67) v1(145.8,52.67) v1(146.11,52.67) v1(146.43,52.67) v1(146.37,32.29) v1(146.49,25.11) v1(146.75,52.67) v1(146.81,25.55) v1(147.07,52.67) v1(147.38,52.67) v1(147.7,52.67) v1(148.02,52.67) v1(148.84,128.78) v1(150.72,46.7) v1(150.89,69.88) v3(2.41,126.01) v3(2.41,125.25) v3(2.41,124.49) v3(2.52,91.87) v3(2.53,91.14) v3(2.88,133.16) v3(2.88,131.66) v3(2.88,124.92) v3(2.88,114.58) v3(2.88,109.34) v3(2.88,107.84) v3(2.88,97.5) v3(2.88,90.76) v3(2.98,123.6) v3(3.24,132.04) v3(3.24,125.31) v3(3.24,109.69) v3(3.24,108.94) v3(3.24,108.23) v3(3.24,107.47) v3(3.25,92.6) v3(3.25,91.86) v3(3.24,90.39) v3(3.24,89.63) v3(3.27,132.78) v3(3.27,91.12) v3(3.63,133.91) v3(3.63,72.93) v3(3.75,51.18) v3(3.91,50.24) v3(4,133.57) v3(3.98,132.78) v3(4,125.31) v3(4,124.55) v3(4,109.69) v3(4,108.93) v3(4,108.23) v3(4,107.47) v3(4.04,92.64) v3(4.04,91.87) v3(4,91.15) v3(4,90.39) v3(4,89.63) v3(4.38,115.33) v3(4.38,108.59) v3(4.38,98.25) v3(4.38,81.17) v3(4.73,133.53) v3(4.75,54.19) v3(4.76,132.75) v3(4.76,124.55) v3(4.75,108.18) v3(4.76,107.47) v3(4.76,91.85) v3(4.78,91.13) v3(4.76,90.39) v3(4.76,89.56) v3(4.94,51.29) v3(5.13,133.91) v3(5.13,132.41) v3(5.13,115.33) v3(5.13,108.59) v3(5.13,98.25) v3(5.11,92.22) v3(5.13,91.51) v3(5.13,81.17) v3(5.13,74.43) v3(5.13,72.93) v3(5.16,80.47) v3(5.5,132.76) v3(5.52,132.04) v3(5.49,131.3) v3(5.46,126.14) v3(5.47,124.54) v3(5.51,108.94) v3(5.49,108.19) v3(5.47,107.46) v3(5.5,97.89) v3(5.51,91.86) v3(5.51,91.1) v3(5.52,90.39) v3(5.52,89.63) v3(5.46,76.35) v3(5.49,75.55) v3(5.88,126.42) v3(5.88,80.42) v3(6.24,133.52) v3(6.25,124.51) v3(6.24,91.86) v3(6.24,91.11) v3(6.22,90.39) v3(6.22,89.56) v3(6.28,132.8) v3(6.27,109.76) v3(6.28,108.94) v3(6.26,108.19) v3(6.28,107.46) v3(6.63,133.91) v3(6.63,132.41) v3(6.63,125.67) v3(6.63,115.33) v3(6.63,107.09) v3(6.63,98.25) v3(6.63,91.51) v3(6.99,133.51) v3(6.99,132.75) v3(6.99,124.5) v3(7.02,108.2) v3(6.99,107.47) v3(7,91.1) v3(7,90.41) v3(7.38,133.91) v3(7.38,115.33) v3(7.38,108.59) v3(7.38,98.25) v3(7.38,90.01) v3(7.38,82.67) v3(7.38,81.17) v3(7.38,74.43) v3(7.37,4.98) v3(7.45,129.44) v3(7.45,128.22) v3(7.75,124.55) v3(7.75,107.47) v3(7.75,91.15) v3(7.75,90.39) v3(7.73,50.6) v3(8.13,92.26) v3(8.46,113.5) v3(8.61,80.11) v3(8.88,50.6) v3(9.14,6) v3(9.17,54.64) v3(9.72,132.62) v3(9.78,80.83) v3(10.37,131.66) v3(10.37,126.42) v3(10.37,114.58) v3(10.37,109.34) v3(10.6,132.62) v3(10.58,54.18) v3(10.73,91.15) v3(10.73,90.39) v3(10.77,133.53) v3(10.79,124.61) v3(10.78,107.46) v3(10.77,82.29) v3(10.78,81.55) v3(10.77,74.04) v3(10.77,73.27) v3(11.12,115.33) v3(11.12,108.59) v3(11.5,133.51) v3(11.49,108.23) v3(11.49,107.47) v3(11.49,91.15) v3(11.49,90.39) v3(11.5,82.27) v3(11.49,81.56) v3(11.52,74.04) v3(11.49,73.31) v3(11.87,125.67) v3(11.87,124.17) v3(11.87,115.33) v3(11.87,108.59) v3(11.87,98.25) v3(11.87,91.51) v3(11.87,81.17) v3(11.87,74.43) v3(12.25,82.27) v3(12.21,74.79) v3(12.25,133.51) v3(12.29,108.97) v3(12.26,108.23) v3(12.26,107.47) v3(12.26,91.15) v3(12.26,90.39) v3(12.26,81.56) v3(12.26,80.8) v3(12.26,74.07) v3(12.26,73.31) v3(12.62,75.18) v3(12.7,123.66) v3(12.76,122.9) v3(13.01,133.52) v3(13.01,132.8) v3(12.98,108.95) v3(12.98,108.2) v3(13.02,107.47) v3(13.02,91.85) v3(13,91.1) v3(13.02,90.39) v3(13,82.27) v3(12.97,81.55) v3(13.02,80.8) v3(12.99,80.05) v3(12.98,74.79) v3(13.02,74.07) v3(13.02,73.31) v3(13.37,115.33) v3(13.37,108.59) v3(13.37,99.75) v3(13.37,91.51) v3(13.37,82.67) v3(13.37,81.17) v3(13.37,74.43) v3(13.73,133.52) v3(13.73,81.51) v3(13.74,75.57) v3(13.75,131.31) v3(13.75,107.43) v3(13.76,91.11) v3(13.75,90.35) v3(13.77,82.31) v3(13.76,74.03) v3(13.78,73.3) v3(14.12,125.67) v3(14.12,115.33) v3(14.12,108.59) v3(14.12,91.51) v3(14.12,81.17) v3(14.12,74.43) v3(14.49,133.52) v3(14.53,109.71) v3(14.52,108.95) v3(14.51,108.2) v3(14.48,107.47) v3(14.53,92.63) v3(14.52,91.87) v3(14.51,91.11) v3(14.5,90.41) v3(14.52,82.29) v3(14.49,81.51) v3(14.5,80.83) v3(14.51,80.07) v3(14.48,75.53) v3(14.49,74.82) v3(14.49,74.09) v3(14.48,73.31) v3(14.87,82.67) v3(15.24,132.04) v3(15.24,109.69) v3(15.24,108.23) v3(15.24,91.85) v3(15.24,90.39) v3(15.21,82.3) v3(15.24,81.56) v3(15.24,80.04) v3(15.24,75.53) v3(15.24,74.07) v3(15.24,73.31) v3(15.26,131.33) v3(15.27,126.8) v3(15.26,92.59) v3(15.25,91.1) v3(15.26,80.82) v3(15.29,74.81) v3(15.62,116.08) v3(15.62,107.84) v3(15.62,90.76) v3(15.62,81.92) v3(16,81.56) v3(16.02,80.85) v3(16.16,132.41) v3(16.19,130.9) v3(20.19,29.54) v3(20.19,29.1) v3(20.64,29.54) v3(20.64,29.1) v3(21.08,29.54) v3(21.08,29.1) v3(21.72,36.67) v3(21.72,36.22) v3(22.16,36.67) v3(22.16,36.22) v3(22.5,41.21) v3(22.52,40.17) v3(22.49,39.04) v3(22.61,36.67) v3(22.61,36.22) v3(23.25,104.85) v3(23.25,100.65) v3(23.39,40.1) v3(24.24,39.02) v3(24.31,116.44) v3(24.3,41.2) v3(24.28,40.07) v3(24.65,105.55) v3(24.65,102.75) v3(24.94,119.28) v3(24.97,93.94) v3(25.35,116.75) v3(25.64,117.78) v3(25.59,42.42) v3(25.68,89.05) v3(26.05,118.15) v3(26.12,112.32) v3(26.29,64.62) v3(26.28,63.4) v3(26.28,62.19) v3(26.37,100.27) v3(26.4,96.83) v3(26.4,95.44) v3(26.75,106.25) v3(26.77,82.59) v3(26.86,134.91) v3(26.99,64.3) v3(27.07,131.31) v3(27.1,100.28) v3(27.11,94.66) v3(27.08,92.51) v3(27.28,110.45) v3(27.45,83.85) v3(27.7,105.96) v3(27.74,86.32) v3(27.71,84.89) v3(27.77,119.23) v3(27.81,97.54) v3(27.8,95.44) v3(27.8,94.66) v3(27.8,93.35) v3(27.81,88.42) v3(28.13,87.91) v3(28.51,107.29) v3(28.5,97.55) v3(28.5,95.44) v3(28.49,94.64) v3(28.85,118.85) v3(28.85,116.75) v3(28.85,109.05) v3(28.85,94.35) v3(28.84,93.53) v3(28.93,89.46) v3(29.1,112.17) v3(29.12,88.13) v3(29.15,4.98) v3(29.55,115.35) v3(29.55,113.95) v3(29.78,138.37) v3(29.78,136.87) v3(29.78,135.37) v3(29.78,130.88) v3(29.78,128.63) v3(30.16,131.22) v3(30.16,130.52) v3(30.18,129.75) v3(30.18,129.01) v3(30.16,128.23) v3(30.16,127.48) v3(30.16,126.77) v3(30.18,75.52) v3(30.18,62.78) v3(30.53,139.12) v3(30.92,131.22) v3(30.87,130.51) v3(30.87,129.75) v3(30.92,129) v3(30.89,128.27) v3(30.92,127.53) v3(30.88,126.76) v3(30.92,126.01) v3(30.93,74.02) v3(30.93,71.02) v3(30.93,66.53) v3(30.93,65.03) v3(30.92,4.98) v3(31.28,137.62) v3(31.28,136.87) v3(31.28,135.37) v3(31.28,134.62) v3(31.28,130.88) v3(31.28,130.13) v3(31.28,128.63) v3(31.28,127.88) v3(31.32,73.66) v3(31.29,64.66) v3(31.41,69.43) v3(31.65,129.72) v3(31.64,126.73) v3(31.65,89.45) v3(31.65,65.08) v3(31.65,129.03) v3(31.67,127.49) v3(31.66,126.04) v3(31.68,72.52) v3(31.68,65.78) v3(32.03,139.12) v3(32.03,133.87) v3(32.03,131.63) v3(32.03,129.38) v3(32.03,126.38) v3(32.05,72.91) v3(32.35,118.15) v3(32.38,137.24) v3(32.39,127.53) v3(32.39,126.77) v3(32.47,125.52) v3(32.66,86.3) v3(32.78,137.62) v3(33.15,42.42) v3(33.49,89.8) v3(33.97,113.49) v3(34.1,87.05) v3(34.45,88.75) v3(35.22,139.35) v3(35.2,138.13) v3(35.5,115.69) v3(35.85,89.45) v3(36.07,128.87) v3(36.16,132.74) v3(36.52,127.88) v3(36.55,63.87) v3(36.58,75.15) v3(36.57,74.39) v3(36.56,72.89) v3(36.59,69.14) v3(36.58,63.15) v3(36.91,129.01) v3(36.93,127.5) v3(36.93,126.75) v3(36.92,65.78) v3(36.93,65.03) v3(36.92,62.78) v3(37.25,116.75) v3(37.27,139.12) v3(37.27,131.63) v3(37.27,75.15) v3(37.31,74.42) v3(37.3,63.87) v3(37.27,63.15) v3(37.34,62.32) v3(37.6,126) v3(37.67,129.74) v3(37.66,129) v3(37.69,128.25) v3(37.69,127.51) v3(37.66,126.77) v3(37.67,74.02) v3(37.67,73.27) v3(37.67,71.77) v3(37.67,71.02) v3(37.67,66.53) v3(37.67,65.03) v3(37.67,64.28) v3(37.95,113.95) v3(38.02,137.62) v3(38.02,136.87) v3(38.02,135.37) v3(38.02,134.62) v3(38.02,130.13) v3(38.02,128.63) v3(38.04,75.15) v3(38.04,74.39) v3(38.04,73.62) v3(38.04,72.16) v3(38.04,70.64) v3(38.04,67.66) v3(38.04,66.89) v3(38.04,65.37) v3(38.04,64.67) v3(38.04,63.91) v3(38.04,63.15) v3(38.04,62.32) v3(38.08,72.9) v3(38.06,71.42) v3(38.08,66.15) v3(38.25,84.86) v3(38.41,131.23) v3(38.4,130.47) v3(38.39,129.73) v3(38.39,129.02) v3(38.4,128.28) v3(38.37,127.49) v3(38.37,126.76) v3(38.42,126.01) v3(38.42,62.78) v3(38.77,139.12) v3(38.8,75.15) v3(38.8,74.39) v3(38.8,73.62) v3(38.8,72.93) v3(38.8,72.16) v3(38.8,71.4) v3(38.8,70.64) v3(38.8,67.66) v3(38.8,66.89) v3(38.8,66.13) v3(38.8,65.37) v3(38.8,64.67) v3(38.8,63.91) v3(38.78,63.16) v3(39.13,130.51) v3(39.15,129.03) v3(39.14,128.27) v3(39.13,127.49) v3(39.13,126.76) v3(39.17,131.23) v3(39.15,129.72) v3(39.17,23.36) v3(39.52,138.37) v3(39.52,136.87) v3(39.52,135.37) v3(39.52,134.62) v3(39.5,22.84) v3(39.66,23.33) v3(40.05,89.45) v3(40.05,88.05) v3(40.05,86.65) v3(40.71,42.42) v3(41.02,114.3) v3(41.84,141.05) v3(41.83,88.5) v3(42.46,87.71) v3(42.51,86.29) v3(43.13,85.59) v3(43.19,115.04) v3(43.55,113.25) v3(43.55,83.15) v3(44.09,88.74) v3(44.15,64.87) v3(44.15,63.64) v3(44.15,62.42) v3(44.25,83.85) v3(44.58,113.6) v3(45.35,115.03) v3(45.58,71.77) v3(45.58,66.53) v3(46.08,114.33) v3(46.35,118.15) v3(46.33,75.52) v3(46.91,60.29) v3(47.08,71.77) v3(47.08,71.02) v3(47.08,66.53) v3(47.08,65.03) v3(47.38,138.37) v3(47.38,136.87) v3(47.38,130.13) v3(47.43,64.68) v3(47.75,138.71) v3(47.75,118.85) v3(47.75,138.01) v3(47.77,137.24) v3(47.77,136.51) v3(47.78,135.75) v3(47.78,135) v3(47.78,134.24) v3(47.83,72.52) v3(47.83,65.78) v3(47.83,62.78) v3(48.13,139.12) v3(48.13,126.38) v3(48.17,60.29) v3(48.33,42.42) v3(48.5,138.72) v3(48.51,138.01) v3(48.49,137.27) v3(48.51,136.49) v3(48.5,135.78) v3(48.47,135) v3(48.51,134.27) v3(48.45,67.12) v3(48.88,137.62) v3(48.88,136.87) v3(48.88,135.37) v3(48.88,134.62) v3(48.88,128.63) v3(48.88,127.88) v3(48.97,64.66) v3(49.22,138) v3(49.22,136.5) v3(49.16,72.52) v3(49.26,138.73) v3(49.28,137.25) v3(49.27,135.78) v3(49.26,128.26) v3(49.35,68.8) v3(49.38,60.29) v3(49.45,70.89) v3(49.45,68.24) v3(49.63,139.12) v3(49.63,126.38) v3(50.6,60.29) v3(50.66,70.89) v3(50.66,68.24) v3(50.93,136.08) v3(50.98,137) v3(52.32,66.93) v3(52.68,74.41) v3(52.69,64.65) v3(52.7,63.91) v3(52.7,63.15) v3(52.9,125.69) v3(53.07,65.78) v3(53.45,75.86) v3(53.44,75.12) v3(53.41,66.14) v3(53.44,63.88) v3(53.44,63.17) v3(53.45,62.43) v3(53.47,74.39) v3(53.46,72.87) v3(53.46,72.11) v3(53.57,136.13) v3(53.66,128.89) v3(53.82,74.02) v3(53.82,71.77) v3(53.82,66.53) v3(54.05,93.65) v3(54.05,92.95) v3(54.19,75.87) v3(54.2,75.12) v3(54.2,74.43) v3(54.21,73.67) v3(54.21,72.88) v3(54.17,72.16) v3(54.19,71.36) v3(54.19,70.69) v3(54.19,67.61) v3(54.19,66.86) v3(54.18,66.14) v3(54.2,63.87) v3(54.2,63.18) v3(54.19,62.42) v3(54.28,64.69) v3(54.42,105.88) v3(54.42,101.75) v3(54.49,138.72) v3(54.53,138) v3(54.57,75.52) v3(54.74,95.85) v3(54.87,131.63) v3(54.87,126.38) v3(54.86,104.17) v3(54.95,74.43) v3(54.94,72.92) v3(54.93,72.16) v3(54.93,66.89) v3(54.96,75.11) v3(54.97,73.66) v3(54.95,71.36) v3(54.95,70.68) v3(54.95,67.61) v3(54.98,66.15) v3(54.95,63.87) v3(54.96,63.19) v3(55.12,96.87) v3(55.24,139.47) v3(55.25,138.72) v3(55.24,138.01) v3(55.24,135.79) v3(55.26,136.48) v3(55.26,128.23) v3(55.32,74.77) v3(55.32,67.28) v3(55.45,95.75) v3(55.62,137.62) v3(55.62,136.87) v3(55.62,135.37) v3(55.63,64.73) v3(55.69,66.13) v3(55.88,95.98) v3(56.01,139.47) v3(56,138.72) v3(56.03,138) v3(55.98,137.22) v3(56.01,136.49) v3(56.03,135.75) v3(56,135.03) v3(55.99,134.29) v3(56.01,42.42) v3(56.15,92.95) v3(56.26,87.47) v3(56.37,126.38) v3(56.43,83.57) v3(56.72,138) v3(56.74,137.22) v3(56.75,136.47) v3(56.73,135.76) v3(56.73,135.01) v3(56.77,138.72) v3(56.77,134.27) v3(56.85,94.35) v3(56.85,93.65) v3(56.85,92.25) v3(57.12,138.37) v3(57.12,136.87) v3(57.12,135.37) v3(57.12,130.13) v3(57.12,127.13) v3(57.37,87.57) v3(57.79,82.9) v3(57.91,84.86) v3(58.49,83.6) v3(58.49,82.9) v3(59.19,84.3) v3(59.19,83.6) v3(60.45,101.44) v3(62.78,108.6) v3(62.78,107.57) v3(62.78,106.68) v3(62.78,105.64) v3(62.78,104.68) v3(62.79,103.62) v3(62.78,102.58) v3(62.8,101.53) v3(63.76,42.42) v3(64.33,109.57) v3(64.33,108.55) v3(64.33,107.6) v3(64.33,105.69) v3(64.33,104.68) v3(64.39,106.68) v3(64.39,103.66) v3(64.39,102.58) v3(64.39,101.63) v3(64.64,97.94) v3(65.21,97.94) v3(65.98,109.57) v3(65.98,108.55) v3(66.03,107.6) v3(65.98,106.64) v3(65.98,105.63) v3(65.98,104.68) v3(65.98,103.66) v3(65.98,102.64) v3(69.46,38.03) v3(69.46,37.45) v3(69.46,36.89) v3(70.03,38.03) v3(70.03,37.45) v3(70.03,36.89) v3(70.8,105.76) v3(70.95,104.96) v3(71.25,103.98) v3(71.31,42.42) v3(72.3,77.11) v3(72.42,6.75) v3(77.6,139.41) v3(78.23,68.8) v3(80.58,78.89) v3(87.57,80.16) v3(87.57,78.77) v3(87.57,77.24) v3(87.57,34.06) v3(88.46,14.89) v3(88.54,7.04) v3(88.84,147.98) v3(88.84,147.35) v3(89.81,6.76) v3(90.81,141.51) v3(90.81,140.62) v3(91.88,44.1) v3(92.2,142.27) v3(92.2,86.2) v3(92.71,85.94) v3(93.09,87.47) v3(93.28,140.81) v3(94.36,151.48) v3(94.36,86.07) v3(95.19,151.48) v3(95.17,138.89) v3(95.44,40.03) v3(95.89,38.38) v3(95.89,31.9) v3(96.2,50.89) v3(96.2,35.52) v3(96.71,31.33) v3(97.22,102.9) v3(97.79,35.4) v3(97.85,33.94) v3(98.04,45.24) v3(98.42,151.48) v3(98.42,109.18) v3(98.74,42.7) v3(98.87,33.87) v3(99.12,41.75) v3(99.19,104.49) v3(99.25,151.48) v3(99.25,102.83) v3(99.38,44.35) v3(99.5,33.3) v3(99.69,106.83) v3(99.76,108.36) v3(99.89,41.75) v3(101.54,108.49) v3(101.6,23.59) v3(102.3,111.09) v3(102.3,109.76) v3(104.08,50.38) v3(105.09,50.13) v3(107.63,45.24) v3(108.08,44.92) v3(108.33,142.97) v3(108.58,144.01) v3(109.22,44.73) v3(109.63,141.82) v3(109.75,143.96) v3(111.29,141.93) v3(111.58,44.35) v3(111.7,52.22) v3(111.95,52.73) v3(112.84,42.51) v3(112.89,44.91) v3(113.08,142.5) v3(113.54,87.59) v3(114.03,44.48) v3(114.68,87.09) v3(114.68,86.45) v3(114.68,85.75) v3(114.87,52.48) v3(115.19,87.66) v3(115.25,53.56) v3(116.08,53.05) v3(116.52,52.48) v3(116.74,142.47) v3(117.19,87.06) v3(117.22,86.39) v3(117.22,85.75) v3(117.22,85.12) v3(117.75,142.59) v3(118.75,35.91) v3(118.87,30.06) v3(118.87,25.94) v3(119,32.86) v3(119.38,46.48) v3(120.14,41.44) v3(120.64,41.99) v3(120.79,45.77) v3(122.17,89.69) v3(122.17,89.05) v3(123,16.35) v3(123.06,88.99) v3(124.02,91.72) v3(124.33,16.35) v3(124.9,90.2) v3(124.9,89.56) v3(124.9,88.42) v3(124.9,15.27) v3(125.79,91.66) v3(126.28,91.3) v3(126.75,91.66) v3(127.64,91.66) v3(128.52,91.66) v3(129.02,91.95) v3(129.02,91.3) v3(129.22,86.39) v3(129.22,85.75) v3(129.22,85.12) v3(129.48,91.66) v3(130.43,91.66) v3(131.38,92.29) v3(131.38,91.66) v3(131.77,91.95) v3(132.21,91.72) v3(132.82,49.62) v3(133.1,91.72) v3(134.62,51.69) v3(134.82,52.73) v3(135.13,85.75) v3(135.09,47.45) v3(135.62,52.73) v3(135.65,51.67) v3(135.69,48.36) v3(136.04,37.34) v3(136.41,49.42) v3(136.55,37.34) v3(137.06,37.34) v3(137.22,141.32) v3(137.48,140.17) v3(137.57,37.34) v3(139.57,64.11) v3(139.89,139.79) v3(142.37,35.02) v3(142.75,25.49) v3(143,24.98) v3(144.02,24.6) v3(144.08,35.02) v3(144.15,26.06) v3(144.78,35.97) v3(145.1,51.78) v3(145.22,52.29) v3(145.73,52.29) v3(145.92,51.78) v3(146.24,52.29) v3(146.43,51.78) v3(146.49,25.11) v3(146.75,52.29) v3(146.81,25.55) v3(147.26,52.29) v3(147.51,51.78) v3(147.76,52.29) v3(148.27,52.29) v4(2.88,133.16) v4(2.88,131.66) v4(2.88,124.92) v4(2.88,114.58) v4(2.88,109.34) v4(2.88,107.84) v4(2.88,97.5) v4(2.88,90.76) v4(3.03,130.14) v4(3.07,127.39) v4(3.33,111.56) v4(3.44,129.34) v4(3.44,128.42) v4(3.63,133.91) v4(3.63,72.93) v4(3.71,112.34) v4(3.75,110.8) v4(3.87,76.54) v4(4.38,115.33) v4(4.38,108.59) v4(4.38,98.25) v4(4.38,81.17) v4(4.75,54.19) v4(5.13,133.91) v4(5.13,132.41) v4(5.13,115.33) v4(5.13,108.59) v4(5.13,98.25) v4(5.13,91.51) v4(5.13,81.17) v4(5.13,74.43) v4(5.13,72.93) v4(5.26,15.34) v4(5.26,9.66) v4(5.26,8.74) v4(5.65,59.35) v4(5.79,98.99) v4(5.88,126.42) v4(5.88,80.42) v4(5.86,9.66) v4(5.86,8.74) v4(6.16,119.12) v4(6.46,16.26) v4(6.46,8.74) v4(6.63,133.91) v4(6.63,132.41) v4(6.63,125.67) v4(6.63,115.33) v4(6.63,107.09) v4(6.63,98.25) v4(6.63,91.51) v4(6.89,127.31) v4(7.03,119.12) v4(7.11,58.44) v4(7.06,15.34) v4(7.06,8.74) v4(7.38,133.91) v4(7.38,115.33) v4(7.38,108.59) v4(7.38,98.25) v4(7.38,90.01) v4(7.38,82.67) v4(7.38,81.17) v4(7.38,74.43) v4(7.45,129.44) v4(7.45,128.22) v4(7.67,130.81) v4(7.66,8.74) v4(8.13,92.26) v4(8.29,84.43) v4(8.26,16.26) v4(8.26,8.74) v4(8.26,5.44) v4(8.76,108.84) v4(8.86,15.34) v4(8.86,6.36) v4(9.06,114.94) v4(9.06,57.5) v4(9.17,54.64) v4(9.27,48.02) v4(9.65,114.94) v4(9.72,132.62) v4(9.72,128.62) v4(9.78,80.83) v4(9.93,57.49) v4(9.93,48.04) v4(10.06,16.26) v4(10.06,5.44) v4(10.37,131.66) v4(10.37,126.42) v4(10.37,114.58) v4(10.37,109.34) v4(10.58,54.18) v4(10.71,48.05) v4(10.66,6.36) v4(10.76,57.47) v4(10.97,128.61) v4(11.12,115.33) v4(11.12,108.59) v4(11.37,25.92) v4(11.87,125.67) v4(11.87,124.17) v4(11.87,115.33) v4(11.87,108.59) v4(11.87,98.25) v4(11.87,91.51) v4(11.87,81.17) v4(11.87,74.43) v4(12.18,128.61) v4(12.23,57.48) v4(12.32,25.92) v4(12.62,75.18) v4(13.06,57.46) v4(13.37,115.33) v4(13.37,108.59) v4(13.37,99.75) v4(13.37,82.67) v4(13.37,81.17) v4(14.12,125.67) v4(14.12,115.33) v4(14.12,108.59) v4(14.12,91.51) v4(14.12,81.17) v4(14.3,128.61) v4(14.87,82.67) v4(15.52,128.61) v4(15.62,116.08) v4(15.62,107.84) v4(15.62,90.76) v4(15.62,81.92) v4(15.74,45.74) v4(15.75,45.27) v4(16.16,132.41) v4(20.05,55.91) v4(20.05,55.6) v4(20.36,55.91) v4(20.36,55.6) v4(20.66,55.91) v4(20.66,55.6) v4(21.27,15.67) v4(22.19,15.67) v4(22.5,41.21) v4(22.52,40.17) v4(22.49,39.04) v4(23.11,15.66) v4(23.39,40.1) v4(24.07,15.66) v4(24.24,39.02) v4(24.3,41.2) v4(24.28,40.07) v4(25.02,15.66) v4(25.97,15.9) v4(26.29,64.62) v4(26.28,63.4) v4(26.28,62.19) v4(26.29,15.9) v4(26.73,137.89) v4(26.67,103.41) v4(26.7,99.88) v4(26.99,64.3) v4(27.07,131.31) v4(27.24,15.9) v4(27.56,15.9) v4(28.45,128.08) v4(28.51,15.9) v4(28.65,129.55) v4(28.83,15.9) v4(29.02,128.08) v4(29.15,4.98) v4(29.78,136.87) v4(29.78,135.37) v4(29.78,130.88) v4(29.78,128.63) v4(29.78,15.9) v4(30.05,90.82) v4(30.1,15.9) v4(30.18,75.52) v4(30.18,62.78) v4(30.63,90.82) v4(30.9,103.98) v4(30.93,74.02) v4(30.93,71.02) v4(30.93,66.53) v4(30.93,65.03) v4(30.92,4.98) v4(30.97,99.55) v4(30.97,98.28) v4(31.22,109.69) v4(31.22,107.79) v4(31.22,107.15) v4(31.22,106.52) v4(31.22,105.88) v4(31.22,105.25) v4(31.22,104.61) v4(31.22,102.71) v4(31.22,102.07) v4(31.2,90.82) v4(31.28,137.62) v4(31.28,136.87) v4(31.28,135.37) v4(31.28,134.62) v4(31.28,130.88) v4(31.28,130.13) v4(31.28,127.88) v4(31.41,69.43) v4(31.68,72.52) v4(31.68,65.78) v4(31.77,90.82) v4(32.03,133.87) v4(32.03,131.63) v4(32.03,129.38) v4(32.03,126.38) v4(32.3,94.71) v4(32.32,93.31) v4(32.34,90.82) v4(32.47,125.52) v4(32.78,137.62) v4(33.01,39) v4(33.24,90.79) v4(33.85,98.92) v4(33.78,94.72) v4(33.81,93.32) v4(33.9,101.65) v4(33.88,100.41) v4(34.2,109.69) v4(34.2,109.06) v4(34.2,107.79) v4(34.2,106.52) v4(34.2,105.25) v4(34.2,103.98) v4(34.2,102.71) v4(34.32,39.02) v4(34.83,114.8) v4(34.84,111.22) v4(34.95,136.18) v4(34.96,135.51) v4(35.04,133.64) v4(35.22,139.35) v4(35.2,138.13) v4(35.46,111.21) v4(35.53,109.69) v4(35.53,109.06) v4(35.53,107.79) v4(35.53,106.52) v4(35.53,105.25) v4(35.53,103.34) v4(35.59,136.98) v4(35.61,133.64) v4(35.61,39.04) v4(36.04,111.21) v4(36.1,90.84) v4(36.25,98.91) v4(36.31,101.65) v4(36.27,100.4) v4(36.39,26.14) v4(36.52,127.88) v4(36.61,111.21) v4(36.67,90.84) v4(36.93,107.79) v4(36.93,106.52) v4(36.93,105.25) v4(36.93,103.98) v4(36.93,102.71) v4(36.92,65.78) v4(36.92,62.78) v4(36.92,39.06) v4(37.24,90.84) v4(37.27,139.12) v4(37.27,131.63) v4(37.67,138.84) v4(37.67,74.02) v4(37.67,73.27) v4(37.67,71.77) v4(37.67,71.02) v4(37.67,66.53) v4(37.67,65.03) v4(37.67,64.28) v4(37.81,90.84) v4(38.02,137.62) v4(38.02,136.87) v4(38.02,135.37) v4(38.02,134.62) v4(38.02,130.13) v4(38.02,128.63) v4(38.02,39.49) v4(38.15,136.03) v4(38.33,109.69) v4(38.33,109.06) v4(38.33,107.79) v4(38.33,106.52) v4(38.33,105.25) v4(38.33,103.34) v4(38.39,138.66) v4(38.41,111.15) v4(38.38,90.84) v4(38.42,62.78) v4(38.6,137.85) v4(38.64,100.39) v4(38.65,98.91) v4(38.77,139.12) v4(38.96,90.84) v4(38.99,39.51) v4(39.05,134.24) v4(39.3,110.3) v4(39.52,138.37) v4(39.52,136.87) v4(39.52,135.37) v4(39.52,134.62) v4(39.73,109.06) v4(39.73,107.79) v4(39.73,106.52) v4(39.73,105.25) v4(39.73,103.98) v4(39.75,139.65) v4(40.32,38.97) v4(40.4,134.27) v4(40.4,132.47) v4(40.61,90.83) v4(41.04,100.4) v4(41.06,108.42) v4(41.06,106.52) v4(41.06,105.25) v4(41.06,103.34) v4(41.08,98.9) v4(41.18,111.34) v4(41.18,90.84) v4(41.62,39) v4(41.75,111.34) v4(41.75,90.84) v4(41.96,139.3) v4(41.97,138) v4(41.97,136.67) v4(41.97,135.44) v4(41.97,131.52) v4(41.97,127.15) v4(42.32,111.34) v4(42.33,106.52) v4(42.33,105.25) v4(42.33,103.98) v4(42.32,90.88) v4(42.85,39) v4(42.89,111.34) v4(42.89,90.88) v4(43.43,100.39) v4(43.47,98.9) v4(43.73,106.52) v4(43.73,105.25) v4(43.73,103.34) v4(43.81,110.52) v4(44.15,64.87) v4(44.15,63.64) v4(44.15,62.42) v4(44.09,38.97) v4(44.73,111.34) v4(44.79,5.91) v4(44.93,139.48) v4(44.93,138.05) v4(44.93,136.57) v4(45.02,5.63) v4(45.06,106.52) v4(45.06,105.25) v4(45.06,103.98) v4(45.1,5.98) v4(45.3,39.54) v4(45.56,110.7) v4(45.58,71.77) v4(45.58,66.53) v4(45.84,100.38) v4(45.83,98.9) v4(46.23,39.55) v4(46.33,75.52) v4(46.46,107.79) v4(46.46,106.52) v4(46.46,105.25) v4(46.46,103.34) v4(46.89,111.87) v4(46.91,59.92) v4(47.08,71.77) v4(47.08,71.02) v4(47.08,66.53) v4(47.08,65.03) v4(47.38,138.37) v4(47.38,136.87) v4(47.38,130.13) v4(47.54,39.3) v4(47.72,139.79) v4(47.79,107.79) v4(47.79,106.52) v4(47.79,105.25) v4(47.79,103.98) v4(47.83,72.52) v4(47.83,65.78) v4(47.83,62.78) v4(48.13,139.12) v4(48.13,126.38) v4(48.21,101.67) v4(48.19,100.38) v4(48.2,98.88) v4(48.17,59.92) v4(48.42,129.24) v4(48.45,67.12) v4(48.7,89.53) v4(48.81,90.72) v4(48.77,39.3) v4(48.88,136.87) v4(48.88,135.37) v4(48.88,134.62) v4(48.88,128.63) v4(48.88,127.88) v4(49.12,107.79) v4(49.12,106.52) v4(49.12,105.25) v4(49.12,103.34) v4(49.16,72.52) v4(49.28,89.53) v4(49.41,112.35) v4(49.42,90.72) v4(49.38,59.92) v4(49.45,70.89) v4(49.45,68.24) v4(49.47,62.79) v4(49.47,21.77) v4(49.63,139.12) v4(49.63,126.38) v4(49.87,89.53) v4(50.03,90.72) v4(49.99,39.3) v4(50.15,139.67) v4(50.08,125.45) v4(50.07,114.8) v4(50.24,63.12) v4(50.42,89.53) v4(50.52,109.69) v4(50.52,109.06) v4(50.52,108.42) v4(50.52,107.79) v4(50.52,106.52) v4(50.52,105.88) v4(50.52,105.25) v4(50.52,103.98) v4(50.52,103.34) v4(50.52,102.71) v4(50.6,101.67) v4(50.56,100.38) v4(50.56,98.88) v4(50.6,90.73) v4(50.6,59.92) v4(50.66,70.89) v4(50.66,68.24) v4(51.01,89.54) v4(51.07,97.16) v4(51.17,90.73) v4(51.21,39.21) v4(51.34,103.53) v4(51.54,102.8) v4(51.54,101.91) v4(51.54,101.02) v4(51.59,29.09) v4(51.74,32.6) v4(51.98,129.57) v4(51.98,128.81) v4(51.97,100.17) v4(51.97,98.9) v4(51.97,97.69) v4(51.97,97.12) v4(51.97,96.55) v4(52,93.28) v4(52.04,92.7) v4(52.04,91.56) v4(52.04,90.99) v4(52.3,108.35) v4(52.3,107.33) v4(52.3,106.43) v4(52.32,66.93) v4(52.35,39.14) v4(52.66,109.79) v4(52.66,109.19) v4(52.89,139.47) v4(52.9,125.69) v4(53.07,65.78) v4(53.23,39.13) v4(53.59,95) v4(53.82,74.02) v4(53.82,71.77) v4(53.82,66.53) v4(54.42,105.88) v4(54.42,101.75) v4(54.57,75.52) v4(54.74,95.85) v4(54.87,131.63) v4(54.86,104.17) v4(55.12,96.87) v4(55.32,74.77) v4(55.32,67.28) v4(55.45,95.75) v4(55.62,137.62) v4(55.62,136.87) v4(55.62,135.37) v4(55.88,95.98) v4(56.26,87.47) v4(56.32,26.43) v4(56.37,126.38) v4(56.71,34.62) v4(56.85,92.25) v4(57.12,138.37) v4(57.12,136.87) v4(57.12,135.37) v4(57.12,130.13) v4(57.12,127.13) v4(57.28,26.43) v4(57.37,87.57) v4(57.61,34.62) v4(57.91,84.86) v4(57.99,129.93) v4(57.99,129.33) v4(58.47,34.67) v4(59.21,39.36) v4(60.26,39.7) v4(60.27,27.4) v4(60.52,26.38) v4(61.18,39.72) v4(61.91,32.41) v4(62.32,39.37) v4(62.29,31.14) v4(63.56,39.42) v4(64.81,115.84) v4(64.77,39.44) v4(66.04,108.17) v4(66.04,107.03) v4(66.13,26.72) v4(66.31,39.44) v4(66.99,39.26) v4(67.42,107.53) v4(67.42,106.58) v4(67.42,105.69) v4(67.84,115.18) v4(68.49,115.74) v4(68.54,115.19) v4(68.49,39.22) v4(69.01,115.72) v4(69.14,115.19) v4(69.09,100.93) v4(69.47,115.71) v4(69.46,38.03) v4(69.46,37.45) v4(69.46,36.89) v4(69.56,39.28) v4(69.76,115.2) v4(69.98,115.71) v4(69.98,100.93) v4(70.03,38.03) v4(70.03,37.45) v4(70.03,36.89) v4(70.51,39.28) v4(70.74,107.39) v4(70.74,107.04) v4(70.83,105.36) v4(70.83,104.22) v4(71.04,107.55) v4(71.12,107.19) v4(71.12,106.78) v4(71.51,105.37) v4(71.5,104.23) v4(71.63,39) v4(72.97,39.02) v4(73.86,102.06) v4(74.55,13.16) v4(75.25,101.54) v4(75.34,102.36) v4(75.54,39.08) v4(75.63,12.92) v4(76.27,129.17) v4(76.57,131.56) v4(77.18,129.19) v4(77.22,13.67) v4(78,131.42) v4(78.13,129.17) v4(78.23,68.8) v4(78.92,129.34) v4(79.5,99.04) v4(79.84,129.39) v4(80.45,99.04) v4(80.58,78.89) v4(82.96,20.17) v4(83.06,16.53) v4(83.2,23.93) v4(83.57,7.83) v4(83.95,17.97) v4(83.95,16.51) v4(84.69,8.27) v4(85.83,41.82) v4(85.87,19.46) v4(86.12,12.16) v4(86.88,20.78) v4(86.98,36.2) v4(87.03,13.82) v4(87.57,80.16) v4(87.57,78.77) v4(87.57,77.24) v4(87.77,20.78) v4(88.66,20.78) v4(89.09,7.28) v4(89.65,36.2) v4(90.04,7.28) v4(90.27,33.34) v4(90.27,27.54) v4(91.71,12.7) v4(91.68,11.9) v4(91.68,11.01) v4(92.2,86.2) v4(92.71,85.94) v4(92.94,18.36) v4(92.93,16.38) v4(93.09,87.47) v4(93.2,24.62) v4(93.25,20.54) v4(93.74,146.19) v4(94.36,151.48) v4(94.36,86.07) v4(95.19,151.48) v4(95.44,16.25) v4(96.2,50.89) v4(96.28,64.37) v4(96.39,61.83) v4(96.76,19.51) v4(97.22,102.9) v4(98,66.25) v4(98.04,45.24) v4(98.26,69.05) v4(98.42,151.48) v4(98.42,109.18) v4(99.12,41.75) v4(99.19,104.49) v4(99.25,151.48) v4(99.25,102.83) v4(99.32,70.86) v4(99.32,70.23) v4(99.5,33.3) v4(99.69,106.83) v4(99.76,108.36) v4(99.89,41.75) v4(101.02,89.33) v4(101.24,89.97) v4(101.54,108.49) v4(101.5,15.49) v4(101.5,14.84) v4(101.56,12) v4(102.3,111.09) v4(102.3,109.76) v4(102.5,70.59) v4(104.2,91.91) v4(104.2,91.28) v4(104.2,90.64) v4(104.2,90.01) v4(104.2,89.37) v4(104.2,88.67) v4(104.95,70.02) v4(105,67.72) v4(105.16,91.91) v4(106.11,91.91) v4(107,91.85) v4(107,91.28) v4(107,90.83) v4(107.63,45.24) v4(107.89,91.91) v4(108.08,44.92) v4(108.69,65.06) v4(108.84,91.85) v4(109.22,44.73) v4(109.79,91.28) v4(109.79,90.77) v4(109.91,140.17) v4(109.86,90.07) v4(109.88,89.69) v4(110.72,91.98) v4(111.19,91.34) v4(111.32,132.97) v4(111.58,92.03) v4(112.01,67.27) v4(112.21,69.05) v4(112.18,65.91) v4(112.39,132.07) v4(112.46,91.28) v4(112.52,90.83) v4(112.58,69.8) v4(112.84,90.07) v4(112.84,89.31) v4(112.84,88.86) v4(113.36,68.28) v4(114.17,69.85) v4(114.31,29.75) v4(114.68,87.91) v4(115.97,22.91) v4(116.07,62.81) v4(117.2,87.45) v4(117.6,27.73) v4(118.24,28.65) v4(118.75,35.91) v4(119.38,46.48) v4(120.14,41.44) v4(120.64,41.99) v4(120.71,89.5) v4(121.03,61.33) v4(121.16,90.71) v4(122.17,89.69) v4(122.17,89.05) v4(123.06,88.99) v4(123.77,137.74) v4(123.9,68.65) v4(123.9,67.85) v4(123.9,66.25) v4(124.02,91.72) v4(124.28,89.4) v4(124.27,88.74) v4(124.84,37.14) v4(124.84,36.82) v4(124.84,36.5) v4(124.9,90.2) v4(124.9,89.56) v4(124.9,88.42) v4(124.9,15.27) v4(124.98,137.74) v4(125.16,37.14) v4(125.16,36.82) v4(125.16,36.5) v4(125.48,37.14) v4(125.48,36.82) v4(125.48,36.5) v4(125.79,91.66) v4(126.28,91.3) v4(126.75,91.66) v4(126.79,88.53) v4(127.64,91.66) v4(127.61,87.47) v4(127.86,88.03) v4(127.92,71.56) v4(128.3,66.17) v4(128.42,69.73) v4(128.52,91.66) v4(128.55,38.33) v4(128.55,38.01) v4(128.55,37.7) v4(128.55,37.38) v4(128.55,37.06) v4(128.87,38.33) v4(128.87,38.01) v4(128.87,37.7) v4(128.87,37.38) v4(128.87,37.06) v4(129.02,91.95) v4(129.02,91.3) v4(129.03,86.76) v4(128.97,86.09) v4(128.98,85.45) v4(129.27,38.22) v4(129.41,88.01) v4(129.38,37.43) v4(129.48,91.66) v4(129.49,90.55) v4(129.48,89.25) v4(129.59,38.22) v4(129.91,38.22) v4(129.96,68.67) v4(130.04,37.43) v4(130.25,68.98) v4(130.31,70.26) v4(130.43,91.66) v4(130.7,37.43) v4(131.32,90.58) v4(131.31,71.68) v4(131.29,70.05) v4(131.33,63.49) v4(131.38,92.29) v4(131.38,91.66) v4(131.77,91.95) v4(131.93,91.41) v4(131.95,58.92) v4(132.21,91.72) v4(132.19,59.24) v4(132.8,65.46) v4(133.1,91.72) v4(133.16,90.86) v4(133.34,137.86) v4(133.6,88.32) v4(133.92,92.29) v4(134,85.72) v4(134.08,91.15) v4(134.06,28.48) v4(134.3,27.33) v4(134.47,137.87) v4(134.54,91.6) v4(134.56,92.29) v4(134.62,51.69) v4(134.66,35.31) v4(134.82,52.73) v4(135.19,92.29) v4(135.18,90.05) v4(135.24,88.92) v4(135.62,52.73) v4(135.65,51.67) v4(135.83,92.29) v4(135.99,87.71) v4(136.04,37.34) v4(136.53,92.29) v4(136.55,37.34) v4(136.65,89.63) v4(137.06,37.34) v4(137.57,37.34) v4(137.6,16.28) v4(138,137.8) v4(137.95,72.77) v4(139.08,71.5) v4(139.22,141.07) v4(139.24,137.8) v4(139.46,139.82) v4(139.5,64.54) v4(139.7,61.85) v4(142.34,35.04) v4(142.34,26.06) v4(142.94,35.96) v4(142.94,25.14) v4(144.14,35.04) v4(144.14,26.06) v4(144.74,35.96) v4(144.74,32.66) v4(144.74,25.14) v4(145.25,93.03) v4(145.34,32.66) v4(145.94,35.04) v4(145.94,32.66) v4(145.94,26.06) v4(146.54,35.96) v4(146.54,32.66) v4(146.54,25.14) v4(147.14,32.66) v4(147.14,31.74) v4(147.74,35.04) v4(147.74,32.66) v4(147.74,31.74) v4(147.74,26.06) v4(149.97,49.28) v4(150.04,39.75) v5(0.44,137.14) v5(0.43,134.84) v5(0.43,133.62) v5(0.43,132.4) v5(0.43,131.18) v5(0.43,129.96) v5(0.43,128.74) v5(0.43,127.52) v5(0.43,126.3) v5(0.43,125.09) v5(0.43,123.87) v5(0.43,122.65) v5(0.43,121.43) v5(0.43,120.21) v5(0.43,118.99) v5(0.43,117.77) v5(0.43,116.55) v5(0.43,115.33) v5(0.43,114.11) v5(0.43,112.89) v5(0.43,111.67) v5(0.43,110.45) v5(0.43,109.24) v5(0.43,108.02) v5(0.43,106.8) v5(0.43,105.58) v5(0.43,104.36) v5(0.43,103.14) v5(0.43,101.92) v5(0.43,100.7) v5(0.43,99.48) v5(0.43,98.26) v5(0.43,97.04) v5(0.43,95.82) v5(0.43,94.61) v5(0.43,93.39) v5(0.43,92.17) v5(0.43,90.95) v5(0.43,89.73) v5(0.43,88.51) v5(0.43,87.29) v5(0.43,86.07) v5(0.43,84.85) v5(0.43,83.63) v5(0.43,82.41) v5(0.43,81.19) v5(0.43,79.97) v5(0.43,78.76) v5(0.43,77.54) v5(0.43,76.32) v5(0.43,75.1) v5(0.43,73.88) v5(0.43,72.66) v5(0.43,71.44) v5(0.43,70.22) v5(0.43,69) v5(0.43,67.78) v5(0.43,66.56) v5(0.43,65.34) v5(0.43,64.13) v5(0.43,62.91) v5(0.43,61.69) v5(0.43,60.47) v5(0.43,59.25) v5(0.43,58.03) v5(0.43,56.81) v5(0.43,55.59) v5(0.43,54.37) v5(0.43,53.15) v5(0.43,51.93) v5(0.43,50.71) v5(0.43,49.49) v5(0.43,48.28) v5(0.43,47.06) v5(0.43,45.84) v5(0.43,44.62) v5(0.43,43.4) v5(0.43,42.18) v5(0.43,40.96) v5(0.43,39.74) v5(0.43,38.52) v5(0.43,37.3) v5(0.43,36.08) v5(0.43,34.86) v5(0.43,33.65) v5(0.43,32.43) v5(0.43,31.21) v5(0.43,29.99) v5(0.43,28.77) v5(0.43,27.55) v5(0.43,26.33) v5(0.43,25.11) v5(0.43,23.89) v5(0.43,22.67) v5(0.43,21.45) v5(0.43,20.23) v5(0.43,19.01) v5(0.43,17.8) v5(0.43,16.58) v5(0.43,15.36) v5(0.43,14.14) v5(0.43,12.92) v5(0.43,11.7) v5(0.43,10.48) v5(0.43,9.26) v5(0.43,8.04) v5(0.43,6.82) v5(0.43,5.6) v5(0.43,4.38) v5(0.43,3.17) v5(0.43,1.95) v5(0.43,0.73) v5(0.47,136.06) v5(0.64,139.64) v5(0.58,138.39) v5(0.72,140.74) v5(0.93,141.9) v5(1.18,145.32) v5(1.61,0.43) v5(2.26,141.88) v5(2.46,145.56) v5(2.83,0.43) v5(3.24,144.74) v5(3.35,142.6) v5(3.52,140.02) v5(3.68,143.8) v5(3.85,10.02) v5(3.95,145.56) v5(4.05,0.43) v5(4.51,13.3) v5(4.51,12.73) v5(4.51,12.16) v5(4.61,66.66) v5(4.57,9.74) v5(4.57,9.18) v5(4.98,142.48) v5(5.08,137.51) v5(5.09,44.5) v5(5.35,145.1) v5(5.27,0.43) v5(5.55,34.23) v5(5.55,31.99) v5(5.7,53.24) v5(5.7,52.09) v5(6.01,64.26) v5(6.05,46.15) v5(6.05,42.85) v5(6.08,69.2) v5(6.22,61.01) v5(6.27,52.67) v5(6.48,144.4) v5(6.49,0.43) v5(6.67,33.11) v5(6.84,53.24) v5(6.84,52.09) v5(7.14,57.18) v5(7.24,27.67) v5(7.24,27.09) v5(7.36,60.66) v5(7.56,143.69) v5(7.58,57.89) v5(7.71,0.43) v5(7.79,34.23) v5(7.79,31.99) v5(7.9,142.48) v5(7.91,137.52) v5(7.87,27.67) v5(7.87,27.09) v5(7.95,46.15) v5(7.95,42.85) v5(8.08,60.65) v5(8.09,59.96) v5(8.13,59.17) v5(8.42,61.43) v5(8.92,60.66) v5(8.92,59.29) v5(8.9,44.5) v5(8.93,0.43) v5(9.09,69.14) v5(9.11,64.24) v5(9.42,139.97) v5(9.49,142.43) v5(10.15,0.43) v5(10.54,141.72) v5(10.67,66.7) v5(11.37,0.43) v5(11.7,141.02) v5(12.59,0.43) v5(12.96,140.97) v5(13.84,12.22) v5(13.81,0.43) v5(14.18,140.97) v5(14.48,12.22) v5(14.48,11.58) v5(15.03,0.43) v5(15.4,140.97) v5(15.94,65.05) v5(16.25,0.43) v5(16.62,140.97) v5(16.57,65.05) v5(17.1,44.34) v5(17.1,42.77) v5(17.21,65.05) v5(17.46,0.43) v5(17.84,140.97) v5(17.84,65.05) v5(17.77,43.56) v5(18.47,44.34) v5(18.47,42.77) v5(18.68,0.43) v5(19.02,43.54) v5(19.06,140.97) v5(19.56,12.22) v5(19.85,44.34) v5(19.85,42.77) v5(19.9,0.43) v5(20.19,12.22) v5(20.28,140.97) v5(20.83,12.22) v5(20.92,45.37) v5(20.92,44.76) v5(20.92,44.14) v5(21.12,0.43) v5(21.41,45.09) v5(21.42,44.43) v5(21.5,140.97) v5(21.58,37.91) v5(22.34,0.43) v5(22.71,140.97) v5(22.76,12.17) v5(23.34,12.18) v5(23.3,11.56) v5(23.56,0.43) v5(23.93,141.02) v5(23.94,12.19) v5(23.94,11.56) v5(24.78,0.43) v5(24.85,141.82) v5(25.14,46.32) v5(25.68,142.66) v5(25.84,45.62) v5(25.78,1.62) v5(26,0.43) v5(26.35,1.62) v5(26.51,46.32) v5(26.57,143.55) v5(26.92,1.62) v5(27.23,155.56) v5(27.23,154.34) v5(27.23,153.12) v5(27.23,151.9) v5(27.23,150.68) v5(27.23,149.46) v5(27.23,148.24) v5(27.23,147.03) v5(27.23,145.81) v5(27.24,144.57) v5(27.24,45.62) v5(27.22,0.43) v5(27.5,1.62) v5(27.92,156.57) v5(27.89,46.32) v5(28.07,1.62) v5(28.44,0.43) v5(28.64,1.62) v5(28.96,46.5) v5(28.96,45.89) v5(29.51,46.51) v5(29.51,45.9) v5(29.66,0.43) v5(30.3,21.99) v5(30.3,21.41) v5(30.3,20.84) v5(30.3,20.27) v5(30.3,19.7) v5(30.3,19.13) v5(30.88,0.43) v5(31.57,156.56) v5(31.88,56.54) v5(31.88,55.97) v5(31.88,55.4) v5(32.09,0.43) v5(32.41,155.68) v5(32.45,56.54) v5(32.45,55.97) v5(32.45,55.4) v5(32.69,46.32) v5(33.05,2.24) v5(33.31,0.43) v5(33.4,45.56) v5(33.63,155.67) v5(33.59,2.38) v5(34.07,46.32) v5(34.16,2.38) v5(34.53,0.43) v5(34.73,2.38) v5(34.85,155.67) v5(34.8,45.56) v5(34.84,32.74) v5(35.13,37.62) v5(35.13,37.04) v5(35.12,31.92) v5(35.12,31.33) v5(35.12,30.75) v5(35.31,2.38) v5(35.45,46.32) v5(35.42,32.74) v5(35.71,37.62) v5(35.71,37.04) v5(35.7,31.92) v5(35.7,31.33) v5(35.7,30.75) v5(35.75,0.43) v5(36,32.74) v5(36.07,155.67) v5(36.3,37.62) v5(36.3,37.04) v5(36.28,31.92) v5(36.28,31.33) v5(36.28,30.75) v5(36.46,46.43) v5(36.46,45.82) v5(36.46,45.2) v5(36.59,32.74) v5(36.88,37.62) v5(36.88,37.04) v5(36.87,31.92) v5(36.87,31.33) v5(36.87,30.75) v5(37.02,46.45) v5(37.02,45.84) v5(36.97,0.43) v5(37.17,32.74) v5(37.29,155.67) v5(38.19,0.43) v5(38.51,155.67) v5(38.48,56.48) v5(38.48,55.91) v5(38.48,55.34) v5(39.05,56.48) v5(39.05,55.91) v5(39.05,55.34) v5(39.72,155.67) v5(40.25,46.32) v5(40.49,2.5) v5(40.94,155.67) v5(40.89,45.56) v5(41.45,4.15) v5(41.45,0.85) v5(41.63,46.32) v5(41.63,44.75) v5(42.16,155.67) v5(42.29,45.56) v5(43,46.32) v5(43,44.75) v5(43.38,155.67) v5(43.35,4.15) v5(43.35,0.85) v5(44.02,46.42) v5(44.02,45.81) v5(44.02,45.19) v5(44.21,18.76) v5(44.21,16.58) v5(44.3,2.5) v5(44.6,155.67) v5(44.58,46.43) v5(44.58,45.82) v5(45.21,37.52) v5(45.2,36.3) v5(45.31,17.67) v5(45.48,36.87) v5(45.54,35.78) v5(45.82,155.67) v5(45.8,37.52) v5(45.87,36.34) v5(45.91,6.49) v5(46.03,35.22) v5(46.03,33.91) v5(46.03,32.59) v5(46.04,11.78) v5(46.4,18.76) v5(46.4,16.58) v5(46.52,30.43) v5(46.67,29.67) v5(46.67,28.36) v5(46.67,27.04) v5(46.67,11.78) v5(46.73,0.43) v5(47.04,155.67) v5(47.04,35.22) v5(47.04,33.91) v5(47.04,32.59) v5(47.11,31.28) v5(47.1,30.43) v5(47.25,29.67) v5(47.25,28.36) v5(47.25,27.04) v5(47.31,11.78) v5(47.37,153.6) v5(47.87,46.32) v5(47.94,11.78) v5(47.94,0.43) v5(48.01,6.38) v5(48.26,155.67) v5(48.32,153.25) v5(48.58,45.56) v5(48.58,11.78) v5(48.68,29.67) v5(48.68,28.36) v5(48.68,27.04) v5(48.68,25.73) v5(48.67,23.65) v5(49.09,153.25) v5(49.25,46.32) v5(49.25,44.75) v5(49.16,0.43) v5(49.48,155.67) v5(49.78,153.25) v5(49.97,45.56) v5(50.38,0.43) v5(50.62,46.32) v5(50.62,44.75) v5(50.7,155.67) v5(50.86,18.25) v5(51.18,154.02) v5(51.61,46.41) v5(51.61,45.8) v5(51.61,45.18) v5(51.6,0.43) v5(51.92,155.67) v5(52.17,46.42) v5(52.17,45.81) v5(52.36,15.57) v5(52.77,56.54) v5(52.77,55.97) v5(52.77,55.4) v5(52.82,0.43) v5(53.14,155.67) v5(53.16,153.24) v5(53.34,56.54) v5(53.34,55.97) v5(53.34,55.4) v5(54.04,0.43) v5(54.28,20.72) v5(54.35,155.67) v5(54.36,10.7) v5(55.04,24.71) v5(55.04,22.71) v5(54.97,10.73) v5(55.33,32.26) v5(55.33,30.12) v5(55.26,0.43) v5(55.57,155.67) v5(55.55,46.32) v5(56.26,45.56) v5(56.4,31.19) v5(56.48,0.43) v5(56.58,154.02) v5(56.79,155.67) v5(56.93,46.32) v5(56.93,44.75) v5(56.92,16.41) v5(57.46,32.26) v5(57.52,16.44) v5(57.66,45.56) v5(57.7,0.43) v5(58.01,155.78) v5(58.31,46.32) v5(58.31,44.75) v5(58.94,156.57) v5(58.92,0.43) v5(59.35,46.41) v5(59.35,45.8) v5(59.35,45.18) v5(59.91,46.42) v5(59.91,45.81) v5(60.14,0.43) v5(61.28,20.86) v5(61.36,0.43) v5(61.59,27.33) v5(61.59,26.76) v5(61.8,21.41) v5(62.13,20.88) v5(62.33,22.25) v5(62.51,21.38) v5(62.57,0.43) v5(62.92,20.88) v5(62.99,22.25) v5(63.16,68.3) v5(63.25,28.92) v5(63.3,46.32) v5(63.4,151.57) v5(63.44,22.7) v5(63.79,0.43) v5(64.59,70.82) v5(64.64,65.75) v5(64.64,28.92) v5(64.71,151.57) v5(64.68,46.32) v5(65.01,0.43) v5(65.93,151.57) v5(66.05,46.32) v5(66.23,0.43) v5(66.32,136.32) v5(66.48,95.01) v5(67.15,151.57) v5(67.11,46.37) v5(67.11,45.76) v5(67.45,0.43) v5(67.58,128.96) v5(67.59,70.81) v5(67.59,65.7) v5(67.67,46.38) v5(67.67,45.77) v5(67.85,139.84) v5(68.36,151.57) v5(68.39,63.53) v5(68.39,62.96) v5(68.67,0.43) v5(68.99,131.43) v5(69.04,126.39) v5(69.05,68.29) v5(68.96,63.53) v5(68.96,62.96) v5(69.37,136.32) v5(69.41,54.45) v5(69.41,53.88) v5(69.41,53.3) v5(69.53,63.53) v5(69.53,62.96) v5(69.58,151.57) v5(69.89,0.43) v5(69.98,54.45) v5(69.98,53.88) v5(69.98,53.3) v5(70.55,54.45) v5(70.55,53.88) v5(70.8,151.57) v5(70.86,46.32) v5(71.11,0.43) v5(71.5,45.56) v5(72.02,151.57) v5(71.96,131.46) v5(72.05,126.38) v5(72.23,46.32) v5(72.23,44.75) v5(72.33,0.43) v5(72.64,28.9) v5(72.9,45.56) v5(73.24,151.57) v5(73.41,128.97) v5(73.55,0.43) v5(73.61,46.32) v5(73.61,44.75) v5(74.17,28.9) v5(74.17,27.38) v5(74.46,151.57) v5(74.63,77.57) v5(74.63,76.19) v5(74.63,74.82) v5(74.6,46.37) v5(74.6,45.76) v5(74.6,45.14) v5(74.78,73.79) v5(74.77,0.43) v5(75.16,46.38) v5(75.16,45.77) v5(75.31,134.61) v5(75.37,76.8) v5(75.37,75.72) v5(75.37,74.51) v5(75.37,73.76) v5(75.63,151.92) v5(75.69,30.43) v5(75.69,28.9) v5(75.69,27.38) v5(76.01,73.74) v5(75.99,0.43) v5(76.2,77.57) v5(76.2,76.19) v5(76.2,74.82) v5(76.48,134.61) v5(76.62,73.73) v5(76.68,152.53) v5(77.21,0.43) v5(77.62,134.61) v5(77.74,153.14) v5(78.42,0.43) v5(78.74,134.65) v5(78.8,153.75) v5(79.64,0.43) v5(79.85,154.36) v5(79.89,134.65) v5(80.01,152.94) v5(80.09,81.03) v5(80.92,154.96) v5(80.86,0.43) v5(81.04,134.66) v5(81.85,152.94) v5(81.98,155.57) v5(82.08,0.43) v5(82.17,134.65) v5(83.03,156.18) v5(82.96,127.61) v5(82.96,127.05) v5(82.96,126.47) v5(83.25,120.17) v5(83.25,119.6) v5(83.25,119.03) v5(83.25,118.46) v5(83.3,0.43) v5(83.88,120.17) v5(83.88,119.6) v5(83.88,119.03) v5(83.88,118.46) v5(84.01,128.47) v5(84.18,156.57) v5(84.52,0.43) v5(84.56,129.33) v5(84.56,127.76) v5(85.05,128.51) v5(85.4,156.57) v5(85.77,152.7) v5(85.86,129.33) v5(85.86,127.76) v5(85.98,0.45) v5(86.18,128.45) v5(86.59,156.57) v5(86.72,154.35) v5(86.72,151.05) v5(86.87,128.46) v5(87.16,129.33) v5(87.16,127.76) v5(87.29,16.87) v5(87.29,14.88) v5(87.34,0.45) v5(87.54,130.47) v5(87.81,156.57) v5(88.01,128.11) v5(88.28,15.87) v5(88.48,126.05) v5(88.52,101.12) v5(88.62,154.35) v5(88.62,151.05) v5(88.58,99.34) v5(89.03,156.57) v5(88.99,0.43) v5(89.27,16.87) v5(89.27,14.88) v5(89.58,152.7) v5(89.71,127.13) v5(89.71,126.44) v5(89.74,125.73) v5(90.21,0.43) v5(90.27,156.57) v5(90.27,128.12) v5(90.3,127.46) v5(90.27,126.77) v5(90.27,126.14) v5(90.55,136.68) v5(90.67,1.56) v5(90.78,128.5) v5(90.81,127.87) v5(90.86,127.08) v5(91.03,151.28) v5(91.06,83.53) v5(91.34,126.35) v5(91.49,156.57) v5(91.49,128.58) v5(91.54,127.08) v5(92.04,129.44) v5(92.04,127.88) v5(92.38,42.34) v5(92.49,128.59) v5(92.71,156.57) v5(93.34,129.44) v5(93.34,127.88) v5(93.65,128.59) v5(93.73,154.45) v5(93.93,156.57) v5(94.31,128.59) v5(94.64,129.44) v5(94.64,127.88) v5(94.95,154.45) v5(95.02,130.58) v5(95.15,156.57) v5(95.49,128.23) v5(96.17,154.45) v5(96.27,33.78) v5(96.37,156.57) v5(96.85,34.03) v5(97.13,126.9) v5(97.1,126.24) v5(97.16,127.56) v5(97.39,154.45) v5(97.43,128.76) v5(97.41,128.2) v5(97.47,136.3) v5(97.59,156.57) v5(97.71,127.21) v5(97.69,126.44) v5(97.69,125.81) v5(97.85,98.96) v5(98.6,154.45) v5(98.56,53.84) v5(98.81,156.57) v5(99.11,127.23) v5(99.06,22.76) v5(99.19,125.91) v5(99.45,126.48) v5(99.72,127.1) v5(99.82,154.45) v5(100.03,156.57) v5(100.13,128.62) v5(100.39,53.69) v5(100.68,129.48) v5(100.68,127.92) v5(101.25,156.57) v5(101.21,128.65) v5(101.98,129.48) v5(101.98,127.92) v5(102.23,42.06) v5(102.31,128.62) v5(102.47,156.57) v5(102.49,152.67) v5(102.87,154.22) v5(102.95,128.64) v5(103.27,129.48) v5(103.27,127.92) v5(103.39,149.3) v5(103.38,104.49) v5(103.38,103.85) v5(103.38,103.22) v5(103.38,102.58) v5(103.38,101.95) v5(103.57,99.6) v5(103.57,99.02) v5(103.57,98.45) v5(103.57,41.94) v5(103.68,156.57) v5(103.65,130.62) v5(104.1,152.7) v5(104.12,128.26) v5(104.11,51.59) v5(104.46,148.73) v5(104.67,32.37) v5(104.95,156.57) v5(105.05,154.35) v5(105.05,151.05) v5(105.32,12.92) v5(105.41,15.78) v5(105.47,51.27) v5(105.6,148.02) v5(105.82,128.53) v5(105.79,127.94) v5(105.79,127.33) v5(105.79,126.72) v5(105.79,126.11) v5(105.79,99.34) v5(105.79,98.64) v5(105.79,98.01) v5(105.79,97.37) v5(105.79,96.8) v5(106.17,156.57) v5(106.43,50.32) v5(106.82,14.41) v5(106.87,103.85) v5(106.87,102.26) v5(106.87,100.8) v5(106.95,154.35) v5(106.95,151.05) v5(107,121.69) v5(107,121.06) v5(107.11,127.43) v5(107.39,156.57) v5(107.42,126.93) v5(107.38,49.94) v5(107.57,121.69) v5(107.57,121.06) v5(107.72,127.43) v5(107.91,152.7) v5(108.14,121.69) v5(108.14,121.06) v5(108.25,15.85) v5(108.32,12.92) v5(108.45,128.62) v5(108.56,156.57) v5(108.71,121.69) v5(108.71,121.06) v5(108.92,135.33) v5(109,129.48) v5(109,127.92) v5(109.33,128.63) v5(109.41,103.91) v5(109.47,102.26) v5(109.47,100.8) v5(109.68,135.33) v5(109.78,156.57) v5(110.17,98.83) v5(110.17,98.14) v5(110.17,97.5) v5(110.17,96.87) v5(110.17,96.29) v5(110.3,129.48) v5(110.3,127.92) v5(110.39,135.33) v5(110.62,128.62) v5(111,156.57) v5(111.02,135.31) v5(111.28,128.63) v5(111.51,41.68) v5(111.59,129.48) v5(111.59,127.92) v5(111.63,99.91) v5(111.63,99.21) v5(111.63,98.52) v5(111.63,97.88) v5(111.63,97.25) v5(111.63,96.67) v5(111.63,95.98) v5(111.63,95.34) v5(111.97,130.62) v5(112.05,154.92) v5(112.22,156.57) v5(112.44,128.26) v5(112.52,102.07) v5(112.52,100.55) v5(112.59,103.85) v5(113.27,154.92) v5(113.44,156.57) v5(113.41,99.6) v5(113.41,98.9) v5(113.41,98.2) v5(113.41,97.56) v5(113.41,96.93) v5(114.49,154.92) v5(114.66,156.57) v5(115.38,103.85) v5(115.57,102.26) v5(115.57,100.93) v5(115.71,154.92) v5(115.76,142.43) v5(115.88,156.57) v5(116.27,99.98) v5(116.27,99.28) v5(116.27,98.58) v5(116.27,97.94) v5(116.27,97.31) v5(116.27,96.74) v5(116.27,96.04) v5(116.27,95.4) v5(116.78,25.36) v5(116.93,154.92) v5(117.1,156.57) v5(117.32,106.54) v5(117.67,100.42) v5(117.67,99.72) v5(117.67,99.02) v5(117.67,98.39) v5(117.67,97.75) v5(117.67,97.18) v5(117.67,96.48) v5(117.67,95.85) v5(118.15,154.92) v5(118.07,106.54) v5(118.24,135.47) v5(118.24,134.9) v5(118.31,156.57) v5(118.55,103.85) v5(118.55,102.33) v5(118.55,101.06) v5(118.81,135.47) v5(118.81,134.9) v5(119.23,36.18) v5(119.38,135.47) v5(119.38,134.9) v5(119.53,156.57) v5(119.63,20.95) v5(119.67,106.53) v5(119.95,135.47) v5(119.95,134.9) v5(120.44,106.54) v5(120.75,156.57) v5(121.22,109.13) v5(121.22,107.81) v5(121.21,106.55) v5(121.28,103.91) v5(121.28,102.2) v5(121.58,154.87) v5(121.7,55.83) v5(121.97,156.57) v5(122.04,106.55) v5(122.11,100.68) v5(122.11,99.98) v5(122.11,99.28) v5(122.11,98.64) v5(122.11,98.01) v5(122.11,97.44) v5(122.11,96.74) v5(122.11,96.1) v5(122.29,55.81) v5(122.62,153.38) v5(122.8,154.87) v5(122.77,106.54) v5(123.04,49.66) v5(123.05,49.04) v5(123.19,156.57) v5(123.83,132.06) v5(123.83,130.76) v5(123.83,129.47) v5(124.02,154.87) v5(124.17,128.62) v5(124.41,156.57) v5(124.38,106.54) v5(124.53,132.61) v5(124.55,129.8) v5(124.56,131.55) v5(124.57,130.46) v5(124.74,123.95) v5(124.74,123.32) v5(124.65,97.37) v5(125.24,154.87) v5(125.2,106.54) v5(125.22,97.37) v5(125.39,132.06) v5(125.39,130.76) v5(125.39,129.47) v5(125.37,123.95) v5(125.37,123.32) v5(125.42,121.96) v5(125.42,120.67) v5(125.42,119.37) v5(125.63,156.57) v5(125.76,118.52) v5(126.12,122.51) v5(126.14,121.49) v5(126.15,120.36) v5(126.14,119.69) v5(126.46,154.87) v5(126.53,129.09) v5(126.62,103.91) v5(126.62,103.22) v5(126.62,102.52) v5(126.62,101.88) v5(126.62,101.25) v5(126.62,100.68) v5(126.62,99.98) v5(126.62,99.34) v5(126.85,156.57) v5(126.77,106.55) v5(126.87,97.37) v5(127.03,123.24) v5(126.98,121.96) v5(126.98,120.67) v5(126.98,119.37) v5(127.44,97.37) v5(127.53,106.54) v5(127.67,154.87) v5(128.07,156.57) v5(128.12,118.99) v5(128.27,103.91) v5(128.27,103.22) v5(128.27,102.52) v5(128.27,101.88) v5(128.27,101.25) v5(128.27,100.68) v5(128.27,99.98) v5(128.27,99.34) v5(128.27,98.71) v5(128.97,154.92) v5(129.1,106.54) v5(129.29,156.57) v5(129.64,153.32) v5(129.87,106.53) v5(130.19,154.92) v5(130.51,156.57) v5(130.86,153.32) v5(131.41,154.92) v5(131.73,156.57) v5(131.76,104.49) v5(132.08,153.32) v5(132.54,53.37) v5(132.54,52.76) v5(132.63,154.92) v5(132.56,132.38) v5(132.95,156.57) v5(133.3,153.32) v5(133.85,154.92) v5(134.16,156.57) v5(134.15,150.59) v5(134.52,153.32) v5(135.07,154.92) v5(135.15,52.21) v5(135.38,156.57) v5(135.51,122.9) v5(135.74,153.32) v5(136.49,154.87) v5(136.6,156.57) v5(136.84,31.11) v5(136.84,29.17) v5(137.25,51.37) v5(137.26,51.93) v5(137.26,50.8) v5(137.44,30.14) v5(137.71,154.87) v5(137.82,156.57) v5(138.05,58.19) v5(138.04,31.11) v5(138.04,29.17) v5(138.09,44.5) v5(138.93,154.87) v5(139.04,156.57) v5(139.05,46.15) v5(139.05,42.85) v5(139.77,18.6) v5(139.77,17.38) v5(139.77,16.17) v5(139.77,14.95) v5(139.77,13.73) v5(139.77,12.51) v5(139.77,11.29) v5(139.77,10.07) v5(139.77,8.85) v5(139.77,7.63) v5(139.77,6.41) v5(139.77,5.19) v5(139.77,3.97) v5(139.98,19.8) v5(140.15,154.87) v5(140.26,156.57) v5(140.98,149.6) v5(140.95,46.15) v5(140.95,42.85) v5(141.2,129.97) v5(141.2,127.85) v5(141.2,125.73) v5(141.16,20.13) v5(141.37,154.87) v5(141.48,156.57) v5(141.94,151.25) v5(141.94,147.95) v5(141.9,44.5) v5(141.96,80.1) v5(142.38,20.13) v5(142.58,154.87) v5(142.7,156.57) v5(143.32,129.97) v5(143.32,127.85) v5(143.32,125.73) v5(143.33,77.61) v5(143.49,87.92) v5(143.47,82.6) v5(143.61,103.16) v5(143.6,20.13) v5(143.87,156.22) v5(143.87,155) v5(143.87,153.78) v5(143.89,33.37) v5(143.96,85.56) v5(144.08,100.8) v5(144.34,88.27) v5(144.34,86.71) v5(144.46,103.51) v5(144.46,101.94) v5(144.46,33.37) v5(144.82,20.13) v5(145.33,146.07) v5(145.44,129.97) v5(145.44,127.85) v5(145.44,125.73) v5(145.5,50.66) v5(145.64,88.27) v5(145.64,86.71) v5(145.76,103.51) v5(145.76,101.94) v5(145.8,51.16) v5(146.04,20.13) v5(146.41,82.57) v5(146.41,77.62) v5(146.37,47.28) v5(146.55,146.07) v5(146.58,114.4) v5(146.93,88.27) v5(146.93,86.71) v5(146.99,47.9) v5(146.99,46.66) v5(147.05,103.51) v5(147.05,101.94) v5(147.26,20.13) v5(147.48,87.56) v5(147.6,102.8) v5(147.61,47.28) v5(147.77,146.07) v5(147.79,80.09) v5(147.96,116.79) v5(147.97,111.93) v5(148.48,20.13) v5(148.58,87.62) v5(148.65,35.33) v5(148.99,146.07) v5(148.97,33.17) v5(149.72,87.62) v5(149.7,20.13) v5(150.21,146.07) v5(150.15,89.45) v5(150.92,20.13) v5(151.13,116.82) v5(151.13,50.38) v5(151.16,112.05) v5(151.17,89.45) v5(151.3,87.66) v5(151.26,74.06) v5(151.26,73.48) v5(151.26,72.91) v5(151.43,146.07) v5(152.14,20.13) v5(152.57,145.63) v5(152.57,144.41) v5(152.57,143.19) v5(152.57,141.97) v5(152.57,140.75) v5(152.57,139.53) v5(152.57,138.31) v5(152.57,137.1) v5(152.57,135.88) v5(152.57,134.66) v5(152.57,133.44) v5(152.57,132.22) v5(152.57,131) v5(152.57,129.78) v5(152.57,128.56) v5(152.57,127.34) v5(152.57,126.12) v5(152.57,124.9) v5(152.57,123.68) v5(152.57,122.47) v5(152.57,121.25) v5(152.57,120.03) v5(152.57,118.81) v5(152.57,117.59) v5(152.58,114.42) v5(152.57,111.49) v5(152.57,110.27) v5(152.57,109.05) v5(152.57,107.83) v5(152.57,106.62) v5(152.57,105.4) v5(152.57,104.18) v5(152.57,102.96) v5(152.57,101.74) v5(152.57,100.52) v5(152.57,99.3) v5(152.57,98.08) v5(152.57,96.86) v5(152.57,95.64) v5(152.57,94.42) v5(152.57,93.2) v5(152.57,91.99) v5(152.57,90.77) v5(152.57,89.55) v5(152.57,88.33) v5(152.57,87.11) v5(152.57,85.89) v5(152.57,84.67) v5(152.57,83.45) v5(152.57,82.23) v5(152.57,81.01) v5(152.57,79.79) v5(152.57,78.57) v5(152.57,77.35) v5(152.57,76.14) v5(152.57,74.92) v5(152.57,73.7) v5(152.57,72.48) v5(152.57,71.26) v5(152.57,70.04) v5(152.57,68.82) v5(152.57,67.6) v5(152.57,66.38) v5(152.57,65.16) v5(152.57,63.94) v5(152.57,62.72) v5(152.57,61.51) v5(152.57,60.29) v5(152.57,59.07) v5(152.57,57.85) v5(152.57,56.63) v5(152.57,55.41) v5(152.57,54.19) v5(152.57,52.97) v5(152.57,51.75) v5(152.57,50.53) v5(152.57,49.31) v5(152.57,48.09) v5(152.57,46.87) v5(152.57,45.66) v5(152.57,44.44) v5(152.57,43.22) v5(152.57,42) v5(152.57,40.78) v5(152.57,39.56) v5(152.57,38.34) v5(152.57,37.12) v5(152.57,35.9) v5(152.57,34.68) v5(152.57,33.46) v5(152.57,32.24) v5(152.57,31.03) v5(152.57,29.81) v5(152.57,28.59) v5(152.57,27.37) v5(152.57,26.15) v5(152.57,24.93) v5(152.57,23.71) v5(152.57,22.49) v5(152.57,21.27) v6(118.02,142) v6(119.15,142.04) v7(9.51,91.17) v7(9.56,90.26) v7(43.84,37.85) v7(43.85,37.26) v7(43.87,36.6) v7(43.87,36.01) v7(44.16,37.59) v7(44.16,36.3) v7(44.5,37.87) v7(44.49,37.27) v7(44.46,36.61) v7(44.48,36.04) v7(70.74,63.76) v8(8.92,78.64) v8(9.94,112.31) v8(33.2,130.86) v8(46.37,116.16) v8(47.42,146.43) v8(48.62,146.43) v8(51.3,133.59) v8(59.63,138.13) v8(59.63,136.06) v8(59.94,133.19) v8(61.98,97.34) v8(84.58,92.04) v8(84.81,97.19) v8(84.98,96.08) v8(85.14,93.75) v8(85.27,95.1) v8(85.65,92.05) v8(86.28,92.04) v8(86.31,91.28) v8(86.78,89.3) v8(87,90.3) v8(87.57,93.13) v8(87.67,94.05) v8(88.04,90.12) v8(90.09,85.94) v8(94.08,148.79) v8(110.48,42.24) v8(111.24,42.24) v8(117.83,47.01) v8(122,41.76) v8(134.21,101.47) v9(78.74,139.35) v10(1.99,65.67) v10(2.13,67.74) v10(3.54,12.39) v10(17.53,70.02) v10(19.63,43.65) v10(23.16,37.1) v10(25.13,37.09) v10(31.67,46.92) v10(35.98,2.29) v10(55.44,23.98) v10(56.18,46.99) v10(59.93,129.59) v10(62.53,29.5) v10(65.54,101.17) v10(68.96,37.23) v10(69.62,47.13) v10(72.99,46.94) v10(74.79,28.13) v10(76.91,72.04) v10(78.92,49.52) v10(84.91,126.85) v10(95.76,126.57) v10(98.22,126.16) v10(120.56,132.95) v10(122.71,135.8) v10(126.35,119.01) v10(134.29,101.13) v10(134.25,51.39) v10(136.02,91.56) v10(142.21,128.01) v11(51.25,115.35) v11(51.25,114.65) v11(51.95,116.05) v11(51.95,115.35) v11(51.95,114.65) v11(52.65,116.75) v11(52.65,115.35) v11(53.35,118.15) v11(53.35,117.45) v11(53.35,116.75) v11(53.35,116.05) v11(53.35,115.35) v11(53.35,114.65) v11(54.05,118.85) v11(54.05,118.15) v11(54.05,117.45) v11(54.05,116.75) v11(54.05,116.05) v11(54.05,115.35) v11(54.05,114.65) v11(54.75,118.15) v11(54.75,116.75) v11(54.75,115.35) v11(55.45,118.85) v11(55.45,118.15) v11(55.45,117.45) v11(55.45,116.75) v11(55.45,116.05) v11(55.45,115.35) v11(55.45,114.65) v12(48.62,148.59) v12(49.81,148.55) v12(51.03,148.62) v12(52.18,148.58) v12(53.4,148.57) v14(2.13,57.08) v14(2.16,55.98) v14(2.27,58.22) v14(2.36,3.89) v14(5.45,5.42) v14(5.65,11.33) v14(5.78,9.93) v14(6.1,12.54) v14(6.48,9.17) v14(6.95,102.35) v14(6.92,12.92) v14(7.3,88.2) v14(7.37,8.73) v14(8.06,12.98) v14(8.65,104.47) v14(8.64,8.79) v14(9,70.87) v14(9.29,5.36) v14(9.46,12.41) v14(9.46,9.24) v14(9.59,40.31) v14(9.94,135.22) v14(9.96,102.24) v14(9.97,11.39) v14(9.97,10.38) v14(10.48,40.31) v14(10.98,54.84) v14(11.07,88.09) v14(11.1,2.69) v14(11.43,9.88) v14(11.56,36.05) v14(11.62,31.7) v14(11.62,30.88) v14(11.84,104.54) v14(12.13,86.2) v14(12.08,70.98) v14(12.37,47.65) v14(12.55,38.93) v14(12.55,38.09) v14(12.57,45.33) v14(12.78,135.28) v14(12.83,51.94) v14(13.08,50.89) v14(13.1,6.98) v14(13.26,39.8) v14(13.37,102.17) v14(13.67,88.03) v14(13.78,45.33) v14(14.67,104.29) v14(14.67,86.31) v14(14.81,65.59) v14(14.82,39.25) v14(15.72,70.98) v14(15.79,135.22) v14(16.03,88.03) v14(17.7,91.01) v14(18.05,34.66) v14(19.27,34.89) v14(20.46,34.91) v14(20.62,133.21) v14(21.67,34.91) v14(22.28,130.91) v14(22.33,128.26) v14(22.39,125.38) v14(22.87,34.89) v14(22.97,85.61) v14(23.03,84.9) v14(23.23,87.58) v14(23.24,87.1) v14(23.56,103.76) v14(23.95,104.15) v14(23.95,102.05) v14(24.08,34.88) v14(24.28,103.1) v14(24.31,100.94) v14(24.59,89.17) v14(24.63,87.59) v14(24.64,87.06) v14(24.93,129.91) v14(24.98,127.26) v14(25.04,124.37) v14(25.03,112.18) v14(25.03,100.94) v14(25.03,100.26) v14(24.97,8.78) v14(25.35,104.15) v14(25.35,102.05) v14(25.31,82.6) v14(25.32,38.99) v14(25.32,35.14) v14(25.26,2.4) v14(25.7,114.29) v14(25.68,111.53) v14(25.74,100.95) v14(25.65,99.51) v14(25.7,88.53) v14(25.9,23.66) v14(26.05,88.05) v14(26.12,40.96) v14(26.12,40.06) v14(26.17,82.62) v14(26.33,99.63) v14(26.4,113.6) v14(26.42,112.88) v14(26.43,111.56) v14(26.35,87.05) v14(26.47,100.95) v14(26.55,73.93) v14(26.78,141.7) v14(27.11,132.32) v14(27.05,124.55) v14(27.06,114.34) v14(27.09,112.11) v14(27.09,99.01) v14(27.17,129.67) v14(27.23,126.79) v14(27.18,84.27) v14(28.03,3.93) v14(28.49,114.26) v14(28.59,2.96) v14(29.1,4.45) v14(29.55,85.25) v14(29.55,83.85) v14(29.6,40.39) v14(29.59,39.06) v14(29.95,117.82) v14(29.92,117.12) v14(29.95,86.29) v14(29.92,85.59) v14(29.92,84.86) v14(29.96,118.52) v14(30.65,115.01) v14(31.65,86.65) v14(31.65,85.25) v14(31.65,83.85) v14(33.31,39.07) v14(33.91,41.02) v14(33.91,40.13) v14(34.01,115.79) v14(34.1,115) v14(34.09,114.28) v14(34.76,117.72) v14(34.79,115.7) v14(35.46,117.08) v14(35.53,116.39) v14(35.85,86.65) v14(36.13,114.45) v14(36.23,116.35) v14(36.22,85.62) v14(36.26,86.29) v14(36.83,113.63) v14(36.89,115.65) v14(36.9,115) v14(36.9,114.3) v14(37.13,40.43) v14(37.1,39.07) v14(37.64,86.26) v14(37.71,114.92) v14(37.68,114.29) v14(37.66,113.59) v14(37.95,116.75) v14(37.95,115.35) v14(38.66,77.66) v14(39.8,6.89) v14(40.89,38.97) v14(41.07,85.61) v14(41.16,83.47) v14(41.42,77.66) v14(41.44,40.97) v14(41.44,40.05) v14(41.63,8.05) v14(41.83,86.27) v14(41.95,83.42) v14(42.02,84.6) v14(42.44,85.68) v14(42.51,87) v14(43.2,86.3) v14(43.92,132.07) v14(43.92,129.95) v14(43.97,125.47) v14(44.09,127.83) v14(44.25,89.45) v14(44.25,88.05) v14(44.25,86.65) v14(44.25,85.25) v14(44.74,40.22) v14(44.73,38.97) v14(44.65,5.77) v14(44.95,88.75) v14(44.95,85.25) v14(45.01,5.44) v14(45.16,132.78) v14(45.16,130.66) v14(45.21,126.18) v14(45.34,128.54) v14(45.31,5.34) v14(45.42,5.01) v14(45.48,146.84) v14(45.62,5.34) v14(45.65,88.05) v14(45.65,85.95) v14(45.65,85.25) v14(45.72,5.01) v14(45.83,143.35) v14(46.35,89.45) v14(46.35,88.05) v14(46.35,86.65) v14(46.35,85.25) v14(46.35,83.85) v14(47.13,145.25) v14(47.05,88.75) v14(47.05,85.25) v14(47.75,88.05) v14(47.75,85.95) v14(47.75,85.25) v14(48.44,1.74) v14(48.45,115.35) v14(48.45,89.45) v14(48.45,88.05) v14(48.45,86.65) v14(48.45,85.25) v14(48.45,83.85) v14(48.45,2.62) v14(48.72,39.06) v14(48.76,118.52) v14(49.15,88.75) v14(49.15,85.25) v14(49.21,12.27) v14(49.28,41.09) v14(49.26,40.17) v14(49.4,118.53) v14(49.48,117.11) v14(49.49,116.39) v14(49.85,85.95) v14(49.85,85.25) v14(50.1,12.27) v14(50.55,85.25) v14(50.55,83.85) v14(52.25,142.01) v14(52.65,88.05) v14(52.65,86.65) v14(52.65,85.25) v14(52.65,83.85) v14(52.69,40.44) v14(52.69,39.02) v14(52.97,2.38) v14(53.77,146.46) v14(53.98,78.98) v14(54.05,97.15) v14(54.05,89.45) v14(54.42,145.33) v14(54.43,143.03) v14(54.75,83.85) v14(55.07,142.01) v14(55.07,80.34) v14(55.45,93.65) v14(55.45,91.55) v14(55.45,89.45) v14(55.7,78.77) v14(55.7,77.88) v14(55.8,26.49) v14(56.15,85.95) v14(56.15,83.85) v14(56.43,39.12) v14(56.85,91.55) v14(56.85,90.85) v14(56.85,89.45) v14(56.85,87.35) v14(56.96,41.09) v14(56.97,40.19) v14(57.16,143.35) v14(57.55,83.15) v14(58.11,2.75) v14(58.25,106.25) v14(58.25,102.05) v14(58.25,91.55) v14(58.25,89.45) v14(58.25,87.35) v14(58.25,83.85) v14(58.25,83.15) v14(58.61,73.38) v14(58.95,84.55) v14(58.95,83.85) v14(59.13,64.57) v14(59.61,75.06) v14(60.71,77.35) v14(61.19,126.02) v14(61.98,74.12) v14(62.27,112.58) v14(62.26,88.84) v14(62.29,71.61) v14(62.69,95.85) v14(62.69,95.02) v14(62.69,94.2) v14(62.79,92.98) v14(62.83,86.32) v14(63.04,75.06) v14(63.08,85.69) v14(63.08,85.05) v14(63.08,84.42) v14(63.08,83.78) v14(63.08,83.15) v14(63.08,82.51) v14(63.08,81.88) v14(63.08,81.24) v14(63.08,80.61) v14(63.08,79.97) v14(63.08,79.34) v14(63.08,78.7) v14(63.08,78.07) v14(63.31,5.93) v14(63.8,119.28) v14(64.22,87.98) v14(64.17,76.93) v14(64.44,26.65) v14(64.49,146.68) v14(64.49,146.04) v14(64.8,133.01) v14(64.87,85.69) v14(64.87,82.51) v14(65.3,90.32) v14(65.3,89.77) v14(65.3,89.16) v14(65.34,72.47) v14(65.43,133.01) v14(65.37,75.13) v14(65.46,94.6) v14(65.49,86.32) v14(65.49,85.69) v14(65.66,91.3) v14(66.08,85.05) v14(66.08,84.42) v14(66.08,83.15) v14(66.08,81.88) v14(66.08,81.24) v14(66.08,80.61) v14(66.08,79.97) v14(66.08,79.34) v14(66.08,78.7) v14(66.08,78.07) v14(66.39,75.13) v14(66.52,76.03) v14(66.85,144.89) v14(66.99,98.4) v14(67.34,133.01) v14(67.4,75.13) v14(67.83,89.12) v14(68.01,87.16) v14(68.1,98.21) v14(68.44,99.21) v14(68.42,75.13) v14(69.34,12.23) v14(69.44,75.13) v14(69.41,19.32) v14(69.44,18.14) v14(69.53,22.71) v14(69.51,2.75) v14(69.62,133.01) v14(69.61,95.79) v14(69.65,78.58) v14(69.89,108.21) v14(69.91,85.86) v14(69.93,84.48) v14(70.74,98.72) v14(70.74,96.03) v14(70.8,84.56) v14(70.79,73.05) v14(70.79,71.97) v14(71.24,10.93) v14(71.28,16.84) v14(71.41,66.45) v14(72.11,133.59) v14(72.11,38.46) v14(72.31,12.16) v14(72.54,145.16) v14(72.54,144.53) v14(73.23,140.49) v14(73.31,65.15) v14(73.29,62.6) v14(73.29,10.57) v14(73.35,19.01) v14(73.47,38.83) v14(73.47,34.78) v14(73.6,121.38) v14(73.85,144.3) v14(74.09,10.63) v14(74.16,13.81) v14(74.55,132.36) v14(74.49,94.39) v14(74.74,38.83) v14(74.76,145.06) v14(74.76,144.49) v14(75.16,1.88) v14(75.42,132.19) v14(75.56,146.8) v14(75.74,138.97) v14(75.72,4.73) v14(75.8,8.51) v14(75.93,9.74) v14(76.07,131.73) v14(76.31,146.97) v14(76.31,146.08) v14(76.43,65.24) v14(76.48,145.32) v14(76.71,131.73) v14(78,20.72) v14(78.16,4.73) v14(78.68,22.71) v14(79.18,145.29) v14(80.09,29.49) v14(80.58,145.9) v14(80.64,140.13) v14(80.66,1.88) v14(80.84,24.14) v14(80.76,19.78) v14(80.76,18.89) v14(80.91,7.71) v14(81.03,4.28) v14(81.28,140.13) v14(81.28,33.63) v14(81.37,20.69) v14(81.65,137.65) v14(81.9,140.12) v14(82.04,146.43) v14(82.04,127.66) v14(82.02,127.28) v14(81.98,124.18) v14(82.07,126.49) v14(82.33,139.03) v14(82.28,137.65) v14(82.45,126.9) v14(82.45,126.49) v14(82.47,127.66) v14(82.47,127.26) v14(82.62,37) v14(82.62,34.14) v14(82.62,31.28) v14(82.89,27.25) v14(83.11,20.68) v14(83.41,127.08) v14(83.44,126.75) v14(83.44,126.39) v14(83.52,141.82) v14(83.5,25.33) v14(83.85,127.08) v14(83.85,126.75) v14(83.85,126.39) v14(84.02,22.51) v14(84.02,21.61) v14(84.05,8.78) v14(84.07,58.36) v14(84.15,143.47) v14(84.3,144.81) v14(84.52,35.7) v14(84.52,32.84) v14(84.52,29.98) v14(84.74,66.62) v14(84.81,137.95) v14(84.76,65.31) v14(84.76,64.9) v14(84.76,64.49) v14(84.76,64.09) v14(84.9,69.3) v14(84.96,143.37) v14(85.02,58.36) v14(85.28,113.83) v14(85.83,64.87) v14(85.78,63.17) v14(85.99,14.58) v14(86.64,64.04) v14(86.58,9.29) v14(87.05,11.81) v14(87.19,144.62) v14(87.19,143.41) v14(87.22,142.52) v14(87.27,141.69) v14(87.27,141.05) v14(87.27,140.42) v14(87.29,138.52) v14(87.29,137.89) v14(87.3,10.95) v14(87.31,10.11) v14(87.45,64.85) v14(87.45,63.15) v14(87.65,71.6) v14(87.96,141.69) v14(87.96,141.05) v14(87.96,140.4) v14(88.25,144.42) v14(88.44,18.25) v14(88.47,11.04) v14(88.78,59.4) v14(88.83,58.01) v14(88.89,48.54) v14(88.93,25.11) v14(89.05,71.55) v14(89.04,9.5) v14(89.06,110.37) v14(89.34,83.9) v14(89.66,20.44) v14(89.79,14.54) v14(90.22,81.12) v14(90.31,82.43) v14(90.55,109.67) v14(90.83,60.62) v14(92.65,39.33) v14(92.65,38.95) v14(92.58,38.19) v14(92.84,83.96) v14(92.84,82.97) v14(92.9,72.14) v14(93.47,72.14) v14(93.84,147.22) v14(94.04,72.14) v14(94.36,15.33) v14(94.49,17.74) v14(94.49,16.47) v14(94.61,72.14) v14(94.74,29.63) v14(94.7,19.27) v14(95.17,144.62) v14(95.19,144.24) v14(95.19,72.14) v14(95.19,68.84) v14(95.19,67.63) v14(95.19,43.21) v14(95.39,147.22) v14(95.35,143.4) v14(95.44,46.57) v14(95.38,45.75) v14(95.63,15.33) v14(95.76,43.53) v14(96.19,106.63) v14(96.19,104.85) v14(96.2,46.19) v14(96.33,19.64) v14(96.47,147.22) v14(96.71,15.98) v14(96.84,43.59) v14(96.77,42.7) v14(97.03,143.45) v14(97.03,44.92) v14(97.28,42.83) v14(97.55,147.22) v14(97.49,105.64) v14(98.22,147.22) v14(98.36,143.16) v14(98.74,44.67) v14(98.93,45.24) v14(99.15,18.46) v14(99.35,85.44) v14(99.44,64.73) v14(99.44,43.53) v14(99.58,148.79) v14(99.77,147.22) v14(99.95,45.18) v14(100.41,143.88) v14(100.52,46) v14(100.65,113.25) v14(101.03,113.88) v14(101.12,57.05) v14(101.28,49.94) v14(101.35,44.99) v14(101.47,113.95) v14(101.56,147.14) v14(101.56,146.19) v14(102.11,113.12) v14(102.25,14.82) v14(102.49,112.3) v14(102.49,13.74) v14(102.8,71.05) v14(103.7,13.55) v14(104.84,13.73) v14(105.35,16.53) v14(105.4,19.25) v14(105.88,106.16) v14(106.17,12.03) v14(106.29,146.4) v14(107.17,18.34) v14(107.38,12.03) v14(107.6,67.85) v14(107.6,67.05) v14(107.89,146.56) v14(108.24,106.16) v14(108.4,71.05) v14(108.4,70.25) v14(108.97,16.18) v14(109.2,67.85) v14(109.73,64.67) v14(109.77,46.36) v14(110.6,106.16) v14(110.55,17.48) v14(111,15.45) v14(112.67,88.04) v14(112.96,106.16) v14(112.97,53.69) v14(113.2,71.05) v14(113.51,88.04) v14(114,145.82) v14(114.17,53.69) v14(114.34,86.74) v14(114.34,86.09) v14(114.34,85.44) v14(114.34,84.79) v14(114.86,41.77) v14(114.86,39.58) v14(114.86,37.38) v14(115.33,106.16) v14(115.8,145.82) v14(116.01,72.58) v14(116.01,71.31) v14(116.08,69.7) v14(116.07,68.02) v14(116.07,65.74) v14(116.08,64.46) v14(116.08,63.83) v14(116.13,60.71) v14(116.62,62.51) v14(116.86,88.04) v14(116.86,87.39) v14(116.86,86.74) v14(116.86,86.09) v14(116.86,85.44) v14(116.86,84.79) v14(117.6,145.82) v14(117.75,86.74) v14(118.49,86.74) v14(119.37,87.39) v14(119.37,86.74) v14(119.37,86.09) v14(119.97,26.38) v14(120.02,23.13) v14(120.21,88.04) v14(120.26,87.39) v14(120.48,63.72) v14(120.79,91.3) v14(120.79,89.35) v14(121.02,71.31) v14(121.02,69.47) v14(120.97,67.55) v14(120.97,64.82) v14(121.22,26.38) v14(121.54,141.46) v14(121.89,86.74) v14(121.89,86.09) v14(121.89,85.44) v14(122.07,55.12) v14(122.06,49.49) v14(122.21,23.65) v14(123.1,67.85) v14(123.1,67.05) v14(123.1,65.45) v14(123.1,63.85) v14(123.1,61.45) v14(123.1,59.05) v14(123.44,135.64) v14(123.35,46.01) v14(123.47,135.18) v14(123.93,135.61) v14(123.93,135.18) v14(123.93,134.5) v14(123.93,133.96) v14(124.02,137.75) v14(124.41,135.56) v14(124.38,135.18) v14(124.7,67.85) v14(124.73,17.74) v14(124.8,47.31) v14(124.8,42.31) v14(124.97,137.75) v14(124.99,21.36) v14(125.13,56.92) v14(125.7,15.94) v14(125.84,142.27) v14(126.03,137.44) v14(126.64,56.92) v14(127.33,139.34) v14(128.49,56.92) v14(128.7,67.85) v14(129.5,61.45) v14(130.48,56.9) v14(131.51,68.94) v14(131.51,62.35) v14(132.26,93.64) v14(132.58,73.28) v14(132.95,20.6) v14(132.95,18.06) v14(132.95,16.79) v14(133.5,67.05) v14(133.5,61.45) v14(134.05,25.82) v14(134.3,71.05) v14(134.3,70.25) v14(134.68,73.28) v14(134.83,85.44) v14(134.8,44.6) v14(135.1,67.85) v14(135.13,26.13) v14(135.51,102.26) v14(135.69,44.6) v14(135.87,18.26) v14(136.08,132.31) v14(136.16,102.26) v14(136.81,107.71) v14(136.81,105.41) v14(136.96,128.3) v14(136.96,127.54) v14(137.32,19.56) v14(138.18,110.01) v14(138.29,48.92) v14(139,118.79) v14(139.1,67.85) v14(139.18,88.17) v14(139.89,83.44) v14(139.9,69.45) v14(140.08,113.71) v14(140.22,108.04) v14(140.22,97.57) v14(140.22,96.62) v14(140.59,118.68) v14(140.74,33.99) v14(140.78,91.89) v14(140.91,28.98) v14(140.93,27.16) v14(140.97,89.87) v14(141.03,87.1) v14(141.03,82.76) v14(141.2,56.99) v14(141.49,40.36) v14(141.48,39.52) v14(141.86,118.68) v14(142.01,107.1) v14(142.14,71.94) v14(142.18,70.23) v14(142.37,50.27) v14(142.89,67.97) v14(142.89,67.15) v14(142.86,47.65) v14(143.32,118.11) v14(143.27,40.11) v14(143.55,54.83) v14(143.55,54.19) v14(143.55,53.56) v14(143.59,56.54) v14(143.65,55.59) v14(143.89,48.61) v14(144.89,114.76) v14(145.17,38.81) v14(145.58,118.05) v14(145.67,42.97) v14(145.73,28.48) v14(146.56,28.86) v14(146.67,42.97) v14(146.93,39.32) v14(146.95,38.47) v14(147.19,98.17) v14(147.19,31.4) v14(147.19,29.56) v14(147.38,30.51) v14(147.65,41.99) v14(148.91,79.05) v14(148.89,78.13) v14(148.89,77.12) v14(149.05,84.22) v14(149.1,126.08) v14(149.1,125.31) v14(149.1,124.55) v14(150.13,128.59) v14(150.42,84.8) v14(150.45,100.56) v14(150.48,98.78) v14(150.62,135.23) v14(150.62,130.28) v14(150.66,139.58) v14(150.9,105.82) v14(150.9,103) v14(150.85,101.91) v14(150.89,68.93) v15(2.28,91.52) v15(2.54,108.99) v15(2.54,108.17) v15(2.54,97.88) v15(2.6,98.64) v15(2.73,115.66) v15(2.67,74.77) v15(3,81.52) v15(3.24,98.64) v15(3.3,75.47) v15(3.37,73.94) v15(3.48,115.01) v15(3.49,114.26) v15(3.81,80.86) v15(4,116.04) v15(3.98,115.48) v15(4,99.28) v15(4.25,98.65) v15(4.71,115.97) v15(4.75,79.47) v15(4.76,99.28) v15(4.76,81.94) v15(4.76,74.01) v15(5.01,98.66) v15(5.33,73.31) v15(5.52,99.28) v15(5.52,81.31) v15(5.52,74.01) v15(5.76,74.77) v15(5.97,115.72) v15(5.97,98.64) v15(6.23,81.87) v15(6.22,73.57) v15(6.32,115.62) v15(6.41,99.29) v15(6.99,99.08) v15(6.99,82.01) v15(7.22,116.4) v15(7.23,74.03) v15(7.81,108.17) v15(10.73,108.23) v15(10.99,116.42) v15(11.28,99.34) v15(11.52,124.93) v15(11.74,115.73) v15(12,99.34) v15(12.25,124.93) v15(12.28,125.77) v15(12.32,115.15) v15(12.26,91.85) v15(12.38,98.52) v15(12.82,99.34) v15(12.89,114.96) v15(12.95,125.44) v15(12.95,124.68) v15(13.02,114.15) v15(13.27,116.42) v15(13.7,109.02) v15(13.72,108.17) v15(13.72,98.9) v15(13.73,97.78) v15(13.72,91.98) v15(13.7,74.88) v15(13.78,124.74) v15(13.78,115.99) v15(14.48,126.39) v15(14.51,124.68) v15(14.67,126.08) v15(14.72,99.37) v15(14.67,97.94) v15(15.01,116.41) v15(14.99,114.96) v15(15.24,107.47) v15(15.18,98.71) v15(15.25,125.68) v15(15.28,98.33) v15(15.82,74.04) v15(15.88,98.58) v15(15.94,91.85) v15(15.94,91.15) v15(15.88,74.77) v15(16.13,91.53) v15(22.5,41.21) v15(22.52,40.17) v15(22.49,39.04) v15(23.39,40.1) v15(24.24,39.02) v15(24.27,85.03) v15(24.3,41.2) v15(24.28,40.07) v15(25.02,84.93) v15(25.06,84.23) v15(25.63,86.3) v15(25.67,84.93) v15(29.84,74.96) v15(29.93,65.45) v15(29.96,66.24) v15(30.1,135.92) v15(30.17,66.9) v15(30.29,73.62) v15(30.3,63.19) v15(30.42,135.03) v15(30.53,134.25) v15(30.53,71.18) v15(30.48,64.03) v15(30.61,137.25) v15(30.58,72.62) v15(30.69,138.69) v15(30.73,75.15) v15(30.86,135.5) v15(30.87,134.73) v15(31.04,65.43) v15(31.19,72.28) v15(31.31,74.51) v15(31.31,63.65) v15(31.26,62.9) v15(31.62,139.41) v15(31.65,138.46) v15(31.62,136.2) v15(32.2,138.06) v15(35.94,64.67) v15(36.32,69.95) v15(36.95,138.52) v15(37.2,73.64) v15(37.24,72.94) v15(37.34,75.91) v15(37.27,65.31) v15(37.27,64.73) v15(37.9,136.46) v15(38.04,75.85) v15(38.36,139.24) v15(38.35,138.08) v15(38.94,86.3) v15(39.05,137.25) v15(39.05,136.49) v15(39.05,135.66) v15(39.12,134.53) v15(46.04,75.02) v15(46.04,66.19) v15(46.04,65.37) v15(46.04,64.73) v15(46.04,63.91) v15(46.29,73.63) v15(46.61,74.45) v15(46.61,73.75) v15(46.61,72.93) v15(46.61,71.4) v15(46.61,63.91) v15(46.74,62.64) v15(46.86,66.07) v15(47.43,74.96) v15(47.37,72.29) v15(47.43,63.46) v15(47.5,73.56) v15(47.69,72.93) v15(47.79,129.24) v15(48.13,127.48) v15(48.9,129.73) v15(48.9,126.73) v15(49.72,126.78) v15(50.55,116.75) v15(50.55,115.35) v15(51.25,116.05) v15(51.95,116.75) v15(51.9,65.15) v15(52.07,64.67) v15(52.65,118.15) v15(52.7,73.56) v15(52.7,73) v15(53.35,118.85) v15(53.51,65.48) v15(54.23,65.37) v15(54.89,65.48) v15(55.26,129.38) v15(55.55,126.78) v15(56.13,130.39) v15(56.45,128.23) v15(56.39,127.48) v15(136.04,37.34) v15(136.55,37.34) v15(137.06,37.34) v15(137.57,37.34) v16(3.75,51.18) v16(3.91,50.24) v16(4.94,51.29) v16(7.73,50.6) v16(8.88,50.6) v16(24.16,100.58) v16(25.54,99.25) v16(26.06,99.66) v16(26.63,97.45) v16(27.81,88.42) v16(27.95,98.12) v16(28.3,99.66) v16(28.5,95.44) v16(28.93,89.46) v16(32.01,107.98) v16(32.02,106.47) v16(31.98,105.19) v16(31.95,103.77) v16(32.01,99.6) v16(32.3,97.86) v16(32.72,96.83) v16(33.35,92.62) v16(33.39,105.19) v16(33.4,94.02) v16(34.07,102.27) v16(34.11,99.61) v16(34.11,98.21) v16(34.13,92.6) v16(34.15,94.02) v16(34.8,102.41) v16(34.8,101.02) v16(34.82,99.62) v16(35.55,96.81) v16(35.85,89.45) v16(36.8,102.16) v16(36.94,109.37) v16(36.89,101) v16(36.89,99.63) v16(37.57,101) v16(37.59,99.6) v16(37.68,102.17) v16(38.3,96.8) v16(38.97,109.35) v16(38.98,94) v16(38.96,92.61) v16(39.58,102.13) v16(39.71,101) v16(39.72,92.6) v16(40.05,89.45) v16(40.29,109.38) v16(40.73,107.63) v16(41.12,96.82) v16(42.45,109.39) v16(42.47,101.01) v16(42.5,99.59) v16(42.47,93.98) v16(42.45,92.61) v16(43.19,115.04) v16(43.21,109.37) v16(43.2,108) v16(43.19,106.59) v16(43.55,113.25) v16(43.92,109.4) v16(43.92,108) v16(43.86,93.97) v16(43.9,92.61) v16(44.58,113.6) v16(44.58,108) v16(44.58,100.99) v16(44.62,99.62) v16(44.58,98.22) v16(45.25,109.36) v16(45.32,107.99) v16(45.28,100.98) v16(45.3,99.59) v16(45.3,98.17) v16(45.98,107.98) v16(46.7,109.39) v16(46.7,107.99) v16(47.39,107.98) v16(47.38,102.4) v16(47.4,101.01) v16(47.42,99.58) v16(47.38,98.21) v16(48.1,109.38) v16(48.11,107.98) v16(48.1,102.37) v16(48.1,100.99) v16(48.08,98.2) v16(48.79,108) v16(49.18,113.88) v16(49.5,109.37) v16(49.51,107.99) v16(49.85,106.22) v16(49.85,101.37) v16(49.84,97.82) v16(50.2,107.99) v16(50.23,102.39) v16(50.2,99.61) v16(50.23,96.82) v16(52.57,108.64) v16(53.27,108.65) v16(54.3,111.05) v16(54.33,110.36) v16(54.37,109.69) v16(54.98,111.73) v16(55.01,111.06) v16(55.51,111.76) v16(55.61,111.06) v16(87.4,75.77) v16(87.45,74.48) v16(88.01,81.69) v16(92.53,88.6) v16(93.01,86.82) v16(92.99,62.41) v16(93.09,61.06) v16(93.47,58.45) v16(93.57,86.18) v16(94.13,88.09) v16(94.13,63.48) v16(94.11,62.36) v16(94.11,61.78) v16(94.13,60.68) v16(94.11,60.12) v16(94.13,59.54) v16(94.11,58.37) v16(94.64,87.78) v16(95.96,42.62) v16(96.57,42.29) v16(97.43,87.53) v16(97.54,65.53) v16(97.51,42.5) v16(97.87,60.96) v16(97.97,63.25) v16(98.04,59.31) v16(98.17,89.89) v16(98.27,69.95) v16(98.81,89.11) v16(99.03,66.75) v16(98.98,65.1) v16(99.09,69.22) v16(101.68,67.26) v16(101.75,70.79) v16(101.83,65.92) v16(101.9,65) v16(102.16,91.59) v16(102.79,65.86) v16(102.95,90.32) v16(102.97,90.96) v16(105.69,90.91) v16(105.69,90.32) v16(108.43,90.93) v16(108.46,90.25) v16(109.52,70.56) v16(109.52,69.65) v16(109.52,64.95) v16(109.55,71.25) v16(110.74,50.07) v16(111.2,90.93) v16(111.2,90.25) v16(111.44,45.72) v16(111.46,50.04) v16(111.58,46.43) v16(111.73,63.99) v16(112.6,70.72) v16(117.47,90.27) v16(118.95,90.38) v16(119.35,89.33) v16(119.35,87.15) v16(119.89,86.26) v16(120.9,86.74) v16(122.43,86.54) v16(123.47,85.42) v16(123.83,85.75) v16(123.9,69.85) v16(125.04,70.59) v16(124.97,69.9) v16(124.97,69.14) v16(125.07,71.3) v16(127.61,90.99) v16(127.64,90.38) v16(127.61,69.14) v16(128.99,84.8) v16(130.38,91.01) v16(130.38,90.32) v16(133.4,67.76) v16(136.04,90.48) v16(137.39,90.99) v16(138.02,65.97) v16(138.1,65.15) v16(138.68,66.17) v16(138.73,65.53) v16(143.13,59.16) v16(143.15,64.37) v16(143.15,63.73) v16(143.18,63.17) v16(143.18,62.61) v16(143.15,62.03) v16(143.15,61.45) v16(143.15,60.91) v16(143.18,60.28) v16(143.18,59.77) v16(143.15,58.6) v18(3.05,63.19) v18(3.77,60.85) v18(3.86,58.66) v18(4.29,59.76) v18(6.46,5.44) v18(7.06,6.36) v18(7.41,84.43) v18(9.58,39.91) v18(9.58,38.95) v18(11.82,46.64) v18(14.86,54.64) v18(18.72,49.56) v18(20.58,8.2) v18(21.45,42.67) v18(22.67,58.96) v18(23.89,58.96) v18(25.12,134.21) v18(25.12,58.96) v18(25.29,140.41) v18(25.3,128.99) v18(25.3,127.38) v18(25.3,125.9) v18(25.39,139.65) v18(26.7,108.89) v18(26.7,105.34) v18(26.7,97.97) v18(26.7,96.19) v18(26.86,86.07) v18(26.86,84.86) v18(27.22,139.17) v18(28.21,141) v18(29.35,84.78) v18(29.64,142.43) v18(29.86,140.22) v18(29.86,138.83) v18(29.98,140.97) v18(30.04,139.91) v18(30.04,138.51) v18(30.04,97.34) v18(30.04,96.77) v18(30.04,96.14) v18(30.04,95.5) v18(30.04,94.93) v18(30.04,93.6) v18(30.04,92.96) v18(30.04,92.07) v18(30.04,91.44) v18(30.21,140.22) v18(30.21,138.83) v18(30.45,111.21) v18(30.73,93.84) v18(30.95,138.75) v18(31.13,138.43) v18(31.15,111.21) v18(31.22,110.33) v18(31.22,109.06) v18(31.31,138.75) v18(31.47,146.64) v18(31.72,111.21) v18(32.1,114.81) v18(32.29,111.21) v18(32.8,109.69) v18(32.8,109.06) v18(32.8,108.42) v18(32.8,107.79) v18(32.8,106.52) v18(32.8,105.25) v18(32.8,103.34) v18(32.8,102.71) v18(33.15,148.4) v18(33.49,139.46) v18(33.67,139.14) v18(33.85,139.46) v18(35.53,90.85) v18(36.84,136.99) v18(37.62,114.8) v18(40.04,114.8) v18(42.32,114.8) v18(42.82,66.48) v18(44.99,114.8) v18(47.66,114.8) v18(48.16,111.87) v18(49.16,65.78) v18(49.86,128.83) v18(50.41,3.45) v18(50.9,31.82) v18(51.05,17.57) v18(51.59,30.04) v18(51.75,151.32) v18(52.27,39.74) v18(52.68,88.41) v18(52.79,89.3) v18(53.19,39.74) v18(53.53,16.22) v18(53.53,11.78) v18(53.59,96.21) v18(53.75,19.71) v18(54.28,39.42) v18(54.48,106.45) v18(54.84,88.8) v18(54.84,88.23) v18(54.8,16.22) v18(54.8,11.78) v18(54.91,1.5) v18(55.31,87.34) v18(55.52,39.41) v18(55.82,106.45) v18(56.07,16.22) v18(56.07,11.78) v18(56.26,96.73) v18(56.32,95.42) v18(56.76,39.21) v18(57.34,96.55) v18(57.4,95.6) v18(57.98,39.18) v18(58.85,148.4) v18(59.5,130.71) v18(59.5,130.39) v18(59.5,130.08) v18(59.5,129.76) v18(59.5,129.44) v18(59.66,89.29) v18(59.66,86.6) v18(59.71,1.5) v18(59.82,114.11) v18(60.45,114.11) v18(60.77,20.16) v18(60.9,101.44) v18(60.9,98.77) v18(60.96,104.1) v18(60.97,89.05) v18(61.09,114.11) v18(61.72,114.11) v18(61.81,3.45) v18(61.95,64.99) v18(61.95,63.61) v18(61.95,62.22) v18(61.98,20.16) v18(62.14,143.36) v18(62.36,114.11) v18(62.64,142.53) v18(62.64,141.52) v18(62.67,86.85) v18(62.81,142.03) v18(62.93,148.68) v18(62.93,147.22) v18(62.93,145.51) v18(63.02,142.53) v18(63.02,141.52) v18(62.99,114.11) v18(63.13,33.17) v18(63.18,20.16) v18(63.44,150.08) v18(63.44,91.34) v18(63.63,114.11) v18(63.94,28.54) v18(64.14,33.23) v18(64.34,8.92) v18(64.39,20.16) v18(64.39,15.28) v18(64.52,91.65) v18(64.5,29.68) v18(64.55,102.58) v18(64.55,102.01) v18(64.55,101.44) v18(64.55,100.87) v18(64.55,100.29) v18(64.58,7.84) v18(64.62,4.05) v18(64.72,99.53) v18(64.72,98.58) v18(64.9,143.73) v18(64.96,104.8) v18(64.96,103.53) v18(65.15,150.08) v18(65.48,77.65) v18(65.53,15.65) v18(65.6,20.16) v18(65.77,98.82) v18(66,84.32) v18(66,83.31) v18(66,82.29) v18(66,81.28) v18(66,80.26) v18(66.13,30.53) v18(66.17,115.79) v18(66.36,91.65) v18(66.48,8.78) v18(66.62,147.39) v18(66.57,103.13) v18(66.71,77.29) v18(66.67,15.41) v18(66.84,74.08) v18(66.87,98.15) v18(66.87,90.3) v18(66.97,138.85) v18(67.31,91.65) v18(67.43,115.75) v18(67.44,8.78) v18(67.61,150.13) v18(67.62,146.04) v18(67.94,143.73) v18(67.94,98.15) v18(67.94,77.24) v18(68.5,147.73) v18(68.5,145.74) v18(68.45,8.78) v18(69.16,77.23) v18(69.28,150.08) v18(69.28,15.41) v18(69.74,92.23) v18(69.76,88.26) v18(69.9,98.64) v18(69.95,7.42) v18(70.1,82.07) v18(70.17,10.18) v18(70.29,94.78) v18(70.4,77.22) v18(70.42,59.53) v18(70.45,7.42) v18(70.68,150.01) v18(70.85,91.34) v18(70.95,7.42) v18(70.98,87.62) v18(71.06,143.73) v18(71.2,96.74) v18(71.37,104.8) v18(71.45,95.79) v18(71.45,77.28) v18(71.63,63.83) v18(71.68,9.36) v18(71.91,92.55) v18(72.01,149.82) v18(72.26,148.05) v18(72.26,145.82) v18(72.45,7.42) v18(72.69,63.14) v18(72.95,7.42) v18(72.96,60.31) v18(73.34,90.43) v18(73.45,7.42) v18(73.6,139.03) v18(73.66,143.98) v18(73.66,142.52) v18(73.66,140.81) v18(73.79,66.74) v18(73.94,91.66) v18(74.27,39.04) v18(74.42,66.74) v18(74.61,9.3) v18(74.89,146.64) v18(74.89,144.8) v18(74.89,143.88) v18(74.89,142.04) v18(74.89,138.36) v18(74.89,137.9) v18(75.23,62.19) v18(75.25,58.71) v18(75.23,17.69) v18(75.59,145.1) v18(75.59,144.45) v18(75.59,143.8) v18(75.59,143.15) v18(75.59,142.5) v18(75.59,141.85) v18(75.59,141.2) v18(75.59,140.55) v18(75.59,139.9) v18(75.59,139.25) v18(75.59,138.6) v18(75.68,94.49) v18(75.77,90.33) v18(76.02,59.7) v18(76.08,63.45) v18(76.24,143.8) v18(76.24,142.5) v18(76.24,141.2) v18(76.16,17.69) v18(76.73,137.9) v18(76.89,146.4) v18(76.89,143.8) v18(76.89,141.2) v18(76.89,140.55) v18(76.89,139.25) v18(77.22,61.8) v18(77.54,146.4) v18(77.54,145.75) v18(77.54,145.1) v18(77.54,144.45) v18(77.54,140.55) v18(77.54,139.9) v18(77.65,137.9) v18(77.88,33.81) v18(78.19,146.4) v18(78.19,145.75) v18(78.19,144.45) v18(78.19,140.55) v18(78.19,139.9) v18(78.57,137.9) v18(78.84,146.4) v18(78.84,144.45) v18(78.84,140.55) v18(78.84,139.25) v18(78.84,138.6) v18(78.81,56.08) v18(78.78,4.05) v18(79.53,149.25) v18(79.49,147.1) v18(79.49,146.4) v18(79.49,144.45) v18(79.49,142.5) v18(79.49,137.9) v18(79.64,23.59) v18(79.9,8.46) v18(80.14,146.4) v18(80.14,145.75) v18(80.14,142.5) v18(80.09,26.89) v18(80.73,149.25) v18(80.71,57.38) v18(80.79,146.4) v18(80.79,145.75) v18(80.79,145.1) v18(80.79,140.55) v18(80.79,139.9) v18(80.96,63.39) v18(81,9.21) v18(81.22,28.84) v18(81.23,14.12) v18(81.23,13.11) v18(81.32,5.87) v18(81.44,146.4) v18(81.44,145.75) v18(81.44,143.8) v18(81.44,140.55) v18(81.44,139.9) v18(81.85,11.58) v18(82.09,146.4) v18(82.09,145.75) v18(82.09,145.1) v18(82.09,140.55) v18(82.09,139.9) v18(82.25,137.9) v18(82.27,10.67) v18(82.52,149.25) v18(82.74,146.4) v18(82.74,145.75) v18(82.74,145.1) v18(82.74,143.8) v18(82.74,141.85) v18(82.74,141.2) v18(82.74,132.18) v18(82.98,15.58) v18(83.39,145.75) v18(83.44,42.78) v18(83.68,135.11) v18(84.09,147.1) v18(84.09,143.42) v18(84.09,142.5) v18(84.09,141.58) v18(84.09,140.66) v18(84.37,39.18) v18(84.55,147.56) v18(84.51,34.88) v18(84.74,40.88) v18(85.67,37.28) v18(86.01,50.07) v18(86.09,24.62) v18(87.01,24.68) v18(87.06,132.03) v18(87.21,145.11) v18(87.21,141.3) v18(87.21,140.67) v18(87.21,140.03) v18(87.21,137.37) v18(87.31,23.52) v18(87.71,47.87) v18(87.67,27.54) v18(87.85,145.76) v18(87.85,145.13) v18(87.89,24.68) v18(88.01,132.03) v18(88.76,24.67) v18(88.93,141.84) v18(88.93,140.95) v18(88.93,140.06) v18(88.93,139.17) v18(88.95,46.68) v18(89.03,17.92) v18(89.2,145.11) v18(89.2,144.22) v18(89.81,140.38) v18(89.81,139.79) v18(89.81,139.16) v18(90.34,62.8) v18(90.34,61.91) v18(90.27,58.99) v18(90.27,58.1) v18(90.42,147.54) v18(90.44,65.37) v18(90.54,22.84) v18(91,149.07) v18(91,147.53) v18(90.97,142.92) v18(91.1,65.39) v18(91.24,142.08) v18(91.17,139.92) v18(91.44,145.63) v18(91.43,22.84) v18(91.59,142.84) v18(91.59,65.39) v18(92.25,63.83) v18(92.25,58.08) v18(92.81,22.84) v18(93.04,145.7) v18(93.74,145.57) v18(93.69,143.62) v18(93.69,138.62) v18(93.87,31.61) v18(94.11,57.25) v18(94.37,146.19) v18(94.37,145.57) v18(94.35,21.29) v18(95.05,70.69) v18(95.05,68.91) v18(95.05,66.22) v18(95.11,73.43) v18(95.11,72.34) v18(95.06,64.47) v18(95.06,57.25) v18(95.2,142.12) v18(95.19,61.9) v18(95.17,61.04) v18(95.17,58.34) v18(95.56,151.92) v18(95.7,142.12) v18(95.7,141.62) v18(95.7,141.12) v18(95.7,140.62) v18(95.95,56.96) v18(96.2,141.62) v18(96.2,141.12) v18(96.2,140.62) v18(96.58,56.96) v18(96.7,141.62) v18(96.7,141.12) v18(96.7,140.62) v18(96.96,106) v18(97.22,145.54) v18(97.2,142.12) v18(97.2,141.62) v18(97.2,141.12) v18(97.2,140.62) v18(97.2,140.12) v18(97.2,139.12) v18(97.2,69.45) v18(97.22,56.96) v18(97.34,17.55) v18(97.66,63.53) v18(97.93,92.15) v18(97.93,91.57) v18(97.85,56.96) v18(97.98,145.54) v18(98,67.85) v18(98.05,151.92) v18(98.1,148.87) v18(98.37,90.32) v18(98.36,64.48) v18(98.4,17.68) v18(98.49,56.96) v18(98.55,145.54) v18(98.7,143.62) v18(98.81,18.6) v18(99.12,56.96) v18(99.38,145.58) v18(99.58,148.87) v18(99.76,56.96) v18(100.27,147.44) v18(101.02,23.27) v18(101.02,22.32) v18(101.54,145.44) v18(101.56,18.98) v18(101.89,141.63) v18(102,67.85) v18(102.44,147.79) v18(102.81,139.79) v18(102.8,71.05) v18(102.84,14.07) v18(103.37,23.84) v18(103.6,59.05) v18(104.01,139.79) v18(104.17,73.41) v18(104.27,15.66) v18(104.27,13.16) v18(105.22,145.39) v18(105.22,139.79) v18(105.59,70.6) v18(105.6,69.45) v18(105.6,65.34) v18(105.59,60.97) v18(105.59,58.28) v18(105.66,61.84) v18(106,19.19) v18(106.06,23.84) v18(106.43,139.79) v18(107.43,73.41) v18(107.63,139.79) v18(107.6,69.45) v18(107.65,19.19) v18(108.14,64.35) v18(108.39,73.41) v18(108.4,71.05) v18(108.4,67.85) v18(108.4,66.25) v18(108.55,142.66) v18(108.54,19.19) v18(109.42,19.19) v18(109.37,13.16) v18(109.87,143.72) v18(109.91,137.63) v18(110.74,85.44) v18(111.6,15.49) v18(111.7,13.82) v18(111.7,11.13) v18(112.13,73.41) v18(112.4,67.85) v18(112.65,13.82) v18(112.65,11.13) v18(112.97,85.42) v18(113.2,71.05) v18(113.2,70.25) v18(113.47,73.41) v18(114,67.85) v18(114,67.05) v18(114.01,63.86) v18(115.05,15.65) v18(115.13,85.37) v18(116.07,71.49) v18(116.08,70.34) v18(116.07,68.21) v18(117.02,64.82) v18(116.96,62.81) v18(117.26,12.41) v18(117.86,23.08) v18(118.71,137.77) v18(119,58.59) v18(119.13,29.57) v18(119.44,92.12) v18(119.82,73.41) v18(119.94,16.5) v18(120.02,29.57) v18(120.28,13.05) v18(120.28,12.16) v18(120.28,11.27) v18(120.53,40.08) v18(120.75,140.43) v18(120.89,73.41) v18(121.02,71.95) v18(121.02,71.31) v18(121.03,69.64) v18(121.02,67.96) v18(121.02,65.6) v18(121.02,64.83) v18(121.02,60.71) v18(122.04,49.48) v18(122.05,55.13) v18(122.73,41.11) v18(123.1,69.45) v18(123.1,65.45) v18(123.1,63.85) v18(123.1,61.45) v18(123.32,27.66) v18(123.9,71.05) v18(124.27,27.94) v18(125.11,14.43) v18(125.73,85.36) v18(125.91,89.1) v18(126.55,124.29) v18(126.63,27.89) v18(126.94,135.3) v18(126.95,13.19) v18(127.32,64.73) v18(127.52,27.89) v18(127.69,56.96) v18(127.9,67.85) v18(128.08,12.23) v18(128.33,85.5) v18(128.27,64.29) v18(128.27,23.98) v18(128.41,27.89) v18(128.56,137.81) v18(128.7,70.25) v18(128.84,151.22) v18(128.85,14.49) v18(128.97,12.23) v18(129.53,73.41) v18(129.5,67.85) v18(129.5,61.45) v18(129.6,137.76) v18(129.92,56.96) v18(129.94,17.07) v18(129.92,14.81) v18(130.1,25.49) v18(130.37,13.31) v18(130.37,10.18) v18(130.95,17.07) v18(131.06,151.64) v18(131.32,13.31) v18(131.25,10.18) v18(131.46,73.41) v18(131.5,71.06) v18(131.5,62.81) v18(131.5,60.71) v18(131.5,58.67) v18(131.5,48.22) v18(131.82,16.11) v18(131.93,20.11) v18(132.74,51.46) v18(132.76,56.86) v18(133.22,52.66) v18(133.18,43.28) v18(133.18,41.56) v18(133.16,15.53) v18(133.5,61.45) v18(134.05,18.31) v18(134.14,57.05) v18(134.24,63.46) v18(134.18,52.66) v18(134.3,71.05) v18(134.62,14.12) v18(135,123.74) v18(135.41,57.05) v18(135.43,49.75) v18(135.43,48.86) v18(135.89,35.74) v18(136.02,123.74) v18(136.08,85.5) v18(136.08,34.52) v18(136.19,40.29) v18(136.39,35.74) v18(136.84,33.61) v18(137.01,129.38) v18(137.22,57.02) v18(137.54,64.67) v18(137.85,73.41) v18(138.18,136.3) v18(138.23,14.63) v18(138.3,67.85) v18(138.48,55.93) v18(138.71,27.21) v18(139.1,70.25) v18(139.13,37.23) v18(139.9,67.85) v18(139.9,63.85) v18(139.88,34.67) v18(140.18,38.19) v18(140.4,28.04) v18(140.9,103.23) v18(141.06,136.26) v18(141.66,73.41) v18(141.8,55.65) v18(141.81,51.27) v18(141.86,64.06) v18(141.98,71.18) v18(142.47,67.08) v18(142.47,65.56) v18(142.62,56.62) v18(142.92,139.11) v18(142.89,66.32) v18(143.13,55.65) v18(143.12,51.26) v18(143.51,56.62) v18(143.89,48.61) v18(144.54,104.45) v18(144.84,143.55) v18(144.84,137.06) v18(145.05,42.68) v18(145.22,58.08) v18(145.35,51.96) v18(149.05,129.5) v18(149.05,128.68) v18(149.56,135.66) v18(150.29,128.81)
